# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BASE_DDC_CLK: length 1.5
  TOP w0.119: RV7.2 130.01,110.96 UV1.33
BASE_DDC_DTA: length 1.5
  TOP w0.119: UV1.34 130.12,111.46 RV5.2
BASE_DP_AUXN: length 1.6
  TOP w0.119: CV13.2 130.09,109.13 129.53,109.13 129.36,108.96 UV1.29
BASE_DP_AUXP: length 1.5
  TOP w0.119: CV12.2 130.04,109.39 129.43,109.39 129.36,109.46 UV1.30
BASE_DP_CAD: length 88.4
  TOP w0.119: UV1.8 121.21,108.96 120.63,108.38 120.63,108.03 120.08,107.48 118.88,107.48 118.17,106.76 118.17,105.21 120.11,103.26 120.29,103.26 v1(120.4,103.15)
  IN1 w0.084: v2(122.71,103.22) 122.63,103.29 120.54,103.29 v1(120.4,103.15)
  IN2 w0.079: v2(119.05,95.1) 119.09,95.1 121.29,97.3 121.29,101.48 122.24,102.43 122.5,102.43 122.71,102.63 v2(122.71,103.22)
  IN3 w0.084: v7(60.32,94.66) 60.32,94.63 v3(61.89,93.07)
  GND3 w0.084: v2(119.05,95.1) 119.38,95.43 v8(119.81,95.43)
  IN4 w0.089: v3(61.89,93.07) 61.99,92.96 79.41,92.96 79.89,93.44 81.36,93.44 82.6,94.67 85.82,94.67 86.8,95.65 95.87,95.65 96.61,96.39 98.3,96.39 98.72,96.8 100.7,96.8 101.66,95.84 118.64,95.84 118.72,95.76 119.48,95.76 v8(119.81,95.43)
  BOTTOM w0.119: v7(60.32,94.66) 60.2,94.66 60,94.86 59.76,94.86 59.69,94.79 58.41,94.79 58.28,94.92 R468.1 58.26,95.16 U47.33
BASE_DP_CLK_AUXP: length 88.1
  TOP w0.119: v1(130.8,109.57) 130.89,109.57 131.04,109.72 131.04,110.52 RV7.1
  IN1 w0.109: v2(130.78,107.95) 130.9,108.07 131.17,108.07 131.45,108.35 131.45,109.02 130.9,109.57 v1(130.8,109.57)
  IN2 w0.079: v2(63.53,96.24) 63.63,96.24 63.96,95.91 76.31,95.91 76.69,96.29 76.69,98.01 84.22,105.54 85.48,105.54 85.86,105.92 87.76,105.92 88.21,106.37 90.58,106.37 91.16,106.96 95.52,106.96 97.95,104.54 104.63,104.54 105.38,103.79 112.55,103.79 122.6,113.83 128.16,113.83 131.34,110.65 131.34,108.33 131.12,108.1 130.93,108.1 v2(130.78,107.95)
  IN3 w0.084: v2(63.53,96.24) 63.26,95.98 63.26,95.95 63.06,95.75 v7(62.85,95.75)
BASE_DP_CLK_AUXP_R: length 3.8
  BOTTOM w0.119: R462.1 62.27,95.96 62.1,96.13 61.86,96.13 R458.1 61.19,96.55 61.1,96.64 61.1,97.18 60.46,97.82 U47.28
BASE_DP_DAT_AUXN: length 88.9
  TOP w0.119: RV5.1 131.3,110.87 131.3,109.61 131.17,109.47 131.17,109.29 130.89,109.01 v1(130.8,109.01)
  IN1 w0.109: v2(130.76,108.5) 130.76,108.42 130.88,108.3 131.07,108.3 131.22,108.44 131.22,108.92 130.97,109.17 130.85,109.17 130.8,109.12 v1(130.8,109.01)
  IN2 w0.079: v2(130.76,108.5) 130.76,108.4 130.89,108.28 131.04,108.28 131.16,108.4 131.16,110.57 128.09,113.65 122.67,113.65 112.63,103.6 105.3,103.6 104.55,104.35 97.87,104.35 95.45,106.78 91.24,106.78 90.65,106.19 88.29,106.19 87.83,105.73 85.94,105.73 85.56,105.35 84.3,105.35 76.87,97.93 76.87,96.22 76.38,95.73 63.88,95.73 63.7,95.9 63.6,95.9 63.5,95.8 v2(63.5,95.7)
  IN3 w0.084: v2(63.5,95.7) 63.69,95.51 63.69,95.33 63.55,95.19 v7(62.85,95.19)
BASE_DP_DAT_AUXN_R: length 3.8
  BOTTOM w0.119: R467.1 62.23,95.19 61.63,95.79 R466.1 61.59,95.9 61.3,96.2 61.2,96.2 61.19,96.2 61.17,96.2 60.84,96.53 60.84,97.07 60.49,97.42 U47.29
BASE_DP_HPD: length 90
  TOP w0.119: v1(120.42,103.55) 120.14,103.55 118.39,105.3 118.39,106.67 118.97,107.25 120.17,107.25 120.85,107.94 120.85,108.29 121.02,108.46 UV1.9
  IN1 w0.084: v1(120.42,103.55) 120.5,103.62 122.88,103.62 v2(123.27,103.24)
  IN2 w0.079: v2(119.66,94.91) 119.66,95.29 121.48,97.11 121.48,101.4 122.32,102.24 122.58,102.24 123.27,102.93 v2(123.27,103.24)
  IN3 w0.084: v3(61.41,93.07) 61.41,93.19 60.03,94.57 v7(59.88,94.57)
  GND3 w0.084: v8(120.05,95.14) 119.82,94.91 v2(119.66,94.91)
  IN4 w0.089: v3(61.41,93.07) 61.71,92.76 80.96,92.76 82.68,94.48 85.9,94.48 86.88,95.46 95.95,95.46 96.69,96.2 98.38,96.2 98.8,96.61 100.62,96.61 101.63,95.6 118.52,95.6 118.64,95.48 119.37,95.48 119.71,95.14 v8(120.05,95.14)
  BOTTOM w0.119: v7(59.88,94.57) 56.99,94.57 56.26,95.3 U47.38
BASE_DP_N0: length 98.5
  IN1 w0.109: v2(127.32,112.26) 127.38,112.26 127.51,112.38 127.51,115.05 v1(127.29,115.27)
  IN2 w0.079: v2(56.32,93.86) 56.19,93.86 56.13,93.92 56.13,94.25 55.96,94.41 55.96,95.2 56.5,95.74 59.58,95.74 59.95,95.38 62.95,95.38 63.18,95.16 76.83,95.16 77.5,95.82 77.5,97.75 84.53,104.78 85.93,104.78 86.3,105.15 88.06,105.15 88.51,105.6 90.89,105.6 91.38,106.09 95.33,106.09 97.64,103.77 99.48,103.77 102.28,100.98 104.42,100.98 106.7,98.69 114.44,98.69 114.82,99.06 114.82,104.38 123.48,113.05 127.33,113.05 127.51,112.86 127.51,112.33 127.44,112.26 v2(127.32,112.26)
  IN3 w0.084: v7(55.98,95.52) 55.89,95.52 55.78,95.4 55.78,94.51 56.07,94.23 56.07,94.06 56.27,93.86 v2(56.32,93.86)
  BOTTOM w0.119: v7(55.98,95.52) 55.89,95.52 55.79,95.62 55.79,95.74 55.86,95.8 U47.39
BASE_DP_N0_C: length 1.7
  TOP w0.119: CV7.2 127.42,114.55 127.42,114.25 127.13,113.96 127.13,113.78 126.97,113.62 UV1.39
BASE_DP_N1: length 95.4
  IN1 w0.109: v2(126.13,112.03) 126.2,112.03 126.33,112.16 126.33,115.07 v1(126.12,115.28)
  IN2 w0.079: v2(57.02,94.69) 56.79,94.69 56.64,94.84 56.64,95.03 56.76,95.15 59.37,95.15 59.71,94.81 62.6,94.81 62.84,94.57 77.05,94.57 78.06,95.59 78.06,97.51 84.74,104.19 86.22,104.19 86.6,104.57 88.33,104.57 88.79,105.02 95.58,105.02 97.41,103.2 99.24,103.2 102.17,100.28 102.68,100.28 103.81,99.14 104.08,99.14 104.49,99.55 104.6,99.55 104.82,99.33 104.82,99.22 104.41,98.81 104.41,98.54 104.83,98.12 114.69,98.12 115.42,98.85 115.42,104.17 123.67,112.43 126.21,112.43 126.31,112.33 126.31,112.14 126.2,112.03 v2(126.13,112.03)
  IN3 w0.084: v2(57.02,94.69) 56.78,94.69 56.65,94.82 56.65,94.93 56.9,95.18 56.9,95.32 57.03,95.44 v7(57.05,95.44)
  BOTTOM w0.119: U47.36 57.06,95.86 56.96,95.76 56.96,95.53 v7(57.05,95.44)
BASE_DP_N1_C: length 2
  TOP w0.119: CV5.2 126.14,114.69 126.28,114.55 126.28,114.4 126.15,114.27 125.89,114.27 125.58,113.97 125.58,113.84 125.47,113.72 UV1.42
BASE_DP_N2: length 93.2
  IN1 w0.109: v1(124.91,115.29) 125.11,115.1 125.11,111.48 124.97,111.34 v2(124.93,111.34)
  IN2 w0.079: v2(57.93,94.05) 57.82,94.05 57.77,94.1 57.77,94.19 57.73,94.23 57.68,94.23 57.61,94.29 57.61,94.43 57.75,94.56 59.12,94.56 59.44,94.24 62.35,94.24 62.61,93.99 77.27,93.99 78.63,95.35 78.63,97.28 84.85,103.49 86.39,103.49 86.89,103.99 88.78,103.99 89.14,104.35 95.45,104.35 97.17,102.63 98.82,102.63 101.92,99.53 102.18,99.53 103.72,97.99 103.72,97.71 104.09,97.35 114.74,97.35 116,98.61 116,103.92 123.8,111.72 125,111.72 125.09,111.62 125.09,111.51 v2(124.93,111.34)
  IN3 w0.084: v2(57.93,94.05) 57.87,94.05 57.81,94.11 57.81,94.2 57.76,94.25 57.67,94.25 57.55,94.37 57.55,94.48 57.82,94.75 57.82,95.47 v7(57.94,95.6)
  BOTTOM w0.119: U47.34 57.86,95.68 v7(57.94,95.6)
BASE_DP_N2_C: length 2.2
  TOP w0.119: CV3.2 125.06,114.56 125.06,114.25 125,114.19 124.54,114.19 123.97,113.62 UV1.45
BASE_DP_N3: length 92.5
  IN1 w0.109: v2(123.69,110.07) 123.75,110.07 123.89,110.21 123.89,115.06 v1(123.66,115.29)
  IN2 w0.079: v2(58.76,93.58) 58.61,93.58 58.51,93.68 58.51,93.89 58.59,93.97 58.9,93.97 59.2,93.68 62.1,93.68 62.42,93.35 77.44,93.35 79.2,95.12 79.2,97.04 85.03,102.86 86.65,102.86 87.21,103.42 89.14,103.42 89.48,103.77 95.23,103.77 97.38,101.62 98.96,101.62 103.88,96.69 114.94,96.69 116.59,98.35 116.59,103.57 123.5,110.48 123.82,110.48 123.91,110.39 123.91,110.23 123.75,110.07 v2(123.69,110.07)
  IN3 w0.084: v7(59.06,95.57) 59.01,95.57 58.92,95.47 58.92,95.25 58.61,94.94 58.61,94.15 58.5,94.04 58.5,93.73 58.64,93.58 v2(58.76,93.58)
  BOTTOM w0.119: v7(59.06,95.57) 58.94,95.69 58.94,95.76 59.06,95.87 U47.31
BASE_DP_N3_C: length 2.5
  TOP w0.119: UV1.48 122.47,113.69 122.58,113.81 122.58,114.09 122.8,114.3 123.61,114.3 123.8,114.48 123.8,114.56 CV1.2
BASE_DP_P0: length 98.5
  IN1 w0.109: v2(127.85,112.26) 127.74,112.37 127.74,115.13 v1(127.88,115.27)
  IN2 w0.079: v2(55.78,93.86) 55.94,94.02 55.94,94.17 55.78,94.34 55.78,95.28 56.43,95.93 59.66,95.93 60.02,95.57 63.03,95.57 63.26,95.34 76.75,95.34 77.31,95.9 77.31,97.83 84.45,104.97 85.85,104.97 86.22,105.34 87.98,105.34 88.43,105.79 90.82,105.79 91.3,106.28 95.4,106.28 97.72,103.96 99.56,103.96 102.36,101.16 104.49,101.16 106.78,98.87 114.37,98.87 114.63,99.13 114.63,104.46 123.4,113.23 127.41,113.23 127.7,112.94 127.7,112.41 v2(127.85,112.26)
  IN3 w0.084: v2(55.78,93.86) 55.9,93.98 55.9,94.16 55.62,94.45 55.62,95.44 v7(55.53,95.52)
  BOTTOM w0.119: U47.40 55.46,95.89 55.53,95.82 v7(55.53,95.52)
BASE_DP_P0_C: length 1.7
  TOP w0.119: CV8.2 127.69,114.49 127.69,114.15 127.39,113.85 127.39,113.77 127.47,113.69 UV1.38
BASE_DP_P1: length 95.4
  IN1 w0.109: v1(126.68,115.28) 126.56,115.15 126.56,112.14 v2(126.67,112.03)
  IN2 w0.079: v2(56.34,94.66) 56.45,94.77 56.45,95.11 56.69,95.34 59.45,95.34 59.79,95 62.67,95 62.92,94.76 76.97,94.76 77.88,95.67 77.88,97.59 84.66,104.37 86.14,104.37 86.52,104.75 88.25,104.75 88.71,105.21 95.66,105.21 97.48,103.39 99.32,103.39 102.24,100.46 102.75,100.46 103.89,99.33 104,99.33 104.41,99.73 104.67,99.73 105.01,99.4 105.01,99.14 104.6,98.73 104.6,98.62 104.91,98.3 114.61,98.3 115.23,98.92 115.23,104.25 123.6,112.61 126.29,112.61 126.5,112.4 126.5,112.2 v2(126.67,112.03)
  IN3 w0.084: v7(56.66,95.44) 56.74,95.37 56.74,95.25 56.48,95 56.48,94.8 v2(56.34,94.66)
  BOTTOM w0.119: v7(56.66,95.44) 56.7,95.48 56.7,95.79 56.66,95.82 U47.37
BASE_DP_P1_C: length 2
  TOP w0.119: UV1.41 125.97,113.66 125.85,113.78 125.85,113.86 126,114.01 126.26,114.01 126.54,114.29 126.54,114.55 CV6.2
BASE_DP_P2: length 93.3
  IN1 w0.109: v1(125.47,115.29) 125.34,115.15 125.34,111.47 v2(125.46,111.34)
  IN2 w0.079: v2(125.46,111.34) 125.3,111.51 125.3,111.68 125.08,111.9 123.72,111.9 115.82,104 115.82,98.69 114.66,97.53 104.16,97.53 103.91,97.79 103.91,98.06 102.25,99.72 102,99.72 98.9,102.82 97.25,102.82 95.53,104.54 89.06,104.54 88.7,104.17 86.81,104.17 86.32,103.68 84.77,103.68 78.45,97.35 78.45,95.43 77.19,94.17 62.69,94.17 62.43,94.43 59.52,94.43 59.2,94.75 57.67,94.75 57.43,94.5 57.43,94.13 v2(57.36,94.06)
  IN3 w0.084: v2(57.36,94.06) 57.39,94.1 57.39,94.55 57.66,94.82 57.66,95.47 v7(57.56,95.57)
  BOTTOM w0.119: v7(57.56,95.57) 57.56,95.72 57.46,95.82 U47.35
BASE_DP_P2_C: length 2.2
  TOP w0.119: CV4.2 125.32,114.55 125.32,114.14 125.11,113.93 124.64,113.93 124.42,113.7 124.42,113.6 124.47,113.55 UV1.44
BASE_DP_P3: length 92.6
  IN1 w0.109: v1(124.25,115.29) 124.12,115.15 124.12,110.18 v2(124.22,110.07)
  IN2 w0.079: v2(124.22,110.07) 124.09,110.2 124.09,110.47 123.89,110.67 123.43,110.67 116.41,103.65 116.41,98.42 114.86,96.88 103.96,96.88 99.04,101.8 97.46,101.8 95.31,103.95 89.41,103.95 89.06,103.6 87.13,103.6 86.58,103.05 84.95,103.05 79.02,97.12 79.02,95.19 77.36,93.54 62.5,93.54 62.18,93.86 59.27,93.86 58.98,94.15 58.51,94.15 58.32,93.97 58.32,93.72 v2(58.18,93.57)
  IN3 w0.084: v7(58.66,95.57) 58.75,95.48 58.75,95.31 58.45,95.01 58.45,94.22 58.33,94.1 58.33,93.73 v2(58.18,93.57)
  BOTTOM w0.119: v7(58.66,95.57) 58.68,95.59 58.68,95.83 58.66,95.85 U47.32
BASE_DP_P3_C: length 2.6
  TOP w0.119: CV2.2 124.06,114.51 124.06,114.37 123.72,114.04 122.91,114.04 122.85,113.98 122.85,113.79 122.97,113.68 UV1.47
BASE_SMB_ALERT#: length 123.3
  IN2 w0.079: v2(131.89,95.71) 131.89,95.81 131.83,95.87 131.83,100.59 131.46,100.96 131.46,102.32 131.66,102.52 132.73,102.52 133.14,102.94 133.14,104.51 v2(132.94,104.71)
  IN3 w0.084: v7(131.92,94.68) 131.79,94.81 131.79,95.61 v2(131.89,95.71) ; v7(193.29,140.49) 193.34,140.49 194.05,139.79 197.59,139.79 200.61,136.77 200.61,133.92 201.4,133.13 201.4,131.62 201.83,131.19 201.83,116.25 200.75,115.17 200.33,114.75 200.33,112.53 195.59,107.8 192.21,107.8 191.38,106.96 190.25,106.96 187.07,103.79 178.09,103.79 177.09,102.78 154.06,102.78 152.54,104.3 148.81,104.3 148.35,104.76 143.56,104.76 143.17,104.37 136.51,104.37 136.13,104.75 132.98,104.75 v2(132.94,104.71)
  IN4 w0.089: v5(192.82,137.24) 193.19,137.61 193.4,137.61 194,138.21 194,139.78 v7(193.29,140.49)
  BOTTOM w0.119: JIO4.46 v7(131.92,94.68)
BASE_SMBCLK: length 128.6
  IN2 w0.079: v2(131.13,95.21) 130.87,95.47 130.87,97.26 130.77,97.36 130.77,100.4 130.5,100.67 v2(130.5,102.68)
  IN3 w0.084: v7(190.91,139.25) 190.91,139.62 191.28,140 191.8,140 192.05,140.25 192.05,140.43 193.11,141.48 193.11,141.65 193.9,142.44 196.16,142.44 197.63,142.44 198.05,142.02 198.05,140.65 202.07,136.62 202.07,131.9 203,130.97 203,126.77 202.69,126.46 202.69,115.9 201.23,114.43 201.23,112.22 195.95,106.94 192.57,106.94 191.73,106.1 191.04,106.1 187.86,102.93 178.45,102.93 177.41,101.89 153.74,101.89 152.6,103.03 151.24,103.03 150.42,102.21 149.49,102.21 149.09,102.61 137.35,102.61 137.34,102.62 136.97,102.62 136.33,101.99 134.61,101.99 134.18,102.42 132.21,102.42 131.88,102.76 130.58,102.76 v2(130.5,102.68) ; v7(131.12,94.7) 131.13,94.71 v2(131.13,95.21)
  BOTTOM w0.119: U34.A9 190.77,137.79 190.77,139.11 v7(190.91,139.25) ; JIO4.50 v7(131.12,94.7)
BASE_SMBDAT: length 127.4
  IN2 w0.079: v2(132.79,103.65) 132.07,103.65 131.25,102.83 131.25,100.87 131.62,100.5 131.62,95.98 v2(131.36,95.71)
  IN3 w0.084: v2(131.36,95.71) 131.56,95.51 131.56,94.73 v7(131.52,94.7) ; v7(191.32,136.24) 191.56,136.48 191.56,136.97 191.31,137.22 191.31,138.54 191.33,138.55 191.33,139.39 191.57,139.63 191.69,139.63 192.55,140.49 v7(192.61,140.49) 192.91,140.49 193.67,141.26 193.67,141.56 194.09,141.98 197.43,141.98 197.59,141.82 197.59,140.45 201.61,136.43 201.61,131.71 202.43,130.89 202.43,126.85 202.23,126.65 202.23,116.09 200.72,114.58 200.72,112.37 195.76,107.4 192.38,107.4 191.54,106.57 190.41,106.57 187.24,103.39 178.26,103.39 177.22,102.35 153.93,102.35 152.72,103.57 150.42,103.57 150.21,103.37 136.72,103.37 136.04,102.68 135.06,102.68 134.1,103.65 v2(132.79,103.65)
  BOTTOM w0.119: JIO4.48 v7(131.52,94.7)
BAT_TAB_EN#: length 123.8
  TOP w0.119: v14(185.76,123.93) 185.65,124.04 185.65,124.41 185.11,124.96 185.11,125.77 185.23,125.9 PU200.2 v1(186.63,125.9)
  IN1 w0.084: v1(186.63,125.9) v2(186.23,125.9)
  IN2 w0.084: v2(186.23,125.9) 186.23,126 186.96,126.73 190.46,126.73 191.13,126.06 193.56,126.06 195.07,127.57 199.37,127.57 v2(199.44,127.51)
  IN3 w0.084: v10(190.82,133.24) 190.79,133.2 190.79,133.06 190.58,132.85 190.58,132.63 188.86,130.91 188.86,129.84 189.02,129.68 189.63,129.68 190.77,130.81 192.03,130.81 193.42,132.2 194.97,132.2 195.24,132.48 198.18,132.48 199.1,131.55 199.1,130.4 199.26,130.25 199.26,129.93 199.59,129.59 199.59,128.18 199.44,128.03 v2(199.44,127.51) 199.69,127.26 199.69,116.37 198.56,115.25 198.56,114.65 197.2,113.29 193.11,113.29 190.81,110.99 190.81,110.42 189.27,108.87 189.27,108.12 186.45,105.3 177.47,105.3 177.26,105.1 v7(170.97,105.1) 170.83,105.1 169.86,104.13 158.18,104.13 157.92,104.39 154.58,104.39 154.29,104.67 148.96,104.67 148.5,105.13 148.5,105.13 147.99,105.65 v3(146.83,105.65)
  IN4 w0.089: v3(146.83,105.65) 146.89,105.71 146.89,107.48 147.33,107.92 147.33,110.06 149.04,111.77 v4(149.04,111.96)
  BOTTOM w0.119: PR544.1 148.67,114.33 149.16,113.83 149.34,113.83 149.67,113.5 149.67,112.59 v4(149.04,111.96)
  BOTTOM w0.254: PQ506.2 170.43,107.3 PR557.1 171.3,107 170.97,106.67 v7(170.97,105.1)
BAT_TAB_OFF: length 73
  IN3 w0.084: v7(170.95,104.74) 177.17,104.74 177.54,105.11 186.52,105.11 189.45,108.04 189.45,108.8 192.02,111.36 192.25,111.59 197.46,111.59 198.86,112.99 198.86,115.28 199.87,116.3 199.87,127.56 199.78,127.66 199.78,129.67 199.44,130 199.44,130.33 199.29,130.48 199.29,131.63 198.25,132.66 195.16,132.66 194.89,132.39 193.34,132.39 191.95,131 190.57,131 v7(190.17,130.6)
  BOTTOM w0.119: U34.N11 189.82,131.17 190.17,130.83 v7(190.17,130.6)
  BOTTOM w0.254: v7(170.95,104.74) 171.13,104.74 171.34,104.94 171.34,106.43 172.16,107.25 172.16,110.02 171.81,110.38 PR558.2 171.18,110.38 PQ505.2
BATDRV#: length 29.9
  IN3 w0.508: 160.58,112.89 160.58,114.49 159.97,115.1 151.13,115.1 150.76,114.73 147.48,114.73 145.67,112.92 145.67,111.28 145.06,110.68 145.06,110.66 144.71,110.31 144.71,110.3 144.23,109.82 142.04,109.82 141.81,109.59 139,109.59 137.19,111.4 137.19,112.08
  vias: v7(137.06,112.94) v7(137.26,112.69) v7(160.43,112.38) v7(160.73,112.38)
BATLOW#: length 17.2
  IN3 w0.06: v10(64.44,122.03) 64.44,122.24 64.24,122.44 64.24,122.53 63.58,123.19 62.89,123.19 62.23,123.85 61.73,124.35
  IN3 w0.084: v7(51.07,129.81) 51.12,129.81 51.6,130.29 52.26,130.29 53.25,129.31 53.37,129.19 55.56,129.19 56.22,128.53 57.55,128.53 57.57,128.51 57.58,128.51 57.61,128.48 57.62,128.48 61.25,124.86 61.25,124.84 61.42,124.67 61.42,124.66 61.73,124.35
BATT_VREF: length 14.2
  TOP w0.254: PU1501.6 v1(188.79,110.71) ; PC1414.2 195.9,113.06 PR1422.1 PR1423.2 190.61,113.05 189.93,112.36 188.96,112.36 v1(188.06,111.46) 187.97,111.36 PU1501.2
  IN1 w0.254: v1(188.06,111.46) 188.06,111.45 v1(188.79,110.71)
BEEP: length 248.1
  IN4 w0.089: v4(191.32,132.24) 191.32,131.93 191.06,131.66 190.12,131.66 189.45,130.99 189.44,130.99 189.14,130.69 189.14,130.36 188.86,130.07 188.86,129.84 189.01,129.68 189.1,129.68 189.77,129.01 190.38,129.01 191.65,127.74 192.47,127.74 193.6,126.61 194.5,126.61 196.01,125.1 197.34,125.1 198.56,123.89 198.56,115.03 196.37,112.84 196.37,109.77 195.58,108.98 195.58,108.05 194.21,106.68 190.13,106.68 188.7,105.25 185.09,105.25 185.09,105.25 184.66,105.25 182.27,102.86 178.89,102.86 178.61,102.58 175.84,102.58 175.07,103.35 167.7,103.35 165.31,100.96 v4(163.32,100.96) ; v4(16.84,120.89) 19.45,120.89 21.26,119.08 21.26,110.38 23.93,107.71 23.93,101.03 24.89,100.07 24.89,96.26 23.9,95.27 v4(23.9,95.07)
  BOTTOM w0.119: RA57.1 17.02,121.62 17.02,121.07 v4(16.84,120.89) ; v4(23.9,95.07) 24.25,94.73 26.42,94.73 28.44,92.72 38.33,92.72 39.23,91.82 42.99,91.82 43.37,92.19 81.14,92.19 81.5,92.19 82.13,92.82 96.34,92.82 98.14,91.02 153.28,91.02 161.64,99.38 162.82,99.38 163.32,99.88 v4(163.32,100.96)
BGT: length 3.1
  IN3 w0.508: v7(112.83,120.7) 112.8,120.73 112.8,121.29 112.79,121.29 112.79,121.46 112.34,121.92 112.17,121.92 111.6,122.49 v7(111.6,123.14)
BIA_PWM_EC: length 123.2
  TOP w0.119: D12.2 116.16,106.86 v1(116.62,107.32)
  IN1 w0.084: v1(116.62,107.32) 116.82,107.51 v2(117.04,107.51)
  IN3 w0.084: v3(124.36,101.99) 122.25,101.99 121.48,102.76 121.48,103.42 121.31,103.59 119.26,103.59 118.57,104.28 v3(117.47,104.28) ; v2(117.04,107.51) 117.04,107.38 v3(116.87,107.2)
  IN4 w0.089: v3(116.87,107.2) 116.66,107 116.66,105.1 v3(117.47,104.28) ; v3(124.36,101.99) 124.64,102.27 126.22,102.27 127.59,103.63 130.23,103.63 131.9,105.3 132.39,105.3 132.8,105.71 136.23,105.71 136.84,105.1 139.85,105.1 141.91,103.04 143.27,103.04 144.06,102.24 148.31,102.24 148.85,102.78 150.17,102.78 150.99,101.96 155.03,101.96 155.56,101.42 165.24,101.42 167.57,103.76 172.94,103.76 173.2,104.03 175.02,104.03 175.43,103.62 178.41,103.62 178.64,103.85 181,103.85 182.97,105.82 188.73,105.82 189.98,107.06 194.02,107.06 195.2,108.25 195.2,110.52 195.99,111.31 195.99,113.38 197.85,115.24 197.85,117.83 197.64,118.04 197.64,122.94 194.43,126.15 193.51,126.15 192.35,127.31 190.75,127.31 189.78,128.28 189.61,128.28 188.09,129.79 188.09,130.08 188.26,130.24 188.49,130.24 188.76,130.51 188.76,130.85 189.25,131.34 189.25,131.34 190.15,132.24 v4(190.32,132.24)
BOARD_ID: length 4.1
  BOTTOM w0.119: U34.G1 195.71,134.74 195.81,134.84 C249.1 196.42,135.19 196.53,135.3 197.82,135.3 R340.2
BQ24777_CSIN: length 24.6
  IN3 w0.305: v7(134.16,116.02) 135.68,116.02 136.63,115.07 136.63,111.24 139.22,108.65 141.64,108.65 141.95,108.35 144.4,108.35 144.81,108.75 145.83,108.75 146.49,109.42 146.49,110.53 146.25,110.77 146.25,112.46 v7(147.7,113.91)
  BOTTOM w0.305: PR500.3 v7(134.16,116.02)
BQ24777_CSIP: length 24.2
  IN3 w0.305: v7(147.73,112.97) 147.35,112.97 146.66,112.28 146.66,110.94 146.9,110.7 146.9,109.25 146,108.35 144.97,108.35 144.57,107.94 141.78,107.94 141.48,108.24 139.05,108.24 136.22,111.07 136.22,114.9 135.51,115.61 v7(134.16,115.61)
  BOTTOM w0.305: PR500.2 v7(134.16,115.61)
BQ24777_CSON: length 32.1
  IN3 w0.305: v7(159.76,116.6) 159.76,116.17 159.21,115.61 150.92,115.61 150.55,115.24 147.07,115.24 145.35,113.53 143.54,113.53 143.18,113.17 143.18,111.85 141.53,110.2 140.26,110.2 138.48,111.98 138.48,113.13 137.85,113.76 v7(137.19,113.76)
  BOTTOM w0.203: PU500.19 138.64,113.14 PC536.2
  BOTTOM w0.305: PC536.2 137.24,113.71 v7(137.19,113.76) ; PR511.3 v7(159.76,116.6)
BQ24777_CSOP: length 32.1
  IN3 w0.305: v7(159.36,116.6) 159.36,116.34 159.04,116.02 150.75,116.02 150.38,115.65 146.9,115.65 145.4,114.15 145.19,113.93 143.34,113.93 142.77,113.37 142.77,112.02 141.36,110.61 140.43,110.61 138.89,112.15 138.89,113.3 138.02,114.16 137.65,114.16 v7(137.15,114.66)
  BOTTOM w0.203: PU500.20 138.8,113.54 138.58,113.76 138.58,114.11 PC536.1
  BOTTOM w0.305: PC536.1 137.19,114.62 v7(137.15,114.66) ; PR511.2 v7(159.36,116.6)
BQ24777_REGN: length 23.5
  IN2 w0.508: v2(138.15,117.03) 138.86,116.32 138.86,112.44 139.6,111.7 139.6,111.37 140,110.96 140,110.96 140.33,110.63 140.33,110.63 141.55,109.41 143.41,109.41 143.97,108.85 145.22,108.85 v2(145.97,109.6)
  IN4 w0.508: 136.99,116.5 136.4,116.5 135.84,115.94 135.84,111.17 137.31,109.69 v4(137.31,108.47)
  vias: v1(145.52,110.12) v1(145.85,110.12) v4(138.12,116.5) v7(138.51,116.91) v7(138.81,116.91)
BST_1.0V:
  vias: v2(174.93,114.73) v7(174.35,114.78) v7(174.6,114.78) v9(175.52,115.05) v9(175.8,115.02)
BT_OFF#_R: length 30.9
  TOP w0.119: v9(47.28,126.58) 47.28,126.51 49.64,124.15 50.6,124.15 D7.1
  GND1 w0.084: v9(47.28,126.58) 47.29,126.58 47.55,126.84 v2(47.61,126.84)
  IN3 w0.084: v7(45.03,146.29) 44.75,146.01 44.75,143.42 44.02,142.69 44.02,140.79 42.62,139.4 42.62,131.08 45.17,128.53 45.17,128.53 46.51,127.19 47.25,127.19 v2(47.61,126.84)
  BOTTOM w0.119: JNGFF3.54 45.55,147.14 45.03,146.62 v7(45.03,146.29)
BT_ON/OFF#: length 34.7
  TOP w0.119: v1(46.53,122.64) 48.34,122.64 48.6,122.9 50.99,122.9 51.8,123.71 51.8,124.54 50.61,125.73 D7.3
  IN1 w0.084: v2(46.6,122.21) 46.6,122.57 v1(46.53,122.64)
  IN2 w0.079: v2(46.6,122.21) 46.72,122.1 46.72,116.35 47.51,115.55 47.73,115.55 50.01,113.27 v2(50.62,113.27)
  IN3 w0.06: v10(62.85,115.04) 62.8,115.04 62.59,114.82 61.58,114.82 61.57,114.84 61.56,114.84 60.69,114.84 59.57,113.72 59.07,113.72 58.94,113.6 58.13,113.6 58.05,113.52
  IN3 w0.084: v2(50.62,113.27) 50.83,113.27 51.09,113.53 51.5,113.53 51.75,113.78 52.04,113.78 52.23,113.6 52.23,113.14 52.61,112.76 52.82,112.76 53.27,112.31 54.49,112.31 54.72,112.54 55.74,112.54 56.02,112.81 56.16,112.81 56.49,113.13 56.49,113.25 56.75,113.52 58.05,113.52
BT_RADIO_DIS#: length 160.9
  TOP w0.119: v1(49.56,126.3) 49.64,126.39 51.35,126.39 51.51,126.23 D7.2
  IN1 w0.084: v2(179.83,133.39) 179.4,132.96 179.11,132.96 177.45,131.3 173.07,131.3 168.61,135.76 138.8,135.76 134.78,131.73 133.53,131.73 132.01,130.21 129.82,130.21 129.66,130.36 127.87,130.36 127.15,131.08 126.25,131.08 125.65,131.69 124.37,131.69 120.5,135.55 120.36,135.69 96.19,135.69 95.82,136.06 94.85,136.06 94.31,135.53 86.63,135.53 85.09,133.98 77.28,133.98 76.62,134.64 68.79,134.64 68.32,135.11 66.52,135.11 65.87,134.46 62.06,134.46 60.85,133.25 60.38,133.25 60.23,133.39 59.86,133.39 59.71,133.25 56.22,133.25 56.11,133.36 55.8,133.36 55.72,133.28 53.12,133.28 52.33,132.49 52.33,132.19 52.57,131.95 52.57,131.25 51.78,130.46 51.78,129.95 51.72,129.9 51.72,129.26 51.85,129.13 51.85,128.28 51.23,127.66 51.23,127.14 50.39,126.3 v1(49.56,126.3)
  IN3 w0.084: v3(185.32,131.84) 185.34,131.87 185.34,133.1 184.91,133.53 183.15,133.53 182.82,133.2 180.92,133.2 180.73,133.39 v2(179.83,133.39)
  IN4 w0.089: v3(185.32,131.84) 185.8,131.84 186.21,131.43 187.28,131.43 188.32,132.47 188.32,132.56 188.72,132.97 189.59,132.97 v4(189.82,132.74)
CAD_SNK: length 119.7
  TOP w0.119: RV16.2 118.89,106.21 118.61,105.93 118.61,105.51 v1(119.33,104.79)
  IN1 w0.084: v2(128.73,104.03) 128.69,104.03 127.88,104.84 119.38,104.84 v1(119.33,104.79)
  IN3 w0.084: v2(128.73,104.03) 128.85,104.03 129.12,104.3 v3(129.51,104.3)
  IN4 w0.089: v4(188.82,133.24) 188.72,133.24 188.12,132.64 188.12,132.55 187.21,131.64 186.28,131.64 185.81,132.11 185.2,132.11 185.05,131.95 185.05,131.06 185.72,130.39 185.72,129.66 185.56,129.5 185.56,126.79 186.46,125.88 191.66,125.88 192.96,124.59 194.08,124.59 195.53,123.15 195.53,115.11 194.5,114.09 194.5,111.78 193.1,110.38 191.82,110.38 188.05,106.61 186.89,106.61 186.55,106.95 185.35,106.95 184.69,106.29 182.83,106.29 180.83,104.28 178.46,104.28 178.23,104.05 175.61,104.05 174.66,105 171.98,105 171.17,104.19 167.4,104.19 165.17,101.97 155.63,101.97 155.2,102.4 153.75,102.4 153.24,102.91 150.65,102.91 150.35,103.21 148.67,103.21 148.13,102.68 144.28,102.68 143.49,103.47 142.09,103.47 140.03,105.53 137.11,105.53 136.11,106.53 133.01,106.53 132.21,105.73 131.72,105.73 130.28,104.3 v3(129.51,104.3)
CAM_LED#: length 32.5
  TOP w0.119: R62.1 122.34,130.06 122.34,131.79 v1(122.31,131.82) ; Q8.3 140.96,129.32 141.68,130.04 141.68,131.74 141.55,131.88 141.55,132.56 141.15,132.96 132.16,132.96 v1(131.93,132.73) ; v1(120.32,134.41) 122.84,134.41 124.07,135.64 v1(124.07,135.73)
  IN1 w0.084: v1(120.32,134.41) 120.32,134.38 122.31,132.38 v1(122.31,131.82) ; v1(124.07,135.73) 124.07,135.52 126.9,132.69 127.78,132.69 127.97,132.5 130.5,132.5 130.64,132.63 131.83,132.63 v1(131.93,132.73)
CEXT: length 1.9
  BOTTOM w0.119: C307.1 58.37,102.94 57.97,102.54 57.97,101.91 57.86,101.79 U47.17
CFG0: length 12.7
  IN4 w0.06: 79.47,103.04 79.47,103.14 79.44,103.17 79.44,103.96 79.11,104.29 79.11,107.21 78.37,107.96 78.37,109.04 77.66,109.75 77.24,109.75 76.87,110.12 76.87,110.35 76.88,110.36 76.88,110.53 76.77,110.64 76.69,110.64 76.4,110.94 v5(76.04,110.94)
  IN4 w0.089: 79.47,103.04 79.47,101.35 79.6,101.21 v4(79.6,100.7)
  BOTTOM w0.119: RC127.1 79.33,100.62 79.41,100.7 v4(79.6,100.7)
CFG1: length 16.9
  IN3 w0.06: v3(79.45,108.35) 79.36,108.35 79.2,108.5 77.54,108.5 77.36,108.69 77.36,109.06 76.36,110.06 v10(76.36,110.69)
  IN4 w0.06: v3(79.45,108.35) 79.77,108.03 79.77,107.81 80.19,107.39 80.19,106.69 80.7,106.18 80.7,105.37 81.09,104.98
  IN4 w0.089: v4(81.69,101.88) 81.48,102.09 81.48,104.59 81.09,104.98
  BOTTOM w0.119: JXDP1.11 78.84,99.76 79,99.91 80.56,99.91 81.47,100.82 81.47,101.65 v4(81.69,101.88)
CFG2: length 20.3
  IN3 w0.06: v10(76.04,111.43) 76.04,111.22 75.84,111.02 75.84,110.85 75.92,110.77 75.92,109.97 76.59,109.3 76.59,109.01 76.78,108.81 76.78,108.65 77.17,108.26 79.02,108.26 79.39,107.9 v3(79.98,107.9)
  IN4 w0.06: v3(79.98,107.9) 80.31,107.57
  IN4 w0.066: 80.31,107.57 80.31,106.74 80.52,106.54 80.57,106.54 80.88,106.22 80.88,105.53
  IN4 w0.089: 80.88,105.53 81.72,104.69 81.72,102.29 82.08,101.93 82.08,98.93 81.11,97.97 v4(81.11,97.87)
  BOTTOM w0.119: JXDP1.15 80.04,98.1 80.27,97.87 81.11,97.87 v4(81.11,97.87)
CFG3: length 31.6
  IN3 w0.06: v10(76.36,111.18) 76.28,111.1 76.28,110.89 76.16,110.77 76.16,110.09 77.24,109.01 77.24,108.57 77.43,108.38 79.11,108.38 79.36,108.13 80.33,108.13 80.54,107.92 80.88,107.92 80.9,107.95
  IN3 w0.084: v7(87.26,108.07) 87.08,108.24 85.58,108.24 85.42,108.4 81.36,108.4 80.9,107.95
  IN4 w0.089: v4(81.74,98.21) 81.74,98.07 81.96,97.84 85.1,97.84 85.86,98.61 85.86,99.95 85.86,100.46 86.8,101.4 86.8,104.49 87.33,105.02 87.33,108 v7(87.26,108.07)
  BOTTOM w0.119: v7(87.26,108.07) 86.4,108.07 RC63.1 ; v4(81.74,98.21) 81.7,98.24 80.84,98.24 80.64,98.45 JXDP1.17
CFG4: length 21.4
  IN3 w0.06: v10(80.67,108.24) 80.47,108.44 79.91,108.44 79.66,108.7 79.35,108.7 79.3,108.74 78.47,108.74 77.46,109.75 77.15,109.75 76.75,110.15 76.75,110.42 76.8,110.47 76.8,110.77 76.95,110.92 76.95,111.13 v10(77.01,111.19)
  IN4 w0.089: v10(80.67,108.24) 81.83,108.24 84.03,106.04 84.03,105.6 84.03,105.6 84.03,104.41 84.03,104.41 84.03,103.4 83.96,103.33 83.96,101.64 v4(84.26,101.35)
  BOTTOM w0.119: v10(80.67,108.24) 80.68,108.25 80.68,108.25 80.68,107.74 81.96,106.46 81.96,106.16 81.96,106.16 81.96,105.43 82.13,105.26 82.13,105.23 RC83.2 ; v4(84.26,101.35) 84.26,100.17 83.64,99.56 JXDP1.27
CFG5: length 17
  IN3 w0.06: v10(77.07,110.29) 77.44,110.29 77.45,110.27 77.46,110.27 77.64,110.08 78.62,109.1 79.26,109.1 79.4,109.25 79.6,109.25 79.84,109 80.39,109 v3(80.47,109.08)
  IN4 w0.06: v3(80.47,109.08) 80.93,108.62 81.03,108.62
  IN4 w0.089: v4(84.3,101.94) 84.3,103.19 84.37,103.26 84.37,104.56 84.37,106.19 83.02,107.54 83.02,108.06 82.46,108.62 81.03,108.62
  BOTTOM w0.119: v4(84.3,101.94) 84.73,101.52 84.73,101.1 84.63,101 84.63,100.02 84.24,99.63 JXDP1.29
CFG6: length 19.1
  IN3 w0.06: v3(84.63,108.83) 84.62,108.82 79.4,108.82 79.35,108.86 78.52,108.86 77.43,109.95 v10(77.32,109.95)
  IN4 w0.089: v3(84.63,108.83) 85.27,108.83 85.95,108.15 85.95,106.3 85.74,106.09 85.74,102.68 v4(85.72,102.66)
  BOTTOM w0.119: v4(85.72,102.66) 85.37,102.66 85.17,102.45 85.17,100.09 85.44,99.82 JXDP1.33
CFG7: length 20.3
  IN3 w0.06: v3(79.49,109.03) 79.35,109.03 79.3,108.98 78.57,108.98 77.52,110.03 77.52,110.03 77.41,110.15 77.24,110.15 77.24,110.15 77.22,110.15 77.15,110.09 76.99,110.09 76.87,110.2 76.87,110.37 77.01,110.51 v10(77.01,110.69)
  IN4 w0.089: v4(85.7,102.07) 85.38,102.39 85.38,102.51 85.38,102.51 85.38,102.8 85.4,102.82 85.4,106.24 85.57,106.41 85.57,107.58 85.3,107.85 85.3,108.17 85.04,108.42 84.55,108.42 84.12,108.86 83.72,108.86 82.71,109.87 81.57,109.87 81.54,109.84 81.49,109.84 81.47,109.86 81.19,109.86 81.17,109.84 80.33,109.84 80.33,109.83 80.3,109.83 80.27,109.81 80.15,109.81 80.01,109.67 79.91,109.67 79.62,109.38 79.62,109.35 79.49,109.22 v3(79.49,109.03)
  BOTTOM w0.119: v4(85.7,102.07) 85.7,100.12 86.04,99.77 JXDP1.35
CFG8: length 18.1
  IN4 w0.06: v5(78.37,110.29) 78.6,110.06 78.6,109.5 78.85,109.24 78.85,108.16 79.83,107.18 79.83,106.38 80.23,105.98 80.23,105.49 80.85,104.87
  IN4 w0.089: 80.85,104.87 81.24,104.48 81.24,101.83 81.74,101.32 81.74,99.1 80.02,97.38 78.71,97.38 78.63,97.46 v4(78.61,97.46)
  BOTTOM w0.119: v4(78.61,97.46) 78.54,97.39 JXDP1.10
CFG9: length 16.6
  IN4 w0.06: 79.34,104.33 79.23,104.43 79.23,107.26 78.49,108.01 78.49,109.09 77.44,110.13 77.44,110.3 77.74,110.6 v10(77.74,110.88)
  IN4 w0.066: 79.34,104.33 79.57,104.1 79.57,103.48 79.71,103.34 79.71,103.04
  IN4 w0.089: 79.71,103.04 79.71,101.45 79.88,101.28 79.88,99.94 79.17,99.23 79.17,98.46 v4(78.92,98.21)
  BOTTOM w0.119: JXDP1.12 79.14,97.14 79.01,97.27 79.01,98.12 v4(78.92,98.21)
CFG10: length 16.5
  IN4 w0.06: 79.78,105.9 79.78,105.82 79.81,105.79 79.81,105.61 79.78,105.59 79.78,105.26 79.54,105.02 79.54,104.43 79.78,104.19 79.78,103.77 79.96,103.59 79.96,103.07
  IN4 w0.066: 79.78,105.9 79.55,106.13 79.55,107.12 78.61,108.06 78.61,109.14 77.64,110.11 v5(77.64,110.22)
  IN4 w0.089: 79.96,103.07 79.96,102.05 80.33,101.68 80.33,99.71 79.71,99.09 79.71,98.43 79.4,98.12 v4(79.4,97.75)
  BOTTOM w0.119: JXDP1.16 80.34,96.81 v4(79.4,97.75)
CFG11: length 19.1
  IN4 w0.06: 81,106.41 81.2,106.21 81.33,106.08 81.33,106.06 ; 80.44,107.45 80.44,107.75 79.27,108.92 79.27,109.19 79.49,109.41 79.49,109.43 80.2,110.15 80.2,110.39 80.05,110.54 79.15,110.54 79.13,110.52 78.6,110.52 v10(78.4,110.72)
  IN4 w0.066: 80.44,107.45 80.44,106.79 80.57,106.66 80.75,106.66 81,106.41
  IN4 w0.089: v4(82.12,98.2) 82.12,98.49 82.73,99.09 82.73,101.77 82.06,102.43 82.06,104.28 81.96,104.38 81.96,105.43 81.33,106.06
  BOTTOM w0.119: v4(82.12,98.2) 82.12,97.65 80.94,96.47 JXDP1.18
CFG12: length 20.6
  IN3 w0.06: v3(81.33,109.51) 80.97,109.87 80.97,110.27 80.29,110.96 78.4,110.96 78.25,111.11 78.25,111.22 78.22,111.25 v10(78.22,111.5)
  IN4 w0.089: v3(81.33,109.51) 81.33,109.42 81.57,109.18 82.38,109.18 83.36,108.2 83.36,107.71 84.72,106.36 84.72,105.31 84.71,105.31 84.71,104.7 84.72,103.1 84.64,103.03 84.64,101.3 84.22,100.88 84.22,98.95 83.51,98.23 v4(83.49,98.23)
  BOTTOM w0.119: v4(83.49,98.23) 83.49,96.75 83.94,96.3 JXDP1.28
CFG13: length 21.6
  IN3 w0.06: v10(77.73,111.37) 77.73,111.18 77.94,110.96 77.94,110.7 78.25,110.4 80.09,110.4 80.78,109.71 80.88,109.71 81.11,109.48 81.11,109.42 81.24,109.3 81.48,109.3 v3(81.71,109.53)
  IN4 w0.089: v3(81.71,109.53) 82.56,109.53 83.7,108.39 83.88,108.39 84.86,107.41 84.86,106.7 85.06,106.5 85.06,105.17 85.06,102.96 84.99,102.89 84.99,101.16 84.57,100.74 84.57,98.8 v4(83.99,98.23)
  BOTTOM w0.119: JXDP1.30 84.54,96.36 83.99,96.91 v4(83.99,98.23)
CFG14: length 22.8
  IN3 w0.06: v3(81.25,110.23) 80.35,111.13 78.52,111.13 v10(78.47,111.18)
  IN4 w0.089: v4(84.46,98.2) 85.18,98.92 85.18,99.67 85.18,100.55 85.18,100.74 86.09,101.65 86.09,104.75 86.36,105.02 86.36,107.05 86.29,107.12 86.29,108.29 85.33,109.26 83.8,109.26 82.85,110.21 81.27,110.21 v3(81.25,110.23)
  BOTTOM w0.119: v4(84.46,98.2) 84.46,97.68 85.74,96.4 JXDP1.34
CFG15: length 24.2
  IN3 w0.06: v10(78.05,111.14) 78.08,111.11 78.08,110.74 78.3,110.52 80.35,110.52 v3(80.57,110.3)
  IN4 w0.089: v4(84.95,98.19) 85.52,98.76 85.52,99.81 85.52,99.96 85.52,99.97 85.52,100.25 85.52,100.25 85.52,100.6 86.46,101.54 86.46,104.63 86.86,105.03 86.86,107.78 86.86,107.78 86.86,108.07 86.72,108.21 86.72,108.35 85.46,109.61 84,109.61 83.05,110.56 80.82,110.56 v3(80.57,110.3)
  BOTTOM w0.119: JXDP1.36 86.34,96.41 85.65,97.1 85.65,97.49 v4(84.95,98.19)
CFG16: length 18
  IN3 w0.06: v10(76.68,111.43) 76.32,111.43 76.16,111.27 76.16,111.15 76.04,111.03 76.04,110.01 77.01,109.04 v3(77.01,108.73)
  IN4 w0.06: v3(77.01,108.73) 77.01,108.62 77.6,108.03 77.6,106.44 77.94,106.1 77.94,104.99 78.32,104.61 78.32,103.56 78.5,103.38 78.5,102.99 78.48,102.97
  IN4 w0.089: v4(78.41,97.83) 78.4,97.83 78.14,98.1 78.14,98.87 78.45,99.18 78.45,102.95 78.48,102.97
  BOTTOM w0.119: v4(78.41,97.83) 78.41,97.8 78,97.39 77.67,97.39 77.34,97.07 JXDP1.6
CFG17: length 17.1
  IN3 w0.06: v10(76.68,110.94) 76.68,110.52 76.63,110.47 76.63,110.1 77.01,109.73 77.01,109.58 77.63,108.96 v3(77.63,108.73)
  IN4 w0.06: v3(77.63,108.73) 77.75,108.61 77.75,106.47
  IN4 w0.066: 78.74,103.04 78.73,103.05 78.73,103.35 78.48,103.6 78.48,105.51 78.16,105.83 78.16,106.05 77.75,106.47
  IN4 w0.089: 78.74,103.04 78.74,102.94 78.72,102.91 78.72,102.87 78.7,102.86 78.7,98.5 v4(78.41,98.21)
  BOTTOM w0.119: v4(78.41,98.21) 78.29,98.21 77.84,97.77 77.52,97.77 76.74,96.99 JXDP1.4
CFG18: length 19.7
  IN3 w0.06: v10(77.34,110.96) 77.32,110.95 77.32,110.6 77.74,110.19 78.12,110.19 78.15,110.16 79.06,110.16 v3(80,109.22)
  IN4 w0.089: v4(82.97,98.23) 83.02,98.23 83.88,99.09 83.88,101.18 83.62,101.44 83.62,103.69 83.69,103.76 83.69,104.27 83.69,105.9 81.69,107.9 80.71,107.9 80.29,108.32 80.29,108.93 v3(80,109.22)
  BOTTOM w0.119: JXDP1.24 82.74,96.85 82.97,97.08 v4(82.97,98.23)
CFG19: length 21.1
  IN3 w0.06: v10(77.33,111.43) 77.33,111.33 77.54,111.11 77.54,110.62 77.8,110.35 78.12,110.35 78.2,110.28 79.14,110.28 79.93,109.49 v3(80.44,109.49)
  IN4 w0.089: v3(80.44,109.49) 80.42,109.46 79.92,109.46 79.77,109.32 79.77,109.12 79.78,109.11 79.78,108.62 80.84,107.56 81.53,107.56 82.04,107.05 83.34,105.75 83.34,104.13 83.34,104.13 83.34,103.9 83.34,103.9 83.27,103.83 83.27,103.55 83.27,103.55 83.27,101.3 83.54,101.03 83.54,99.23 82.53,98.22 v4(82.5,98.22)
  BOTTOM w0.119: v4(82.5,98.22) 82.5,97.25 82.14,96.89 JXDP1.22
CFG_RCOMP: length 5.4
  BOTTOM w0.305: UC1.A54 76.68,109.43 76.68,108.89 76.06,108.27 76.06,106.58 75.92,106.44 75.92,106 76.2,105.72 77.11,105.72 77.24,105.85 RC81.1
CHG_CELL: length 4.5
  BOTTOM w0.203: PU500.16 138.79,111.94 138.61,111.76 138.61,109.72 PR532.1 137.34,109.36 PR529.2
CHG_LED#: length 47.1
  IN2 w0.079: v2(197.06,137.05) 197.44,137.42 199.37,137.42 199.87,137.93 201.76,137.93 202.7,138.87 207.51,138.87 209.07,140.43 213.56,140.43 215.52,138.47 v2(215.59,138.47)
  IN3 w0.084: v2(197.06,137.05) 197.05,137.05 196.51,136.5 195.78,136.5 195.77,136.51 194.59,136.51 v10(193.82,135.74) ; v7(217.22,118.12) 217.18,118.15 216.24,118.15 215.14,119.26 215.14,124.17 215.43,124.47 215.43,138.31 v2(215.59,138.47)
  BOTTOM w0.119: v7(217.22,118.12) 217.26,118.08 JIO1.12
CHG_LGATE: length 7
  IN3 w1.016: 140.59,116.32 140.59,118.25 144.14,121.81
  vias: v7(140.46,115.56) v7(140.66,115.38) v7(144.54,122.8) v7(144.6,122.54)
CHG_SMBCLK: length 80
  IN3 w0.084: v3(183.09,127.2) 183.09,127.19 173.3,127.19 171.24,125.13 171.24,121.93 170.65,121.34 170.65,121.34 168.45,119.14 168.45,115.46 160.44,107.45 148.67,107.45 148.4,107.72 145.78,107.72 145.22,107.16 141.3,107.16 141.28,107.19 140.6,107.19 v7(140.59,107.19)
  IN4 w0.089: v3(183.09,127.2) 183.46,127.2 183.9,127.64 183.9,130.09 183.16,130.84 183.16,134.84 183.55,135.23 183.55,135.76 184.04,136.25 184.44,136.65 184.44,136.94 184.99,137.49 184.99,138.72 186.79,140.52 188.47,140.52 188.77,140.82 189.99,140.82 v4(190.32,140.49) 191.16,139.66 191.16,139.14 190.81,138.8 190.81,138.28 191.32,137.77 v4(191.32,137.24)
  BOTTOM w0.119: PR510.1 140.59,107.99 v7(140.59,107.19)
CHG_SMBCLK_R: length 1.8
  BOTTOM w0.119: PR510.2 140.61,109.9 140.76,109.9 141.15,110.29 PU500.12
CHG_SMBDAT: length 79.9
  IN3 w0.084: v3(183.58,126.65) 183.51,126.73 173.49,126.73 171.71,124.94 171.71,121.74 171.11,121.15 171.11,121.15 168.98,119.01 168.98,115.29 160.68,106.98 150.13,106.98 149.71,106.57 148.74,106.57 148.48,106.83 148.21,106.83 147.83,107.21 145.92,107.21 145.41,106.7 141.11,106.7 v7(141.09,106.72)
  IN4 w0.066: 191.08,137.41 191.08,136.98 191.32,136.74 v10(191.32,136.74)
  IN4 w0.089: 191.08,137.41 190.58,137.9 190.58,139.75 189.84,140.49 v4(189.61,140.49) 188.94,139.82 186.76,139.82 185.46,138.52 185.46,137.3 185.14,136.97 185.14,136.68 184.02,135.57 184.02,134.35 183.77,134.1 183.77,133.75 183.78,133.21 183.78,133.21 183.78,130.89 184.37,130.29 184.37,127.44 v3(183.58,126.65)
  BOTTOM w0.119: v7(141.09,106.72) 141.09,106.73 141.09,108.4 PR508.1
CHG_SMBDAT_R: length 1.5
  BOTTOM w0.119: PU500.11 141.55,109.92 PR508.2
CHG_SW: length 6.7
  IN1 w0.508: v13(145.77,118.68) 144.5,118.68 v1(143.51,117.69)
  BOTTOM w1.016: 146.61,117.92 146.28,117.92 144.65,116.3 143.25,116.3
CHG_UGATE: length 3.4
  IN3 w1.016: 143.93,119.13 142.01,117.21 142.01,116.53
  vias: v7(141.96,115.66) v7(141.95,115.38) v7(144.59,120.06) v7(144.59,119.8) v7(144.61,119.46)
CK_XDP: length 34.4
  IN3 w0.06: 69.8,104.84 69.8,104.91 69.84,104.95 69.84,105.09 69.91,105.16 69.91,106.54 69.97,106.59 69.97,106.91 70.06,107 70.15,107.09 70.15,107.23 70.04,107.34 70.04,107.63 69.96,107.71 69.96,109.14 70.62,109.79 70.62,110.32 70.53,110.41 70.53,111.06 70.45,111.14 70.33,111.14 70.24,111.05 v10(70.24,110.94)
  IN3 w0.084: v3(87.38,99.79) 87.38,99.79 87.53,99.94 87.53,100.02 87.4,100.15 81.34,100.15 80.87,99.68 78.41,99.68 77.75,99.02 72.39,99.02 69.8,101.61 69.8,104.84
  IN4 w0.089: v4(87.25,98.24) 87.38,98.37 87.38,99.08 87.47,99.18 87.47,99.69 v3(87.38,99.79)
  BOTTOM w0.119: v4(87.25,98.24) 87.37,98.13 87.37,97.19 87.72,96.83 87.72,96.54 87.54,96.35 JXDP1.40
CK_XDP#: length 34.4
  IN3 w0.06: 69.96,104.84 69.96,105.04 70.03,105.11 70.03,106.49 70.09,106.54 70.09,106.86 70.27,107.04 70.27,107.24 70.27,107.29 70.16,107.4 70.16,107.68 70.08,107.76 70.08,109.09 70.74,109.74 70.74,110.37 70.65,110.46 70.65,110.96 70.65,111.11 70.5,111.26 70.41,111.26 v10(70.24,111.43)
  IN3 w0.084: 69.96,104.84 69.96,101.68 72.46,99.19 77.68,99.19 78.34,99.84 80.8,99.84 81.28,100.32 87.46,100.32 87.69,100.09 87.69,99.9 v3(87.78,99.81)
  IN4 w0.089: v3(87.78,99.81) 87.69,99.72 87.69,99.09 87.59,98.99 87.59,98.36 v4(87.71,98.24)
  BOTTOM w0.119: JXDP1.42 88.14,96.26 87.99,96.41 87.99,96.94 87.63,97.3 87.63,98.17 v4(87.71,98.24)
CL_CLK: length 93.5
  IN2 w0.079: v2(42.69,140.45) 42.58,140.35 31.36,140.35 24.95,133.94 24.95,130.97 23.73,129.75 23.73,128.89 22.21,127.37 22.21,124.66 23.78,123.09 24.5,123.09 26.87,120.73 26.87,115.19 27.63,114.43 33.27,114.43 37.75,109.95 44.02,109.95 44.24,109.72 47.6,109.72 48.6,108.72 49.82,108.72 50.11,108.42 51.08,108.42 51.43,108.07 51.91,108.07 52.2,108.35 52.36,108.52 55.68,108.52 56.14,108.05 57.89,108.05 58.54,107.41 60.37,107.41 v2(61.34,108.37)
  IN3 w0.06: v2(61.34,108.37) 61.8,108.37 v3(62.23,107.94)
  IN3 w0.084: v7(44.07,144.02) 44.01,144.02 43.13,143.14 43.13,140.9 v2(42.69,140.45)
  IN4 w0.06: v3(62.23,107.94) 61.98,108.19 61.98,108.42 62.56,109 62.56,109.14 62.92,109.5 63.33,109.5 63.56,109.72 63.61,109.78 63.61,109.81 63.72,109.93 63.72,110.2 63.69,110.23 63.69,110.28 63.6,110.36 63.6,110.57 v5(63.48,110.69)
  BOTTOM w0.119: JNGFF3.42 46.36,144.14 46.24,144.02 v7(44.07,144.02)
CL_DATA: length 93.9
  IN2 w0.079: v2(61.39,107.81) 60.75,107.17 58.45,107.17 57.8,107.82 56.04,107.82 55.58,108.28 52.46,108.28 51.98,107.81 51.36,107.81 51,108.17 50.01,108.17 49.7,108.48 48.46,108.48 47.56,109.39 44.09,109.39 43.87,109.61 37.61,109.61 33.13,114.1 25.14,114.1 24.16,115.08 24.16,121.94 23.81,122.28 23.81,122.59 21.88,124.53 21.88,127.51 23.4,129.03 23.4,129.89 24.61,131.1 24.61,134.09 31.53,141.01 v2(43.56,141.01)
  IN3 w0.06: v2(61.39,107.81) v3(61.77,107.81)
  IN3 w0.084: v7(44.07,143.6) 43.56,143.09 v2(43.56,141.01)
  IN4 w0.06: v5(63.48,110.2) 63.55,110.2 63.6,110.15 63.6,109.98 63.49,109.86 63.49,109.83 63.35,109.69 63.27,109.62 62.87,109.62 62.44,109.19 62.44,109.05 61.86,108.47 61.86,107.9 v3(61.77,107.81)
  BOTTOM w0.119: v7(44.07,143.6) 44.11,143.64 JNGFF3.40
CL_RST#: length 90.3
  IN2 w0.079: v2(61.26,108.98) 60.95,108.67 60.29,108.67 59.55,107.93 58.35,107.93 57.99,108.29 56.24,108.29 55.78,108.75 52.26,108.75 52.24,108.72 51.84,108.32 51.54,108.32 51.19,108.68 50.27,108.68 49.99,108.96 48.77,108.96 47.52,110.2 44.5,110.2 44.14,110.56 37.79,110.56 33.45,114.9 27.81,114.9 27.33,115.38 27.33,120.92 24.69,123.56 23.97,123.56 22.67,124.86 22.67,127.07 24.19,128.59 24.19,129.56 25.41,130.78 25.41,133.75 31.55,139.89 43.64,139.89 43.79,140.05 v2(45.52,140.05)
  IN3 w0.06: v2(61.26,108.98) 61.57,108.98 v3(62.23,108.32)
  IN3 w0.084: v7(45.49,141.09) 45.52,141.06 v2(45.52,140.05)
  IN4 w0.06: v3(62.23,108.32) 62.34,108.32 63.24,109.23 v4(63.48,109.23)
  BOTTOM w0.06: 63.48,109.23 v4(63.48,109.23)
  BOTTOM w0.119: v7(45.49,141.09) 45.49,142.74 45.9,143.14 JNGFF3.38 ; UC1.B12 63.48,109.23
CLK_LPC_DEBUG: length 210.6
  TOP w0.119: v1(57.65,124.28) 57.65,124.13 57.3,123.79 CH6.1 57.07,123.99 RH27.2
  IN1 w0.109: v2(57.98,124.29) 57.66,124.29 v1(57.65,124.28)
  IN2 w0.079: v2(216.16,105.09) 216.16,105.66 217.33,106.84 217.33,113.97 216.92,114.39 216.92,117.4 215.81,118.51 215.81,123.12 217.02,124.33 217.02,132.05 215.55,133.52 210.1,133.52 209.78,133.84 207.24,133.84 204.21,130.81 202.33,130.81 201.38,131.75 193.59,131.75 193.08,131.24 190.38,131.24 190.06,131.57 183.94,131.57 180.51,128.13 180.05,127.68 173,127.68 168.96,131.71 165.95,131.71 165.01,132.65 147.98,132.65 147.09,131.76 142.1,131.76 141.45,131.12 140.51,131.12 139.41,130.03 137.49,130.03 136.41,128.95 133.43,128.95 132.7,128.22 131.28,128.22 131,128.5 129.22,128.5 129,128.73 124.91,128.73 124.45,129.19 122.01,129.19 120.59,130.6 119.85,130.6 119.73,130.73 115.74,130.73 115.24,131.23 112.79,131.23 112.36,131.66 108.75,131.66 108.5,131.42 105.96,131.42 105.33,132.04 100.05,132.04 99.4,131.39 97.52,131.39 97.33,131.58 94.2,131.58 94.09,131.47 91.99,131.47 91.96,131.44 91.29,131.44 91.26,131.47 86.69,131.47 86.48,131.26 78.09,131.26 76.3,129.47 75.54,129.47 66.15,129.48 63.36,126.68 61.23,126.68 60,125.45 59.77,125.45 59.49,125.16 59.42,125.16 58.56,124.29 v2(57.98,124.29)
  IN3 w0.084: v7(219.73,98.7) 219.18,99.25 219.18,100.1 218.35,100.93 218.35,101.82 216.16,104.01 v2(216.16,105.09)
CLK_PCI_MEC: length 153.1
  IN2 w0.079: v2(192.76,132.76) 191.9,131.9 190.88,131.9 190.76,132.03 183.75,132.03 179.97,128.25 173.13,128.25 169.2,132.17 166.14,132.17 165.2,133.11 147.78,133.11 146.89,132.22 140.34,132.22 139.77,131.65 139.77,131.03 139.22,130.48 137.28,130.48 136.21,129.41 133.22,129.41 132.49,128.68 131.47,128.68 131.19,128.96 129.45,128.96 129.39,129.02 129.35,129.02 129.19,129.19 125.16,129.19 124.7,129.65 122.3,129.65 120.88,131.06 120.04,131.06 119.45,131.65 118.71,131.65 118.46,131.89 112.78,131.89 112.55,132.12 108.55,132.12 108.31,131.88 106.15,131.88 105.52,132.5 99.86,132.5 99.21,131.85 97.71,131.85 97.52,132.04 94.01,132.04 93.9,131.93 91.8,131.93 91.77,131.9 91.48,131.9 91.45,131.93 86.5,131.93 86.29,131.72 77.9,131.72 76.11,129.93 75.73,129.93 65.96,129.93 63.16,127.14 60.88,127.14 58.53,124.79 56.83,124.79 56.47,125.15 v2(56.47,126.4)
  IN3 w0.084: v7(56.32,126.74) 56.32,126.54 v2(56.47,126.4) ; v7(192.32,131.74) 192.32,131.79 192.76,132.23 v2(192.76,132.76)
  BOTTOM w0.119: v7(192.32,131.74) 192.35,131.71 192.35,130.59 192.05,130.3 191.85,130.3 R356.1 ; v7(56.32,126.74) 56.35,126.71 RH69.2
CLK_PCIE2: length 182.2
  IN3 w0.06: v10(70.89,110.94) 70.89,110.93 70.89,110.64 70.89,110.64 70.89,110.54 70.97,110.46 70.97,109.66 71.32,109.31 71.32,107.53 70.86,107.07 70.47,107.07 70.21,106.81 70.21,106.39 70.15,106.33 70.15,105.85 70.24,105.76 70.24,104.95 70.2,104.91 70.2,104.84
  IN3 w0.084: v3(203.7,105.5) 203.59,105.39 203.59,105.11 203.1,104.61 201.8,104.61 201.28,105.13 201.28,105.89 200.85,106.33 199.91,106.33 197.17,103.59 193.73,103.59 193.03,104.29 190.69,104.29 187.34,100.94 181.63,100.94 180.54,99.85 165.71,99.85 162.95,97.09 152.44,97.09 148.21,101.32 140.35,101.32 139.21,100.19 122.18,100.19 121,101.36 120.39,101.36 119.46,102.29 118.93,102.29 118.11,103.11 112.29,103.11 110.19,101.01 105.46,101.01 105.25,101.22 95.56,101.22 94.98,101.81 93.54,101.81 92.6,100.87 90.47,100.87 90.33,101.01 88.92,101.01 88.72,101.21 84.39,101.21 83.92,100.73 81.12,100.73 80.65,100.26 78.17,100.26 77.51,99.6 72.67,99.6 70.2,102.07 70.2,104.84
  IN4 w0.089: v3(203.7,105.5) 203.63,105.43 203.63,104.22 204.48,103.37 212.5,103.37 217.35,108.22 217.84,108.22 219.09,109.46 219.09,112.51 219.39,112.82 221.48,112.82 v4(221.54,112.88)
  BOTTOM w0.119: JIO1.37 v4(221.54,112.88)
CLK_PCIE2#: length 182.7
  IN3 w0.06: v10(70.89,111.43) 70.89,111.22 71.09,111.02 71.09,110.85 71.01,110.77 71.01,110.59 71.09,110.51 71.09,109.71 71.44,109.36 71.44,107.48 70.91,106.95 70.52,106.95 70.33,106.76 70.33,106.34 70.27,106.28 70.27,105.9 70.36,105.81 70.36,104.84
  IN3 w0.084: 70.36,104.84 70.36,102.13 72.73,99.76 77.44,99.76 78.1,100.42 80.58,100.42 81.05,100.89 83.85,100.89 84.33,101.37 88.79,101.37 88.99,101.17 90.4,101.17 90.54,101.03 92.53,101.03 93.47,101.97 95.05,101.97 95.63,101.39 105.32,101.39 105.53,101.18 110.13,101.18 112.23,103.28 118.18,103.28 119,102.45 119.53,102.45 120.46,101.52 121.07,101.52 122.25,100.35 139.14,100.35 140.28,101.49 148.27,101.49 152.5,97.26 162.88,97.26 165.64,100.02 180.47,100.02 181.56,101.11 187.27,101.11 190.62,104.45 193.1,104.45 193.8,103.75 197.1,103.75 199.85,106.49 200.91,106.49 201.45,105.96 201.45,105.2 201.87,104.78 203.03,104.78 203.43,105.18 203.43,105.39 v3(203.32,105.5)
  IN4 w0.089: v3(203.32,105.5) 203.42,105.4 203.42,104.13 204.39,103.15 212.59,103.15 217.44,108 217.93,108 219.3,109.37 219.3,112.42 219.48,112.6 221.42,112.6 v4(221.54,112.48)
  BOTTOM w0.119: JIO1.39 v4(221.54,112.48)
CLK_PCIE3: length 54.7
  IN2 w0.079: v2(70.81,105.22) 70.46,104.88 70.14,104.88 70.11,104.85 69.26,104.85 69.06,105.04 69.06,106.01 68.78,106.29 67.12,106.29 67.03,106.19 66.31,106.19 65.43,107.08 62.84,107.08 62.33,107.58 61.73,107.58 61.09,106.94 58.35,106.94 57.7,107.59 55.69,107.59 55.66,107.56 53.03,107.56 52.91,107.69 52.47,107.69 52.07,107.28 51.31,107.28 50.83,107.76 49.13,107.76 48.93,107.96 47.94,107.96 47.31,108.59 45.52,108.59 45.31,108.38 42.65,108.38 42.2,108.82 35.55,108.82 32.16,112.21 30.3,112.21 29.95,111.86 29.95,111.56 v2(29.74,111.36)
  IN3 w0.06: v2(70.81,105.22) 70.88,105.22 71.01,105.1 71.01,104.94 71.13,104.81 71.21,104.81 71.62,105.21 71.62,106.94 71.97,107.29 71.97,109.59 71.53,110.02 71.53,110.56 71.53,110.94 v10(71.53,110.94)
  IN3 w0.084: v7(29.57,111.02) 29.74,111.2 v2(29.74,111.36)
  BOTTOM w0.119: R404.1 29.57,110.84 v7(29.57,111.02)
CLK_PCIE3#: length 54.7
  IN2 w0.079: v2(70.82,104.69) 70.22,104.69 70.19,104.67 69.18,104.67 68.88,104.97 68.88,105.93 68.71,106.1 67.2,106.1 67.11,106.01 66.24,106.01 65.36,106.89 62.76,106.89 62.25,107.4 61.81,107.4 61.17,106.76 58.27,106.76 57.62,107.41 55.77,107.41 55.73,107.37 52.96,107.37 52.83,107.5 52.55,107.5 52.14,107.1 51.23,107.1 50.75,107.58 49.05,107.58 48.85,107.77 47.86,107.77 47.23,108.4 45.6,108.4 45.39,108.19 42.57,108.19 42.13,108.64 35.47,108.64 32.09,112.02 30.37,112.02 30.13,111.78 30.13,111.55 v2(30.33,111.36)
  IN3 w0.06: v10(71.53,111.43) 71.53,111.22 71.73,111.02 71.73,110.85 71.73,110.85 71.65,110.77 71.65,110.61 71.65,110.07 72.08,109.64 72.08,107.24 71.74,106.89 71.74,105.17 71.26,104.69 v2(70.82,104.69)
  IN3 w0.084: v2(30.33,111.36) 30.42,111.26 v7(30.42,111.02)
  BOTTOM w0.119: R403.1 30.42,110.84 v7(30.42,111.02)
CLK_PCIE3#_R: length 5.3
  IN3 w0.084: v7(30.42,109.32) 30.07,108.98 30.07,108.02 29.85,107.8 29.85,104.94 v7(30.03,104.77)
  BOTTOM w0.119: R403.2 30.63,109.53 v7(30.42,109.32)
CLK_PCIE3_R: length 5.3
  IN3 w0.084: v7(29.57,109.32) 29.91,108.99 29.91,108.08 29.69,107.87 29.69,104.94 v7(29.52,104.77)
  BOTTOM w0.119: R404.2 29.36,109.53 v7(29.57,109.32)
CLK_PCIE4: length 68.2
  TOP w0.119: v1(53.26,133.83) 53.3,133.8 R37.1
  IN1 w0.109: v2(53.7,133.99) 53.7,134.17 53.58,134.28 53.3,134.28 53.21,134.19 53.21,133.88 v1(53.26,133.83)
  IN2 w0.079: v2(70.65,106.63) 70.65,106.6 70.39,106.35 70.31,106.35 69.31,107.34 69.31,107.49 68.9,107.9 67.95,107.9 67.6,108.24 65.8,108.24 65.51,107.95 63.77,107.95 61.17,110.56 57.05,110.56 56.79,110.29 49.73,110.29 48.21,111.81 46.45,111.81 44.28,113.99 44.28,116.05 43.57,116.76 43.57,120.98 43.79,121.2 43.79,121.8 44.12,122.13 44.12,124.28 43.54,124.87 43.54,125.75 43.64,125.85 43.64,126.42 45.02,127.8 45.02,127.92 45.02,128.59 44.89,128.71 44.89,130.99 48.28,134.38 48.28,134.6 49,135.32 49.23,135.32 49.94,136.03 51.19,136.03 51.27,136.11 51.81,136.11 52.44,135.47 52.44,135.47 52.44,134.92 52.44,134.69 52.69,134.44 53.37,134.44 53.7,134.11 v2(53.7,133.99)
  IN3 w0.06: v2(70.65,106.63) 70.65,106.51 70.94,106.22 71.07,106.22 71.22,106.37 71.22,107.03 71.63,107.43 71.63,109.48 71.29,109.82 71.29,110.61 v10(71.21,110.69)
CLK_PCIE4#: length 68.2
  TOP w0.119: v1(53.26,134.63) 53.3,134.66 R32.1
  IN1 w0.109: v1(53.26,134.63) 53.69,134.63 v2(53.7,134.62)
  IN2 w0.079: v2(70.63,106.1) 70.57,106.16 70.23,106.16 69.12,107.27 69.12,107.36 69.12,107.41 68.83,107.71 67.87,107.71 67.52,108.06 65.88,108.06 65.58,107.77 63.69,107.77 61.09,110.37 57.13,110.37 56.87,110.11 49.65,110.11 48.13,111.63 46.38,111.63 44.09,113.91 44.09,115.98 43.38,116.69 43.38,121.06 43.6,121.28 43.6,121.87 43.93,122.21 43.93,124.21 43.35,124.79 43.35,125.82 43.45,125.92 43.45,126.5 44.83,127.88 44.83,128.51 44.71,128.64 44.71,131.07 48.1,134.46 48.1,134.68 48.93,135.5 49.15,135.5 49.86,136.21 51.11,136.21 51.19,136.29 51.88,136.29 52.63,135.55 52.63,135.4 52.63,134.99 52.63,134.99 52.63,134.76 52.77,134.62 v2(53.7,134.62)
  IN3 w0.06: v2(70.63,106.1) 71.12,106.1 71.34,106.32 71.34,106.98 71.75,107.38 71.75,109.53 71.41,109.87 71.41,110.77 71.21,110.97 v10(71.21,111.18)
