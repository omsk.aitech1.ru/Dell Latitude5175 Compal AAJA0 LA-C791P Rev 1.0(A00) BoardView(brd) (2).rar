# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_DDI1_N3_C: length 1.7
  TOP w0.119: UV2.47 25.31,55.79 25.24,55.86 25.24,56.73 CV25.2
PCH_DDI1_P0: length 108.2
  IN1 w0.109: v2(29.24,58.03) 29.39,57.87 29.39,57.66 v1(29.29,57.55)
  IN2 w0.079: v2(29.24,58.03) 29.38,57.89 29.38,57.59 29.59,57.38 30.12,57.38 30.45,57.71 30.45,58.45 30.31,58.6 30.31,60.89 22.37,68.83 22.37,80.82 26.58,85.03 26.58,85.52 39.34,98.28 42.72,98.28 43.31,97.69 46.68,97.69 47.28,98.28 49.88,98.28 50.26,97.91 51.46,97.91 51.72,98.17 52.98,98.17 54.06,97.09 60.91,97.09 62.14,95.85 62.87,95.85 63.17,96.15 63.17,96.45 63.36,96.64 64.12,96.64 64.57,96.18 68.98,96.18 69.19,96.4 70,96.4 70.87,97.26 72,97.26 72.78,98.03 73.66,98.03 75.61,99.98 76.07,99.98 76.56,100.47 76.56,101.33 77.54,102.31 77.54,103.76 76.96,104.35 75.69,104.35 75.55,104.49 v2(74.98,104.49)
  IN3 w0.084: v2(74.98,104.49) v3(75.31,104.49)
  IN4 w0.06: v3(75.31,104.49) 75.21,104.39 75.11,104.39 75.04,104.45 75.04,104.61 75.51,105.08 75.51,106.37 75.14,106.75 75.14,107.6 74.84,107.89 74.84,108.36 74.31,108.9 74.31,109.35 74.31,109.35 74.31,109.52 74.31,109.53 74.14,109.69 74.14,109.92 v5(74.11,109.95)
PCH_DDI1_P0_C: length 1.7
  TOP w0.119: CV32.2 29.29,56.96 29.43,56.81 29.43,56.35 29.43,56.35 29.43,56.06 29.31,55.94 UV2.39
PCH_DDI1_P1: length 108
  IN1 w0.109: v1(27.79,57.52) 28,57.31 28,57.22 v2(27.74,56.95)
  IN2 w0.079: v2(27.74,56.95) 28.02,56.95 28.05,56.99 28.05,57.26 27.86,57.45 27.41,57.45 26.96,57.01 23.94,57.01 21.62,59.32 21.62,66.33 20.38,67.57 20.38,81.66 24.58,85.86 24.58,86.93 26.63,88.99 26.87,88.99 34.56,96.67 35.01,96.67 40.21,101.88 46.71,101.88 48.3,100.3 53.68,100.3 54.94,99.03 61.75,99.03 62.35,98.43 67.81,98.43 68.77,99.39 71.22,99.39 72.67,100.84 73.39,100.84 74.13,101.58 74.13,101.82 v2(74.5,102.19)
  IN3 w0.084: v3(74.93,102.17) 74.8,102.05 74.64,102.05 v2(74.5,102.19)
  IN4 w0.06: v5(74.75,109.43) 74.83,109.36 74.83,109.28 75.31,108.8 75.31,108.03 75.69,107.65 75.69,106.95 76.11,106.53 76.11,105.77 76.4,105.48 76.4,104.87
  IN4 w0.089: 76.4,104.87 76.4,104.61 76.48,104.54 76.48,103.29 75.79,102.61 75.79,102.16 75.64,102.01 75.07,102.01 74.93,102.15 v3(74.93,102.17)
PCH_DDI1_P1_C: length 1.7
  TOP w0.119: UV2.42 27.81,55.94 27.93,56.06 27.93,56.8 CV30.2
PCH_DDI1_P2: length 105.8
  IN1 w0.109: v2(26.24,58.06) 26.43,57.87 26.43,57.68 v1(26.29,57.55)
  IN2 w0.079: v2(26.24,58.06) 26.4,58.21 26.4,58.38 26.31,58.47 26.07,58.47 25.81,58.2 25.81,57.93 25.45,57.58 24.17,57.58 22.63,59.12 22.63,66.21 20.99,67.85 20.99,81.44 25.16,85.61 25.16,86.67 26.83,88.34 27.06,88.34 34.78,96.05 35.19,96.05 37.91,98.77 39.94,100.8 43.99,100.8 45.75,99.04 46.15,99.04 46.73,99.63 48.63,99.63 48.72,99.72 53.43,99.72 54.72,98.44 61.53,98.44 61.97,98.01 68.37,98.01 69.1,98.75 71.48,98.75 72.94,100.21 73.67,100.21 74.95,101.48 74.95,102.27 74.46,102.76 74.46,103.04 74.71,103.29 75.11,103.29 v2(75.23,103.42)
  IN3 w0.084: v2(75.23,103.42) 74.91,103.42 74.91,103.42 v3(74.9,103.42)
  IN4 w0.06: v5(73.78,110.2) 73.78,109.99 73.99,109.79 73.99,109.62 73.9,109.53 73.9,108.96 74.57,108.3 74.57,107.8 74.81,107.56 74.81,105.52 74.66,105.37 74.66,103.78 74.45,103.57 74.45,103.42 74.59,103.29 74.79,103.29 74.9,103.4 v3(74.9,103.42)
PCH_DDI1_P2_C: length 1.7
  TOP w0.119: CV28.2 26.29,56.95 26.43,56.81 26.43,56.06 26.31,55.94 UV2.45
PCH_DDI1_P3: length 101.8
  IN1 w0.109: v2(24.57,58.28) 24.89,57.96 v1(24.89,57.52)
  IN2 w0.079: v2(76.1,103.09) 76.24,103.23 76.55,103.23 76.73,103.06 76.73,102.87 75.79,101.94 75.79,101.42 73.76,99.38 73,99.38 71.76,98.14 69.25,98.14 68.55,97.44 61.73,97.44 61.3,97.87 54.41,97.87 53.33,98.95 51.41,98.95 51.28,98.82 50.66,98.82 50.44,99.04 46.96,99.04 46.37,98.45 43.63,98.45 42.94,99.14 39.12,99.14 25.82,85.84 25.82,85.35 21.58,81.11 21.58,68.07 25.03,64.62 25.03,62.2 24.81,61.97 24.81,58.5 24.59,58.28 v2(24.57,58.28)
  IN3 w0.084: v3(75.72,103.09) v2(76.1,103.09)
  IN4 w0.06: v5(74.43,110.2) 74.43,109.99 74.64,109.78 74.64,109.6 74.55,109.51 74.55,109.08 75.13,108.5 75.13,107.96 75.47,107.63 75.47,106.92 75.88,106.52 75.88,105.68 76.15,105.41 76.15,104.66 75.98,104.5 75.98,104.02 76.17,103.84 76.17,103.37 76.05,103.25 75.88,103.25 v3(75.72,103.09)
PCH_DDI1_P3_C: length 1.7
  TOP w0.119: UV2.48 24.81,55.75 24.98,55.92 24.98,56.85 CV26.2
PCH_DDI2_AUXN: length 23.4
  IN2 w0.079: v2(73.17,104.07) 73.35,103.89 73.47,103.89 73.74,103.62 73.74,103.12 73.33,102.71 72.98,102.71 70.66,100.39 68.24,100.39 67.25,99.41 63.93,99.41 63.66,99.68 63.25,99.68 63.15,99.58 63.04,99.58 62.89,99.58 62.76,99.46 v2(62.76,99.41)
  IN3 w0.06: 73.13,104.84 73.14,104.85 73.14,106.06 73.33,106.25 73.33,107.69 72.77,108.25 72.77,109.78 72.29,110.26 72.29,110.77 72.37,110.85 72.37,111.02 72.17,111.22 v10(72.17,111.43)
  IN3 w0.084: v2(73.17,104.07) 73,103.9 72.85,103.9 72.76,103.99 72.76,104.46 73.13,104.84 ; v7(62.28,99.33) 62.39,99.44 62.48,99.44 62.54,99.51 62.66,99.51 v2(62.76,99.41)
PCH_DDI2_AUXN_C: length 2.2
  BOTTOM w0.119: C330.2 61.55,99.48 60.97,99.48 60.59,99.09 60.37,99.09 60.3,99.02 U47.25
PCH_DDI2_AUXP: length 23.4
  IN2 w0.079: v2(73.19,103.39) 73.19,103.61 73.28,103.7 73.39,103.7 73.55,103.54 73.55,103.2 73.25,102.9 72.9,102.9 70.58,100.58 68.16,100.58 67.18,99.59 64.01,99.59 63.74,99.86 63.17,99.86 63.08,99.77 62.93,99.77 v2(62.76,99.94)
  IN3 w0.06: v10(72.17,110.94) 72.17,110.21 72.65,109.73 72.65,108.2 73.21,107.64 73.21,106.3 73.02,106.11 73.02,104.96 72.9,104.84
  IN3 w0.084: v2(73.19,103.39) 73.19,103.59 73.05,103.74 72.78,103.74 72.59,103.93 72.59,104.53 72.9,104.84 ; v7(62.28,99.89) 62.21,99.89 62.08,99.76 62.08,99.68 62.15,99.6 62.41,99.6 62.47,99.67 62.49,99.67 v2(62.76,99.94)
PCH_DDI2_AUXP_C: length 2.2
  BOTTOM w0.119: C328.2 61.55,99.74 60.87,99.74 60.48,99.35 60.32,99.35 60.25,99.42 U47.24
PCH_DDI2_CLK: length 14.5
  IN4 w0.06: v5(61.37,111.18) 61.35,111.2 60.94,111.2
  IN4 w0.089: 60.94,111.2 59.49,109.75 59.49,103.95 60.32,103.12 60.32,101.48 60.25,101.41 v4(60.25,101.39)
  BOTTOM w0.119: U47.22 60.16,100.22 60.44,100.5 60.44,100.94 60.55,101.05 RC124.2 60.91,101.41 60.27,101.41 v4(60.25,101.39)
PCH_DDI2_DAT: length 13.6
  IN4 w0.06: v5(61.47,110.72) 61.47,110.7 61.38,110.61 61.34,110.61 61.15,110.42 61.15,110.38 61.09,110.31 61.09,109.99 59.76,108.67 59.76,106.71 59.79,106.68 59.79,105.83
  IN4 w0.089: v4(60.73,100.62) 60.6,100.75 60.6,103.18 59.95,103.83 59.95,105.67 59.79,105.83
  BOTTOM w0.119: v4(60.73,100.62) 61.12,100.62 RC128.2 61.06,100.27 60.68,100.27 60.24,99.82 U47.23
PCH_DDI2_HPD: length 18.5
  IN3 w0.06: v10(62.85,111.82) 62.33,111.3 61.59,111.3 61.14,110.84 59.95,110.84 58.76,109.65 57.77,109.65 56.18,108.07
  IN3 w0.084: 56.18,108.07 55.83,107.71 55.83,107.28 55.35,106.81 55.35,106.13 54.21,104.99 53.62,104.99 51.97,103.34 51.97,102.63 v7(51.87,102.53)
  BOTTOM w0.119: U47.3 52.26,101.71 51.46,102.5 51.46,102.9 RH129.2 51.76,102.75 51.76,102.63 v7(51.87,102.53)
PCH_DDI2_N0: length 32.5
  IN2 w0.079: v2(52.37,102.61) 52.52,102.76 53.44,102.76 53.59,102.61 54.73,102.61 55.22,102.12 56.74,102.12 57.23,101.62 60.07,101.62 60.18,101.73 62.77,101.73 63.6,100.9 65.85,100.9 65.87,100.88 67.69,100.88 67.89,101.07 70.59,101.07 72.8,103.29 72.8,104.21 73.02,104.43 73.53,104.43 v2(73.73,104.23)
  IN3 w0.084: v2(73.73,104.23) v3(74.07,104.23) ; v2(52.37,102.61) 52.51,102.75 52.95,102.75 53.24,103.04 v7(53.24,103.56)
  IN4 w0.06: v5(72.82,109.43) 72.82,108.79 72.92,108.69 73.05,108.56 73.05,105.63 73.46,105.22 73.46,104.67 73.64,104.49 74.14,104.49 74.22,104.41 74.22,104.33 74.12,104.23 v3(74.07,104.23)
PCH_DDI2_N0_C: length 2
  BOTTOM w0.119: U47.7 53.86,101.83 53.73,101.96 53.72,101.96 53.72,101.96 53.72,102.09 53.12,102.69 53.12,102.85 C314.2
PCH_DDI2_N1: length 27
  IN2 w0.079: v2(55.68,103.27) 55.5,103.09 55.5,102.98 55.59,102.89 56.01,102.89 56.48,103.36 58.05,103.36 58.33,103.08 63.71,103.08 64.06,102.73 64.46,102.73 64.69,102.51 70.07,102.51 71.79,104.23 71.79,105.1 72.8,106.11 72.8,106.68 73,106.88 73.48,106.88 73.6,107 v2(73.7,107)
  IN3 w0.06: v2(73.7,107) 73.71,107.01 74.16,107.01 74.29,107.15 74.29,107.29 74.23,107.36 v3(74.04,107.36)
  IN3 w0.084: v7(55.47,103.56) 55.47,103.47 v2(55.68,103.27)
  IN4 w0.06: v3(74.04,107.36) 73.94,107.36 73.86,107.28 73.86,107.13 73.96,107.03 74.24,107.03 74.45,107.23 74.45,107.41 73.91,107.96 73.91,108.44 73.46,108.88 v5(73.46,109.43)
PCH_DDI2_N1_C: length 1.9
  BOTTOM w0.119: U47.10 55.06,101.8 55,101.86 55,102.16 55.32,102.48 55.32,102.82 C312.2
PCH_DDI2_N2: length 24.5
  IN2 w0.079: v2(56.92,104.31) 56.75,104.14 56.75,104 56.83,103.93 58.32,103.93 58.58,103.67 64.37,103.67 64.98,103.06 66.34,103.06 66.7,103.42 70.15,103.42 71.37,104.64 71.37,105.29 71.48,105.4 71.48,106.21 71.48,106.36 71.82,106.71 72.07,106.71 72.21,106.84 v2(72.21,106.94)
  IN3 w0.06: v3(72.62,107.05) 72.62,106.85 72.44,106.67 72.29,106.67 72.21,106.75 v2(72.21,106.94)
  IN3 w0.084: v7(56.59,103.56) 56.53,103.56 56.41,103.67 56.41,103.8 v2(56.92,104.31)
  IN4 w0.06: v3(72.62,107.05) 72.72,106.95 72.72,106.82 72.65,106.75 72.47,106.75 72.31,106.9 72.31,109.64 72.38,109.71 v5(72.5,109.71)
PCH_DDI2_N2_C: length 1.9
  BOTTOM w0.119: U47.13 56.26,101.84 56.15,101.96 56.15,102.05 56.4,102.3 56.4,102.78 C310.2
PCH_DDI2_N3: length 27
  IN2 w0.079: v2(73.61,105.96) 73.61,105.88 73.48,105.76 73.14,105.76 72.2,104.82 72.2,103.75 70.35,101.89 66.09,101.89 65.76,101.56 64.78,101.56 64.4,101.95 63.74,101.95 63.18,102.5 59.86,102.5 59.74,102.38 57.66,102.38 57.55,102.5 57.55,102.57 v2(57.78,102.81)
  IN3 w0.06: v2(73.61,105.96) 73.61,105.83 73.79,105.65 74.02,105.65 74.12,105.76 74.12,105.91 v3(74.04,105.98)
  IN3 w0.084: v2(57.78,102.81) 57.52,103.08 57.52,103.39 v7(57.71,103.58)
  IN4 w0.06: v5(73.14,109.71) 73.14,109.7 73.14,108.84 73.53,108.45 73.53,106.76 73.91,106.37 74.16,106.37 74.32,106.21 74.32,105.88 74.32,105.75 74.22,105.65 73.92,105.65 73.86,105.7 73.86,105.91 73.94,105.98 v3(74.04,105.98)
PCH_DDI2_N3_C: length 1.9
  BOTTOM w0.119: U47.16 57.46,101.87 57.38,101.95 57.38,102.38 57.55,102.55 57.55,102.84 C308.2
PCH_DDI2_P0: length 32.5
  IN2 w0.079: v2(52.4,103.14) 52.6,102.94 53.52,102.94 53.67,102.79 54.81,102.79 55.3,102.3 56.82,102.3 57.31,101.81 59.99,101.81 60.1,101.92 62.85,101.92 63.68,101.09 65.93,101.09 65.95,101.06 67.61,101.06 67.81,101.26 70.51,101.26 72.62,103.37 72.62,104.29 72.94,104.61 73.56,104.61 v2(73.74,104.79)
  IN3 w0.084: v2(73.74,104.79) v3(74.07,104.79) ; v2(52.4,103.14) 52.63,102.91 52.88,102.91 53.08,103.11 53.08,103.29 52.81,103.56 v7(52.68,103.56)
  IN4 w0.06: v5(72.82,109.95) 72.82,109.72 73.02,109.51 73.02,109.35 73.02,109.35 72.94,109.27 72.94,108.84 73,108.78 73.17,108.61 73.17,105.68 73.58,105.27 73.58,104.72 73.69,104.61 73.89,104.61 v3(74.07,104.79)
PCH_DDI2_P0_C: length 2
  BOTTOM w0.119: U47.6 53.46,101.98 52.86,102.58 52.86,102.8 C315.2
PCH_DDI2_P1: length 27.1
  IN2 w0.079: v2(55.15,103.19) 55.31,103.02 55.31,102.9 55.52,102.7 56.08,102.7 56.56,103.17 57.97,103.17 58.25,102.89 63.63,102.89 63.98,102.55 64.39,102.55 64.61,102.33 70.14,102.33 71.97,104.15 71.97,105.02 72.98,106.03 72.98,106.6 73.07,106.7 73.53,106.7 73.76,106.47 v2(73.81,106.47)
  IN3 w0.06: v2(73.81,106.47) 73.81,106.54 74.02,106.75 v3(74.08,106.75)
  IN3 w0.084: v7(54.91,103.56) 54.91,103.42 v2(55.15,103.19)
  IN4 w0.06: v3(74.08,106.75) 74.24,106.91 74.29,106.91 74.57,107.18 74.57,107.28 74.57,107.28 74.57,107.46 74.03,108 74.03,108.49 73.58,108.93 73.58,109.26 73.66,109.34 73.66,109.52 73.55,109.63 73.55,109.87 v5(73.46,109.95)
PCH_DDI2_P1_C: length 1.9
  BOTTOM w0.119: C313.2 55.06,102.83 55.06,102.59 54.74,102.26 54.74,101.9 54.66,101.82 U47.9
PCH_DDI2_P2: length 24.5
  IN2 w0.079: v2(72.2,106.38) 72.06,106.52 71.9,106.52 71.67,106.29 71.67,105.32 71.55,105.21 71.55,104.56 70.22,103.23 66.78,103.23 66.41,102.87 64.9,102.87 64.29,103.48 58.5,103.48 58.24,103.74 56.75,103.74 56.57,103.93 56.57,104.11 v2(56.37,104.31)
  IN3 w0.06: v3(72.62,106.53) 72.6,106.55 72.38,106.55 v2(72.2,106.38)
  IN3 w0.084: v7(56.03,103.56) 56.25,103.78 56.25,103.87 56.46,104.08 56.46,104.21 v2(56.37,104.31)
  IN4 w0.06: v5(72.5,110.2) 72.5,109.99 72.19,109.69 72.19,106.85 72.42,106.63 72.52,106.63 v3(72.62,106.53)
PCH_DDI2_P2_C: length 1.8
  BOTTOM w0.119: U47.12 55.86,101.84 55.88,101.87 55.88,102.16 56.14,102.41 56.14,102.87 C311.2
PCH_DDI2_P3: length 26.9
  IN2 w0.079: v2(57.12,102.81) 57.36,102.57 57.36,102.42 57.58,102.2 59.82,102.2 59.94,102.32 63.1,102.32 63.66,101.76 64.32,101.76 64.7,101.38 65.84,101.38 66.17,101.71 70.42,101.71 72.39,103.67 72.39,104.74 73.22,105.57 73.44,105.57 v2(73.58,105.43)
  IN3 w0.06: v3(74.04,105.43) 73.94,105.53 73.68,105.53 v2(73.58,105.43)
  IN3 w0.084: v2(57.12,102.81) 57.35,103.04 57.35,103.38 v7(57.15,103.58)
  IN4 w0.06: v3(74.04,105.43) 74.14,105.53 74.27,105.53 74.44,105.7 74.44,105.93 74.44,106.26 74.21,106.49 73.96,106.49 73.65,106.81 73.65,108.4 73.65,108.4 73.65,108.5 73.26,108.88 73.26,109.52 73.34,109.6 73.34,109.78 73.34,109.79 73.14,109.99 v5(73.14,110.2)
PCH_DDI2_P3_C: length 1.8
  BOTTOM w0.119: U47.15 57.06,101.84 57.12,101.89 57.12,102.27 57.12,102.49 57.29,102.65 57.29,102.86 C309.2
PCH_DPWROK: length 186
  TOP w0.119: v1(43.15,127.55) 44.35,127.55 T10.1 45.69,128.41 RH16.1
  IN1 w0.084: v2(43.18,127.88) 43.18,127.58 v1(43.15,127.55)
  IN2 w0.079: v2(43.18,127.88) 43.18,129.49 43.58,129.89 43.58,131.74 45.12,133.28 45.12,134.31 45.68,134.86 45.68,135.41 47.4,137.14 48.18,137.14 49.66,138.62 49.66,139.91 50.99,141.24 54.1,141.24 54.92,142.06 64.98,142.06 70.44,136.6 70.5,136.6 70.52,136.57 81.21,136.57 81.24,136.6 93.89,136.6 94.46,137.16 96.28,137.16 96.74,136.7 101.11,136.7 102.39,137.98 102.67,137.98 103.48,137.17 121.12,137.17 122.9,135.38 124.88,135.38 126.84,133.42 133.68,133.42 137.41,137.15 169.84,137.15 174,132.99 177.08,132.99 179.78,135.69 179.78,136.62 181.22,138.05 181.6,138.05 186.77,143.22 188.58,143.22 188.84,142.97 192.87,142.97 v2(193.96,144.06)
  IN3 w0.084: v3(191.39,140.88) 191.73,141.22 191.89,141.22 192.11,141.44 192.11,141.74 193.7,143.32 193.7,143.8 v2(193.96,144.06)
  IN4 w0.089: v3(191.39,140.88) 191.9,140.88 192.12,140.66 192.12,138.77 192.82,138.07 v5(192.82,137.74)
PCH_DPWROK_R: length 22.7
  TOP w0.119: v9(48.46,129.21) 47.89,129.21 C74.2 47.71,129.03 47.71,128.2 RH19.2 RH16.2
  GND1 w0.119: v2(47.78,129.38) 47.94,129.21 v9(48.46,129.21)
  GND3 w0.119: v2(47.78,129.38) 47.94,129.21 v8(48.34,129.21)
  IN4 w0.06: 53.26,128.23 56.03,128.23 56.11,128.31 56.44,128.31 56.57,128.18 56.57,127.89 56.83,127.62 57.12,127.62 v4(57.56,127.19)
  IN4 w0.089: 53.26,128.23 52.02,128.23 51.33,128.92 51.14,128.92 50.25,129.81 48.93,129.81 v8(48.34,129.21)
  BOTTOM w0.076: v4(57.56,127.19) 58.04,127.19 58.62,126.61 58.82,126.61 59.4,126.03 62.72,126.03 64.12,124.64 UC1.BN15
PCH_ENVDD: length 51.1
  TOP w0.119: v1(77.14,104.08) 77.23,104.17 81.57,104.17 83.62,102.12 95.63,102.12 95.97,101.77 96.86,101.77 97.31,102.21 97.31,102.83 98.72,104.25 D16.2
  IN1 w0.084: v1(77.14,104.08) 77.14,104.95 76.65,105.44 76.14,105.44 75.87,105.17 75.38,105.17 75.18,105.37 75.18,105.5 74.88,105.81 74.88,106.53 73.99,107.42 73.11,107.42 72.77,107.08 72.77,106.12 70.69,104.04 69.16,104.04 68.8,103.68 68.26,103.68 67.27,104.67 66.43,104.67 66.33,104.77 66.24,104.77 66.22,104.79 66.13,104.79 63.81,107.11 63.71,107.11 61.16,109.66 60.3,109.66 v2(60.01,109.36)
  IN3 w0.06: v7(60.58,109.9) 60.05,109.36 v2(60.01,109.36)
  BOTTOM w0.119: UC1.D3 60.97,110.29 v7(60.58,109.9)
PCH_GPD11: length 19.6
  IN4 w0.06: v5(64.12,121.78) 64.12,121.99 63.82,122.29 63.75,122.29 63.72,122.32 63.6,122.44 63.6,122.6 63.61,122.62 63.61,122.62 63.68,122.68 63.68,122.85 63.6,122.93 63.6,123.1 63.68,123.18 63.68,123.36 63.5,123.53 63.5,123.89 63.48,123.91 63.48,124.13 63.29,124.32 63.15,124.32 61.68,125.8 59.57,125.8 58.85,126.52 58.54,126.52 57.87,127.19 57.87,127.66 57.77,127.75 56.89,127.75 56.69,127.95 56.69,128.5 56.01,129.17 56.01,129.85 55.56,130.31 55.36,130.31
  IN4 w0.089: v7(51.13,129.32) 51.31,129.32 51.5,129.13 51.73,129.13 51.89,129.29 51.89,129.52 51.88,129.52 52.1,129.74 52.1,130.14 52.27,130.31 55.36,130.31
PCH_GPIOA7: length 12.7
  IN4 w0.06: 56.29,123.31 56.31,123.31 56.4,123.4 56.67,123.4 56.79,123.27 56.79,122.88 56.88,122.79 57.07,122.79 57.45,122.41 57.93,122.41 57.93,122.41 58.78,122.41 59.05,122.14 59.62,122.14 60.05,122.57 60.56,122.57 60.67,122.45 v5(61.13,122.45)
  IN4 w0.089: v4(53.26,124.07) 53.35,124.07 53.87,123.55 54.29,123.55 54.3,123.55 54.33,123.55 54.78,123.1 55.52,123.1 55.72,123.31 56.29,123.31
  BOTTOM w0.119: RC38.1 51.12,124.15 51.73,123.54 TC36.1 52.13,123.54 52.52,123.15 53,123.15 53.19,123.33 53.19,123.74 53.26,123.81 v4(53.26,124.07)
PCH_INV_PWM: length 72.4
  TOP w0.119: v1(115.95,105.02) 117.12,105.02 117.46,105.36 D12.3
  IN1 w0.084: v2(61.72,104.66) 61.72,104.18 63.3,102.6 63.94,102.6 64.55,101.99 64.55,101.68 64.84,101.39 68.69,101.39 69.1,100.98 72.13,100.98 72.54,100.57 74.92,100.57 75.63,101.27 76.63,101.27 77.65,102.3 79.29,102.3 80.18,103.18 82.28,103.18 83.97,104.88 88.19,104.88 88.44,105.12 94.3,105.12 95.54,103.88 97.4,103.88 97.61,103.67 99.18,103.67 100.64,102.2 104.66,102.2 105.93,100.94 110.44,100.94 112.25,102.75 112.78,102.75 115.05,105.02 v1(115.95,105.02)
  IN3 w0.084: v2(61.72,104.66) 61.72,104.49 61.49,104.26 61.35,104.26 61.01,103.91 v3(60.96,103.91)
  IN4 w0.06: 60.48,105.83 60.48,105.98 60.8,106.3 60.8,106.53 60.66,106.67 60.66,107.79 60.67,107.8 60.67,108.3 61.72,109.35 61.72,109.68 v5(61.9,109.86)
  IN4 w0.089: v3(60.96,103.91) 60.63,104.24 60.63,104.73 60.48,104.88 60.48,105.83
PCH_JTAG_TCK: length 29.3
  IN1 w0.109: v2(75.82,105.63) 75.98,105.79 76.8,105.79 77.61,104.98 79.15,104.98 79.5,105.34 79.5,105.72 79.89,106.11 81.67,106.11 83.08,107.52 86.13,107.52 86.66,108.04 87.63,108.04 v2(87.76,108.17)
  IN3 w0.06: v2(75.82,105.63) 75.77,105.58 v7(75.77,105.2)
  IN3 w0.084: v2(87.76,108.17) 87.83,108.09 v3(88.09,108.09)
  IN4 w0.089: v4(92.33,103.99) 92.34,103.99 92.34,106.2 92.46,106.32 92.46,107.33 91.57,108.22 88.36,108.22 88.27,108.12 88.09,108.12 v3(88.09,108.09)
  BOTTOM w0.119: v4(92.33,103.99) 92.23,103.88 92.23,103.29 92.71,102.81 RC111.1 ; UC1.B53 76.36,108.95 75.58,108.17 v14(75.58,107.95) 75.58,105.39 v7(75.77,105.2)
PCH_JTAG_TDI: length 30.4
  TOP w0.119: v14(95.75,110.54) 93.94,108.74 v1(93.67,108.74)
  IN1 w0.109: v1(93.67,108.74) 93.33,108.4 v2(93.23,108.4)
  IN3 w0.06: 78.59,106.4 78.52,106.47 77.07,106.47 76.02,107.52 76.02,108.4 v3(75.92,108.5)
  IN3 w0.084: v2(93.23,108.4) 92.99,108.16 v3(92.99,107.97) 92.86,108.1 89.69,108.1 88.86,107.26 88.52,107.26 88.33,107.46 87.24,107.46 86.74,106.96 84.39,106.96 83.83,106.4 78.59,106.4
  IN4 w0.06: v5(75.4,109.95) 75.4,109.46 75.8,109.06 75.8,108.62 v3(75.92,108.5)
  IN4 w0.089: v3(92.99,107.97) 93.09,107.86 93.09,106.65 92.91,106.47 92.91,103.65 v4(92.99,103.57)
  BOTTOM w0.119: RC98.2 93.29,102.99 RC110.1
PCH_JTAG_TDO: length 26.2
  TOP w0.119: v14(92.51,109.01) 92.18,108.68 v1(89.53,108.68)
  IN1 w0.109: v1(89.53,108.68) 89.04,108.18 v2(89.04,108.17)
  IN3 w0.06: v10(75.72,109.71) 75.72,109.54 76.54,108.71 76.54,108.55 77.07,108.02 78.79,108.02 79.54,107.28 80.25,107.28 80.59,107.62 80.94,107.62 81.43,108.1 85.19,108.1 85.55,107.74 87.15,107.74
  IN3 w0.084: v2(89.04,108.17) 89.04,107.88 88.7,107.53 v3(88.65,107.53) 88.44,107.74 87.15,107.74
  IN4 w0.089: v3(88.65,107.53) 89.69,107.53 90.6,106.62 90.6,105.12 91.25,104.48 91.25,103.79 v4(91.34,103.7)
  BOTTOM w0.119: RC115.1 91.34,102.64 v4(91.34,103.7)
PCH_JTAG_TMS: length 9.2
  TOP w0.119: v1(77.65,107.17) 77.52,107.29 v14(77.52,107.74)
  IN1 w0.109: v1(77.65,107.17) 77.43,106.95 77.43,106.93 v2(77.42,106.93)
  IN3 w0.06: v2(77.42,106.93) 77.42,106.93 77.28,107.07 v6(77.28,107.28)
  IN4 w0.06: v4(77.74,103.19) 77.74,103.31 77.74,103.32 77.74,104.85 77.7,104.89 77.7,105.8 77.1,106.4 77.1,107.1 v6(77.28,107.28) 77.28,107.99 76.12,109.14 76.12,109.35 v12(76.04,109.43)
  BOTTOM w0.119: v4(77.74,103.19) 77.74,102.69 77.87,102.56 77.87,102.49 RC120.2
PCH_JTAG_TRST#: length 9.6
  TOP w0.119: v14(79.31,107.17) 79.31,107.17 v1(78.36,107.17)
  IN1 w0.109: v2(78.07,107) 78.19,107 v1(78.36,107.17)
  IN3 w0.06: v6(78.02,107.31) 78.02,107.05 v2(78.07,107)
  IN4 w0.06: v5(76.04,109.95) 76.24,109.75 76.24,109.7 76.36,109.59 76.36,109.39 76.72,109.03 76.72,109.02 76.79,108.95 76.8,108.95 76.8,108.96 77.72,108.96 77.89,108.79 77.89,107.44 v6(78.02,107.31) 78.02,106.93
  IN4 w0.066: v4(78.98,103.77) 78.61,104.15 78.61,106.35 78.32,106.63 78.02,106.93
PCH_JTAGX: length 6.2
  BOTTOM w0.119: UC1.B49 75.07,109.7 75.07,109.3 v14(73.77,108) 73.69,107.91 RC69.2 74.24,107.05 74.35,106.95 74.35,105.48 74.18,105.31 RC86.1
PCH_MUTE#: length 82.7
  IN1 w0.084: v2(23.05,108.64) 23.01,108.68 23.01,109.63 23.8,110.42 27.68,110.42 27.97,110.71 27.97,113.73 27.53,114.17 24.89,114.17 24.43,114.63 24.43,116.49 23.01,117.91 23.01,122.41 22.11,123.31 22.11,126.06 24.43,128.38 v1(24.49,128.38)
  IN3 w0.06: 57.95,113.72 58.25,113.72 58.89,113.72 59.02,113.84 59.52,113.84 60.72,115.04 v10(62.36,115.04)
  IN3 w0.084: v3(23.7,108.77) 23.57,108.64 v2(23.05,108.64) ; 57.95,113.72 56.64,113.72 56.29,113.36 56.29,113.21 56.07,112.99 55.94,112.99 55.67,112.72 54.64,112.72 54.41,112.49 53.35,112.49 52.79,113.06 52.62,113.06 52.41,113.26 52.41,113.67 52.12,113.97 51.67,113.97 51.42,113.72 51.01,113.72 50.9,113.61 50.43,113.61 50.1,113.27 50.1,112.82 49.37,112.1 49.37,111.71 48.25,110.59 v3(48.25,110.59)
  IN4 w0.089: v3(23.7,108.77) 23.7,109.18 24.41,109.9 26.21,109.9 26.95,109.16 27.84,109.16 28.85,110.17 28.85,111.27 29.23,111.64 30.03,111.64 30.43,112.05 32.59,112.05 34.8,109.84 34.8,106.31 35.34,105.77 43.83,105.77 45.72,107.66 46.68,107.66 47.83,108.8 47.83,109.52 48.25,109.94 v3(48.25,110.59)
PCH_OPIRCOMP: length 8.8
  BOTTOM w0.089: UC1.BP16 64.44,124.59 62.86,126.18 59.46,126.18 58.81,126.82 58.67,126.82
  BOTTOM w0.119: RC36.1 58.04,127.46 58.17,127.33 58.67,126.82
PCH_PLTRST#: length 21.5
  IN4 w0.06: 54.7,120.5 55.23,120.5 55.5,120.77 55.71,120.77 55.77,120.84 60.28,120.84 60.33,120.88 60.67,120.88 60.95,121.16 61.51,121.16 61.6,121.26 61.61,121.26 61.64,121.28 61.95,121.28 62.03,121.36 62.24,121.36 v5(62.36,121.48)
  IN4 w0.089: 54.7,120.5 53.64,121.56 53.12,121.56 51.94,122.74 50.2,122.74 49.57,123.37 49.57,124.2 49.33,124.44 48.58,124.44 v4(48.45,124.56)
  BOTTOM w0.119: UH3.2 48.01,125.77 47.58,125.34 RH73.2 ; RH73.2 47.78,125.12 UH3.1 ; RH73.2 47.56,124.22 RH82.2 RH81.1 48.08,124.16 48.08,124.37 48.27,124.56 v4(48.45,124.56)
PCH_PWR_EN: length 284.6
  TOP w0.119: PR910.1 179.78,103.06 180.15,103.44 180.15,106.17 180.24,106.26 v1(180.24,108.4)
  IN1 w0.084: v1(180.24,108.4) 180.26,108.37 v2(180.59,108.37) ; 30.15,114.42 28.65,114.42 27.69,115.38 27.69,121.25 v2(29.18,122.75) ; 30.15,114.42 34.61,114.42 v1(35.14,114.95) ; 30.15,114.42 30.15,112.02 30.67,111.5 30.67,111.04 28.78,109.15 28.78,101.51 31.12,99.17 32.84,99.17 34.65,97.35 v2(34.65,95.16)
  IN2 w0.079: v2(93.62,100.9) 93.4,101.13 88.25,101.13 87.64,100.52 85.51,100.52 81.82,96.83 81.82,94.21 79.53,91.92 46.94,91.92 45.57,93.3 44.78,93.3 44.46,92.98 44.46,92.67 43.67,91.87 42.63,91.87 41.11,90.35 v2(41.11,89.88)
  IN3 w0.084: v2(41.11,89.88) 40.78,90.21 40.78,92.89 40.4,93.27 37.85,93.27 37.2,93.92 35.9,93.92 v2(34.65,95.16) ; v7(171.02,120.18) 171.02,120.13 169.56,118.67 169.56,115 160.97,106.41 150.39,106.41 149.91,105.93 v3(148.78,105.93) ; v3(93.28,100.82) 93.37,100.9 v2(93.62,100.9) ; v3(184.77,107.57) 180.95,107.57 v3(180.58,107.94) 180.58,108.35 v2(180.59,108.37)
  IN3 w0.254: v7(29.77,123.12) 29.56,123.12 v2(29.18,122.75)
  IN4 w0.089: v7(171.02,120.18) 170.8,119.96 170.8,111.64 175.45,106.99 177.33,106.99 177.62,106.7 179.3,106.7 180.58,107.97 v3(180.58,107.94) ; v3(148.78,105.93) 148.78,105.59 148.24,105.05 146.56,105.05 146.53,105.08 145.22,105.08 142.37,107.94 139.61,107.94 139.43,107.76 136.87,107.76 136.69,107.94 131.46,107.94 130.97,107.45 130.45,107.45 128.78,105.78 128.78,105.28 128.55,105.06 127.07,105.06 126.55,104.54 125.58,104.54 122.61,101.56 120.15,101.56 118.43,103.28 116.26,103.28 113.34,100.36 111.52,100.36 111.38,100.22 109.25,100.22 109.14,100.12 104.88,100.12 104.8,100.04 99.95,100.04 99.77,100.22 99.24,100.22 98.89,99.87 98.23,99.87 97.8,100.3 95.32,100.3 94.89,100.74 94,100.74 93.84,100.9 93.37,100.9 v3(93.28,100.82) ; v4(188.47,134.51) 188.26,134.51 188.18,134.59 185.13,134.59 184.37,133.84 184.37,133.46 184.37,133.46 184.37,131.14 184.97,130.54 184.97,126.11 185.88,125.2 191.67,125.2 193.35,123.52 194.3,123.52 195.12,122.7 195.12,115.3 194.12,114.31 194.12,111.93 192.98,110.79 191.66,110.79 188.32,107.45 184.89,107.45 v3(184.77,107.57)
  BOTTOM w0.119: U34.H13 188.74,134.24 v4(188.47,134.51) ; PR813.2 v7(171.02,120.18)
PCH_PWROK: length 92.5
  IN1 w0.084: v2(54.82,128.22) 55.07,128.47 56.55,128.47 56.7,128.62 57.83,128.62 59.59,130.38 60.5,130.38 63.02,132.9 65.19,132.9 65.53,132.55 68.21,132.55 69.32,133.66 71.82,133.66 72.42,133.06 74.43,133.06 75.01,132.48 76.58,132.48 77.15,133.06 85.47,133.06 86.95,134.53 94.93,134.53 v2(95.37,134.97)
  IN3 w0.084: v2(54.82,128.22) 55.39,128.22 56.07,127.55 56.32,127.55 v7(56.36,127.51) ; v7(94.98,115.89) 94.98,120.62 96.15,121.79 96.15,123.18 97.02,124.05 97.02,125.35 98.24,126.57 98.24,127.51 97.92,127.83 97.92,131.27 96.94,132.25 96.94,133.4 v2(95.37,134.97)
  BOTTOM w0.076: UC1.BP14 62.42,125.9 59.29,125.9 58.72,126.47 58.57,126.47 58.07,126.97 57.4,126.97 57.21,127.16 56.72,127.16 v7(56.36,127.51)
  BOTTOM w0.119: UH5.4 92.05,107.13 92.47,107.55 92.47,109.08 T25.1 93.38,109.25 93.73,108.91 93.73,107.61 93.9,107.43 95.1,107.43 95.39,107.72 95.39,115.48 v7(94.98,115.89)
PCH_RSMRST#: length 239
  TOP w0.119: v1(41.17,126.46) 41.67,126.46 42.25,125.87 45.03,125.87 T12.1 45.69,125.92 45.96,126.19 RH24.2 45.96,127.26 RH21.1
  IN1 w0.109: v1(41.17,126.46) 41.17,117.31 43.27,115.21 43.27,109.94 42.32,108.99 42.32,103.99 44.67,101.63 44.67,99.54 45.59,98.62 46.62,98.62 47.84,99.84 51.07,99.84 51.95,98.95 54.5,98.95 55.99,97.46 60.93,97.46 61.98,96.42 61.98,96.03 62.75,95.25 77.05,95.25 78.01,96.21 81.26,96.21 83.46,98.41 85.2,98.41 85.58,98.8 85.88,98.8 v2(86.66,99.58) 87.46,98.79 93.21,98.79 93.32,98.9 102.6,98.9 103.58,97.92 104.27,97.92 v2(104.28,97.91)
  IN3 w0.084: v2(104.28,97.91) 104.3,97.88 v3(104.71,97.88) ; v2(86.66,99.58) 86.72,99.53 v3(86.99,99.53)
  IN4 w0.089: v4(189.64,130.52) 189.64,129.81 189.97,129.48 190.58,129.48 191.84,128.21 192.66,128.21 193.79,127.08 194.7,127.08 196.21,125.57 197.54,125.57 199.2,123.91 199.2,115.01 196.84,112.65 196.84,108.34 194.51,106.01 190.58,106.01 189.1,104.54 184.88,104.54 182.37,102.02 180.97,102.02 180.33,101.39 174.95,101.39 174.23,102.1 170.22,102.1 169.76,102.56 168,102.56 165.65,100.22 163.01,100.22 162.66,100.57 154.66,100.57 154.19,100.1 150.43,100.1 148.8,101.73 143.79,101.73 142.95,102.57 138.65,102.57 137.16,101.08 129.84,101.08 128.08,102.83 127.72,102.83 126.01,101.12 125.45,100.56 115.35,100.56 114.05,99.26 109.78,99.26 109.69,99.16 105.7,99.16 104.71,98.17 v3(104.71,97.88) ; v4(87.92,102.4) 87.92,101.19 87.83,101.11 87.83,101.09 87.41,100.66 87.22,100.66 86.71,100.16 86.71,99.65 86.83,99.53 v3(86.99,99.53)
  BOTTOM w0.119: v4(189.64,130.52) 189.54,130.52 189.2,130.86 189.2,131.62 U34.N12 ; v4(87.92,102.4) 86.64,102.4 86.51,102.28 RC122.1
PCH_RSMRST#_R: length 20.9
  TOP w0.119: RH21.2 47.68,127.29 v9(47.7,127.27)
  GND1 w0.112: v9(47.7,127.27) 47.7,127.7 v2(47.75,127.75)
  GND3 w0.112: v8(48.08,127.68) 47.82,127.68 v2(47.75,127.75)
  IN4 w0.06: 56.11,127.82 56.47,127.82 56.86,127.43 56.99,127.43 57.48,126.94 57.93,126.94 58.47,126.4 58.8,126.4 59.52,125.68 61.63,125.68 63.1,124.2 63.24,124.2 63.36,124.08 63.36,123.38 v5(63.48,123.26)
  IN4 w0.084: 51.39,128.45 51.78,128.06 55.87,128.06 56.11,127.82
  IN4 w0.089: 51.39,128.45 50.95,128.45 50.17,129.23 49.15,129.23 48.71,128.78 48.71,128.31 v8(48.08,127.68)
PCH_RTCX1: length 14.4
  BOTTOM w0.112: 60.49,126.77 63.23,126.77 65.19,124.81 65.31,124.81 65.41,124.7 UC1.BN19
  BOTTOM w0.119: YH1.1 55.58,129.53 56.08,129.53 RH60.1 56.24,130.08 56.34,130.18 57.93,130.18 58.01,130.1 CH9.1 58.34,129.68 58.47,129.56 58.47,128.79 60.49,126.77
PCH_RTCX2: length 15.6
  BOTTOM w0.119: UC1.BP18 65.09,124.57 63.1,126.56 60.24,126.56 CH10.1 57.61,129.2 56.67,129.2 RH60.2 55.96,128.49 55.96,128.21 55.68,127.94 54.58,127.94 53.47,129.05 YH1.2
PCH_SPI1_CLK: length 11.5
  IN1 w0.109: v2(53.67,107.91) 53.97,108.22 v1(54.05,108.22)
  IN3 w0.06: 58.63,110.72 58.81,110.72 59.66,111.56 60.28,111.56 61.27,112.56 62.11,112.56 62.34,112.79 62.6,112.79 62.61,112.79 v10(62.61,112.79)
  IN3 w0.084: v2(53.67,107.91) 56.47,110.72 58.63,110.72
PCH_SPI1_CS#: length 14.2
  IN1 w0.109: v2(53.81,106.02) 54.05,105.78 v1(54.05,105.55)
  IN3 w0.084: v3(54.14,105.31) 53.92,105.52 53.81,105.64 v2(53.81,106.02)
  IN4 w0.06: 57.72,106.4 57.72,106.23 57.21,105.73 ; v5(61.87,112.47) 61.75,112.47 61.73,112.44 61.64,112.44 61.46,112.27 61.29,112.27 61.21,112.34 61.05,112.34 58.25,109.55 58.25,106.94
  IN4 w0.066: 58.25,106.94 57.72,106.4
  IN4 w0.089: 57.21,105.73 57,105.51 57,105.27 56.76,105.03 54.42,105.03 v3(54.14,105.31)
PCH_SPI1_IO2: length 19.8
  TOP w0.119: v1(52.16,108.8) 52.16,109.04 52.7,109.59 53.57,109.59 RC25.2
  IN1 w0.109: v2(51.69,108.69) 51.81,108.8 v1(52.16,108.8)
  IN3 w0.06: v10(63.35,114.4) 63.38,114.37 63.68,114.37 63.93,114.11 63.93,112.82 63.7,112.59 63.5,112.59 63.43,112.67 63.26,112.67 63.18,112.59 63.02,112.59 62.9,112.7 62.9,112.78 62.69,112.99 62.37,112.99 62.06,112.68 61.22,112.68 60.23,111.68 59.61,111.68 58.89,110.97 58.78,110.97
  IN3 w0.084: 58.78,110.97 56.38,110.97 56.28,110.86 53.28,110.86 51.69,109.28 v2(51.69,108.69)
PCH_SPI1_IO3: length 22.7
  TOP w0.119: v1(54.53,104.54) 54.41,104.66 RC32.2
  IN1 w0.109: v1(54.53,104.54) 54.76,104.54 54.97,104.74 v2(54.97,104.71)
  IN3 w0.084: v2(54.97,104.71) 54.93,104.68 v3(54.5,104.68)
  IN4 w0.06: 53.16,111.91 53.45,111.91 53.77,111.59 54.91,111.59 55.52,112.2 56.93,112.2 56.97,112.16 59.1,112.16 60.82,113.88 61.21,113.88 61.29,113.95 61.3,113.95 61.99,113.95 v5(62.11,114.08)
  IN4 w0.089: 53.16,111.91 53,111.91 52.66,111.57 52.17,111.57 51.89,111.29 51.89,109.49 51.92,109.46 51.92,107.29 51.88,107.25 51.88,104.59 52.03,104.45 54.27,104.45 v3(54.5,104.68)
PCH_SPI1_MISO: length 10.8
  TOP w0.119: RC28.2 54.43,107.33 v1(54.69,107.58)
  IN1 w0.109: v2(54.61,107.94) 54.61,107.66 v1(54.69,107.58)
  IN3 w0.06: v10(62.36,112.47) 62.19,112.47 62.16,112.44 61.32,112.44 60.33,111.44 59.71,111.44 58.79,110.53 58.64,110.53
  IN3 w0.084: 58.64,110.53 57.19,110.53 54.61,107.95 v2(54.61,107.94)
PCH_SPI1_MOSI: length 12.3
  IN1 w0.109: v2(54.38,106.21) 54.25,106.21 v1(54.05,106.42)
  IN3 w0.084: v3(54.27,105.86) 54.27,106.1 v2(54.38,106.21)
  IN4 w0.06: v5(61.13,112.79) 61.13,112.79 61.13,112.79 60.98,112.79 59.08,110.89 58.71,110.89 58.7,110.87 ; 57.6,107.51 57.28,107.19
  IN4 w0.066: 58.7,110.87 57.51,109.68 57.51,107.86 57.6,107.77 57.6,107.51
  IN4 w0.089: v3(54.27,105.86) 56.07,105.86 56.12,105.81 56.35,105.81 56.69,106.15 56.69,106.66 56.83,106.8 56.89,106.8 57.28,107.19
PCH_SPI_CLK: length 39.5
  TOP w0.119: JSPI1.8 53.21,147.07 53.3,146.98 53.3,145.95 52.81,145.46 v1(52.33,145.46) ; RC6.1 48.67,141.18 v1(49.17,140.67) R9.1 ; RC16.1 v1(45.49,122.09)
  IN1 w0.109: v1(52.33,145.46) 52.33,142.06 51.2,140.93 49.66,140.93 49.39,140.67 v1(49.17,140.67) 49.17,140.55 48.09,139.47 48.09,138.07 48.58,137.59 48.58,135.46 48.03,134.92 48.03,134.71 47.4,134.08 47.4,133.91 47.74,133.57 47.74,133.39 47.55,133.2 47.4,133.2 47.18,133.42 47,133.42 46.87,133.29 46.87,133.11 47.09,132.89 47.09,132.74 46.18,131.83 46.18,129.76 46.07,129.65 45.42,129.65 45.29,129.52 45.29,129.34 45.42,129.21 46.07,129.21 46.18,129.1 46.18,128.89 46.07,128.78 45.57,128.78 45.46,128.67 45.46,128.45 45.57,128.34 46.07,128.34 46.18,128.23 46.18,128.01 46.07,127.9 45.57,127.9 45.46,127.79 45.46,127.57 45.57,127.47 46.07,127.47 46.18,127.36 46.18,127.14 46.07,127.03 45.57,127.03 45.46,126.92 45.46,126.7 45.57,126.59 46.07,126.59 46.18,126.48 46.18,126.18 46.09,126.09 45.57,126.09 45.46,125.98 45.46,125.71 45.63,125.54 45.63,124.48 45.48,124.33 45.48,122.1 v1(45.49,122.09)
PCH_SPI_CLK_R: length 31.9
  TOP w0.119: RC16.2 47.73,122.09 47.91,121.91 47.91,121.22 48.02,121.11 48.39,121.11 48.5,121.23 48.5,121.97 48.67,122.14 48.79,122.14 49.01,122.36 49.26,122.36 49.38,122.24 49.38,121.58 49.5,121.45 49.85,121.45 49.97,121.58 49.97,122.24 50.09,122.36 50.45,122.36 50.57,122.24 50.57,121.61 50.7,121.48 51.04,121.48 51.17,121.6 51.17,122.24 51.29,122.36 52.44,122.36 v1(53.14,123.05)
  IN1 w0.109: v1(53.14,123.05) 53.3,123.05 53.57,122.77 54.46,122.77 54.76,122.47 55.65,122.47 55.97,122.79 55.97,123.48 55.8,123.64 55.19,123.64 54.86,123.31 53.97,123.31 53.85,123.43 53.85,123.62 53.29,124.19 52.29,124.19 52.14,124.04 52.14,123.89 52.71,123.31 53.03,123.31 v2(53.13,123.41)
  IN3 w0.06: v10(62.85,120.2) 62.64,120.2 62.44,120.39 62.29,120.39 62.05,120.63 61.77,120.63 61.73,120.68 61.16,120.68 60.27,121.57 60.02,121.57 59.8,121.57 59.01,122.36 56.64,122.36 55.41,123.59 55.12,123.59
  IN3 w0.084: 55.12,123.59 53.51,123.59 53.34,123.41 v2(53.13,123.41)
PCH_SPI_CS0#: length 66.1
  TOP w0.119: v1(54.71,148.35) 54.21,147.85 JSPI1.10
  IN1 w0.109: v2(42.75,121.75) 42.19,122.31 42.19,128.29 42.66,128.76 42.66,130.58 42.66,130.77 42.66,131.95 42.67,131.96 42.67,133.65 42.75,133.73 42.75,134.53 42.45,134.83 42.45,139.26 44.58,141.39 v1(44.6,141.39) 44.98,141.39 45.77,142.19 45.77,143.46 50.55,148.24 54.59,148.24 v1(54.71,148.35)
  IN3 w0.084: v3(44.53,120.74) 44.53,121.16 44.31,121.38 43.12,121.38 v2(42.75,121.75)
  IN4 w0.06: 54,119.37 54.41,119.37 54.61,119.17 55.76,119.17 56.18,119.6 58.48,119.6 59,120.12 60.7,120.12 60.78,120.2 v5(61.37,120.2)
  IN4 w0.089: v3(44.53,120.74) 45.11,120.74 45.2,120.65 45.2,120.38 45.29,120.29 45.47,120.29 45.55,120.38 45.55,120.65 45.64,120.74 46.69,120.74 46.78,120.65 46.78,119.82 46.89,119.71 47.03,119.71 47.14,119.82 47.14,121.31 47.24,121.41 47.39,121.41 47.49,121.31 47.49,119.79 47.6,119.69 47.74,119.69 47.85,119.79 47.85,120.75 47.97,120.87 48.14,120.87 48.26,120.75 48.26,119.45 48.36,119.34 48.51,119.34 48.62,119.45 48.62,120.65 48.71,120.74 48.86,120.74 50.03,121.91 50.64,121.91 50.64,121.91 51.02,121.91 51.03,121.91 51.62,121.91 52.77,120.76 52.77,120.19 53.59,119.37 54,119.37
PCH_SPI_CS1#: length 60.2
  TOP w0.119: v1(50.21,146.75) JSPI1.2
  IN1 w0.109: v2(42.78,122.28) 43.13,122.64 43.13,123.33 43.33,123.53 43.33,124.17 42.82,124.68 42.82,125.7 42.93,125.81 43.11,125.81 43.22,125.92 43.22,126.14 43.11,126.25 42.93,126.25 42.82,126.36 42.82,126.58 42.93,126.69 43.11,126.69 43.22,126.79 43.22,127.01 43.11,127.12 42.93,127.12 42.82,127.23 42.82,128.26 43.13,128.57 43.13,130.77 43.13,130.97 43.13,131.75 43.19,131.82 43.19,133.51 43.33,133.65 43.33,133.92 43.46,134.05 43.69,134.05 43.82,134.18 43.82,134.91 43.66,135.07 43.66,135.67 43.54,135.79 43.1,135.79 42.98,135.92 42.98,136.1 43.1,136.23 43.54,136.23 43.66,136.36 43.66,136.42 44.98,137.74 44.98,137.92 44.81,138.09 44.53,138.09 43.23,136.78 43.07,136.78 42.92,136.93 42.92,138.93 44.85,140.86 45.39,140.86 45.77,141.24 45.77,141.5 46.38,142.1 v1(46.38,142.28) 46.39,142.29 46.39,143.41 49.73,146.75 v1(50.21,146.75)
  IN3 w0.06: v10(61.87,120.2) 61.6,120.2 61.48,120.32 60.98,120.32 60.09,121.21 59.87,121.21 59.65,121.21 58.86,122 56.36,122 55.45,122.9 55.12,122.9
  IN3 w0.084: 55.12,122.9 53.76,122.9 53.43,122.57 52.12,122.57 51.95,122.74 49.42,122.74 48.57,121.89 46.96,121.89 46.75,121.68 45.51,121.68 45.43,121.77 45.43,121.89 45.33,121.99 45.19,121.99 45.09,121.89 45.09,121.77 45.01,121.68 44.84,121.68 44.76,121.77 44.76,122.23 44.66,122.33 44.52,122.33 44.42,122.23 44.42,121.77 44.34,121.68 44.17,121.68 44.09,121.77 44.09,122.36 44,122.44 43.84,122.44 43.75,122.36 43.75,121.77 43.67,121.68 43.38,121.68 v2(42.78,122.28)
PCH_SPI_CS2#: length 85.7
  TOP w0.119: R10.1 48.97,139.61 v1(49.17,139.41)
  IN1 w0.109: v1(26.72,126.6) v2(26.72,127.14) ; v2(49.17,139.01) v1(49.17,139.41)
  IN2 w0.079: v2(42.97,123.68) 42.68,123.68 42.39,123.97 42.39,128.53 42.57,128.71 42.57,129.18 43.37,129.98 43.37,131.83 43.83,132.28 43.83,132.4 43.37,132.85 43.37,132.98 43.46,133.08 43.6,133.08 44.02,132.65 44.2,132.65 44.32,132.77 44.32,132.95 43.45,133.82 43.45,133.92 43.57,134.05 43.68,134.05 44.44,133.29 44.57,133.29 44.66,133.38 44.66,133.52 43.9,134.27 43.9,134.38 44.02,134.49 44.13,134.49 44.54,134.08 44.67,134.08 44.76,134.17 44.76,134.3 44.35,134.72 44.35,134.83 46.87,137.34 48.1,137.34 49.17,138.42 v2(49.17,139.01)
  IN3 w0.06: v10(62.36,120.2) 62.32,120.2 62,120.51 61.62,120.51 61.58,120.56 61.1,120.56 60.21,121.45 59.97,121.45 59.75,121.45 58.96,122.24 56.52,122.24 55.44,123.32 55.12,123.32
  IN3 w0.084: 55.12,123.32 53.58,123.32 53.33,123.07 53.27,123.07 53.27,123.06 52.42,123.06 52.04,123.44 52.04,124.49 51.82,124.7 51.16,124.7 51.05,124.81 50.84,124.81 50.68,124.97 50.18,124.97 49.92,124.72 48.56,124.72 47.29,123.44 43.78,123.44 43.54,123.68 v3(43.46,123.68) v2(42.97,123.68) ; v2(26.72,127.14) v3(26.72,126.7)
  IN4 w0.089: v3(43.46,123.68) 43.27,123.48 41.07,123.48 40.82,123.73 40.82,124.59 43.54,127.3 43.54,133.31 42.72,134.13 31.03,134.13 28.07,131.17 28.07,130.77 26.72,129.43 v3(26.72,126.7)
PCH_SPI_CS2#_R: length 1.5
  TOP w0.119: R12.2 50.4,138.77 U2.20
PCH_SPI_IO2: length 81.4
  TOP w0.119: v1(55.71,148.73) 55.71,148.5 55.21,148 JSPI1.12 ; RC13.1 44.07,122.68 44.77,123.38 44.77,125.17 44.57,125.37 44.02,125.37 43.89,125.24 43.89,123.1 43.57,122.79 43.23,122.79 43.09,122.93 43.09,123.23 42.86,123.46 42.56,123.46 v1(42.51,123.51)
  IN1 w0.109: v1(55.71,148.73) 54.98,148 50.65,148 46.01,143.36 46.01,142.07 45.5,141.55 45.5,141.52 v1(45.49,141.39) 45.49,141.29 45.31,141.11 44.77,141.11 42.69,139.03 42.69,134.93 42.99,134.63 42.99,133.63 42.91,133.55 42.91,131.87 42.89,131.85 42.89,130.87 42.89,130.68 42.89,128.66 42.57,128.34 42.57,124.36 v2(42.73,124.2) 42.57,124.03 42.57,123.57 v1(42.51,123.51)
  IN3 w0.06: 55.12,124.4 55.19,124.33 55.19,123.88 55.27,123.8 55.49,123.8 55.82,123.47 55.91,123.47 56.3,123.86 56.4,123.86 56.47,123.79 56.47,123.69 56.07,123.3 56.07,123.21 56.81,122.48 59.23,122.48 59.9,121.81 60.12,121.81 60.12,121.81 60.44,121.81 60.87,121.37 61.8,121.37 62.38,120.8 62.59,120.8 62.76,120.63 62.99,120.63 v10(63.1,120.52)
  IN3 w0.084: v2(42.73,124.2) 42.98,124.44 43.17,124.44 43.29,124.31 43.29,124.08 43.42,123.95 43.61,123.95 43.74,124.08 43.74,124.72 43.84,124.82 43.98,124.82 44.08,124.72 44.08,123.75 44.18,123.65 44.31,123.65 44.41,123.75 44.41,124.82 44.51,124.92 44.65,124.92 44.75,124.82 44.75,123.75 44.85,123.65 44.98,123.65 45.08,123.75 45.08,125.3 45.18,125.4 45.32,125.4 45.42,125.3 45.42,123.78 45.54,123.65 47.15,123.65 47.33,123.84 47.33,124.73 47.53,124.93 49.83,124.93 50.09,125.18 50.76,125.18 50.93,125.02 51.14,125.02 51.27,124.89 51.9,124.89 52.11,124.67 52.3,124.67 52.38,124.59 52.38,123.36 52.48,123.26 52.62,123.26 52.72,123.36 52.72,124.59 52.8,124.67 52.97,124.67 53.05,124.59 53.05,123.86 53.15,123.76 53.29,123.76 53.39,123.86 53.39,124.59 53.47,124.67 54,124.67 54.26,124.42 54.38,124.42 54.42,124.37 54.42,123.92 54.51,123.82 54.64,123.82 54.74,123.92 54.74,124.33 54.83,124.42 55.1,124.42 55.12,124.4
PCH_SPI_IO3: length 64.7
  TOP w0.119: JSPI1.14 56.21,147.85 56.67,148.31 v1(56.67,148.38)
  IN1 w0.109: v2(44.48,125.26) 44.48,128.42 44.31,128.59 44.31,131.26 44.37,131.33 44.37,133.02 44.82,133.47 45.03,133.47 45.17,133.33 45.17,133 45.26,132.92 45.71,132.92 45.89,133.09 45.89,134.49 45.8,134.58 45.58,134.58 45.38,134.78 45.38,135.43 47.27,137.32 47.27,137.51 47.1,137.68 47.1,139.87 48.02,140.79 48.02,141.04 48.02,141.04 48.02,142.44 48.68,143.1 48.94,143.1 49.13,142.91 49.13,142.58 49.45,142.26 50.42,142.26 v1(50.52,142.36) 50.96,142.79 50.96,143.88 51.35,144.27 51.35,145.76 52.6,147.01 55.56,147.01 56.67,148.12 v1(56.67,148.38)
  IN3 w0.06: v10(63.59,120.52) 63.38,120.52 63.15,120.76 63.15,120.83 63.05,120.92 63.05,120.92 62.94,121.04 62.48,121.04 61.9,121.61 61.1,121.61 60.09,122.63 59.57,122.63 59.49,122.72 59.05,122.72 59,122.77 59,123.2 58.93,123.27 58.79,123.27 58.73,123.21 58.73,122.83 58.67,122.77 58.55,122.77 58.49,122.83 58.49,123.21 58.43,123.27 58.31,123.27 58.25,123.21 58.25,122.83 58.19,122.77 58.07,122.77 58.01,122.83 58.01,123.21 57.95,123.27 57.45,123.27 57.27,123.09 57.21,123.09 57.12,123.18 57.12,123.28 57.2,123.36 57.2,123.46 57.09,123.57 57.01,123.57 56.8,123.36 56.68,123.36 56.62,123.42 56.62,123.51 56.84,123.74 56.84,123.82 56.68,123.98 56.25,123.98 55.97,123.7 55.76,123.7 55.39,124.07 55.39,124.39 55.31,124.47 55.15,124.63 55.12,124.63
  IN3 w0.084: v2(44.48,125.26) 44.48,125.27 44.86,125.65 46.52,125.65 46.65,125.51 46.65,123.93 46.71,123.87 47.05,123.87 47.12,123.93 47.12,125.06 47.2,125.14 48.63,125.14 48.76,125.27 48.76,125.48 48.87,125.59 49.02,125.59 49.14,125.48 49.14,125.27 49.26,125.14 49.75,125.14 50,125.39 50.09,125.39 50.15,125.46 50.15,125.67 50.26,125.78 50.41,125.78 50.52,125.67 50.52,125.52 50.65,125.39 50.85,125.39 51.01,125.23 51.22,125.23 51.37,125.07 51.97,125.07 52.19,124.86 54.11,124.86 54.34,124.63 55.12,124.63
PCH_SPI_SCLK: length 1.5
  TOP w0.119: U2.19 50.61,139.27 49.8,140.08 R9.2
PCH_SPI_SI: length 77.9
  TOP w0.119: v1(48.68,138.96) 49.55,138.96 R18.1 ; v1(52.67,144.95) 50.5,144.95 50.24,145.21 50.24,145.45 50.57,145.78 50.83,145.78 51.21,146.16 JSPI1.4
  IN1 w0.109: v2(46.84,140.78) 46.86,140.81 46.86,140.81 47.27,141.21 v1(47.27,141.39) ; v1(52.67,144.95) 52.82,144.8 52.82,141.86 51.39,140.43 50.88,140.43 50.33,139.88 49.25,139.88 48.68,139.32 v1(48.68,138.96) 48.68,138.44 v2(48.55,138.31) 49.07,137.79 49.07,135.26 48.64,134.84 48.64,134.27 48.23,133.86 48.23,133.18 46.67,131.63 46.67,123.54 46.53,123.4 46.1,123.4 45.97,123.27 45.97,121.88 45.73,121.63 45.67,121.63 45.07,121.03 45.07,120.74 44.95,120.62 44.95,118.81 44.9,118.76 44.9,117.34 45.31,116.92 46.57,116.92 46.86,117.21 v2(47.24,117.21)
  IN3 w0.084: v2(46.84,140.78) 46.84,142.08 46.97,142.2 48.42,142.2 48.55,142.08 48.55,141.66 48.47,141.57 47.58,141.57 47.5,141.49 47.5,141.32 47.58,141.24 48.47,141.24 48.55,141.16 48.55,140.99 48.47,140.9 47.58,140.9 47.5,140.82 47.5,140.65 47.58,140.57 48.47,140.57 48.55,140.48 48.55,140.32 48.47,140.23 47.58,140.23 47.5,140.15 47.5,139.98 47.58,139.9 48.47,139.9 48.55,139.81 48.55,139.65 48.47,139.56 48.08,139.56 47.98,139.46 47.98,139.33 48.08,139.23 48.47,139.23 48.55,139.14 v2(48.55,138.31) ; v2(47.24,117.21) 47.24,117.31 v7(47.04,117.52)
  IN4 w0.06: 54,118.67 54.22,118.88 55.88,118.88 56.35,119.36 58.58,119.36 59.1,119.88 60.36,119.88 60.36,119.87 v5(61.13,119.87)
  IN4 w0.089: 54,118.67 53.86,118.53 52.76,118.53 52.32,118.09 51.88,118.09 51.65,117.86 48.04,117.86 47.68,117.51 47.53,117.51 47.15,117.89 47.15,118.78 47.07,118.86 46.14,118.86 45.41,118.13 45.41,117.6 45.62,117.38 46.91,117.38 v7(47.04,117.52)
  BOTTOM w0.119: v7(47.04,117.52) 47.1,117.58 RC49.1
PCH_SPI_SI_MOSI: length 1.2
  TOP w0.119: R18.2 49.91,138.27 U2.21
PCH_SPI_SO: length 66.6
  TOP w0.119: R25.1 50.08,135.75 v1(50.29,135.55) ; v1(49.94,143.04) 49.94,142.79 50.04,142.69 50.04,141.56 49.87,141.39 RC7.1 ; JSPI1.6 52.21,146.58 50.95,145.33 v1(50.53,145.33)
  IN1 w0.109: v2(44.63,135.94) 46.39,137.71 46.39,139.57 46.39,140.85 46.48,140.94 46.48,141.03 46.7,141.24 46.7,141.35 47.27,141.92 47.27,143.28 47.95,143.97 48.86,143.97 50.22,145.33 v1(50.53,145.33) 50.53,144.45 49.94,143.86 v1(49.94,143.04) ; v1(50.29,135.55) 50.29,136.25 50.52,136.49 v2(50.52,136.59)
  IN2 w0.079: v2(42.77,122.82) 42.77,122.91 42.18,123.49 42.18,128.61 42.37,128.8 42.37,129.26 43.17,130.07 43.17,134.03 44.62,135.49 44.62,135.94 v2(44.63,135.94)
  IN3 w0.06: 55.12,123.11 55.47,123.11 56.46,122.12 58.91,122.12 59.7,121.33 59.92,121.33 60.14,121.33 61.03,120.44 61.53,120.44 61.57,120.39 61.95,120.39 62.16,120.18 62.16,120.11 62.28,120 62.44,120 62.45,120 62.45,120 62.52,120.07 62.69,120.07 62.77,120 62.94,120 63.06,120.12 63.27,120.12 v10(63.35,120.2)
  IN3 w0.084: 55.12,123.11 53.67,123.11 53.44,122.88 52.34,122.88 51.15,124.07 50.77,124.07 50.77,124.07 50.63,124.07 50.63,124.07 49.33,124.07 49.05,123.79 48.31,123.79 47.65,123.13 47.59,123.13 47.28,122.82 v2(42.77,122.82) ; v2(50.52,136.59) 50.52,136.82 v3(50.39,136.95) ; v2(44.63,135.94) 44.6,135.96 v3(44.6,136.31)
  IN4 w0.089: v3(44.6,136.31) 44.68,136.23 49.98,136.23 50.19,136.44 50.19,136.74 v3(50.39,136.95)
PCH_SPI_SO_R: length 3.7
  TOP w0.119: U2.24 50.96,136.48 51.13,136.31 51.13,135.4 51,135.27 50.75,135.27 50.62,135.4 50.62,136.11 50.39,136.34 R25.2
PCH_SRTCRST#: length 18.7
  TOP w0.119: T13.1 55.38,125 56.72,125 57.34,125.62 57.34,127.03 57.14,127.23 RH23.2 57.21,127.73 CH5.1 57.64,128.86 v1(57.64,129.1)
  IN1 w0.109: v1(57.64,129.1) 57.63,129.1 v2(57.63,129.45)
  IN3 w0.084: v2(57.63,129.45) 57.56,129.53 v3(57.56,129.78)
  IN4 w0.06: v3(57.56,129.78) 57.92,129.42 57.92,128.64 59.92,126.64 62.23,126.64 63.62,125.24 63.63,125.24 63.63,125.2 63.83,125 63.97,125 64.34,124.63 64.34,124.26 64.89,123.71 64.89,123.42 65.09,123.22 v5(65.09,123.01)
PCH_STROBE_OUT: length 125.9
  IN1 w0.084: v1(127.81,121.38) v2(128.17,121.38)
  IN2 w0.079: v2(94.26,101.29) 93.9,101.65 87.71,101.65 87.07,101.01 85.48,101.01 81.32,96.85 81.32,94.24 79.38,92.29 55.79,92.29 55.33,92.75 55.33,94.15 55.32,94.17 55.32,94.58 54.55,95.34 52.65,95.34 v2(51.89,96.1)
  IN3 w0.084: v2(94.26,101.29) 94.75,101.29 v3(94.83,101.21) ; v2(51.89,96.1) 51.54,96.46 51.54,97.35 53.9,99.71 53.9,104.63 v3(53.8,104.72) ; v3(128.15,115.2) 128.61,115.66 128.61,116.13 127.75,116.99 127.75,120.57 128.17,120.98 v2(128.17,121.38)
  IN4 w0.06: 56.67,105.76 56.67,105.83 56.73,105.89 56.73,105.92 57.07,106.26 57.23,106.26 57.43,106.47 57.61,106.47 57.95,106.81 v4(57.95,107.12) 58.13,107.3 58.13,109.6 61,112.47 v5(61.37,112.47)
  IN4 w0.089: 56.67,105.76 56.49,105.58 54.25,105.58 54.25,105.58 53.93,105.58 53.8,105.46 v3(53.8,104.72) ; v3(94.83,101.21) 94.96,101.21 95.48,100.68 97.35,100.68 97.78,101.11 100.86,101.11 101.66,101.91 106.86,101.91 107.97,100.8 108.81,100.8 108.91,100.9 110.82,100.9 110.98,101.07 112.26,101.07 113.6,102.41 113.6,104.01 115.53,105.94 115.53,107.18 116.17,107.82 116.18,107.82 118.17,109.81 118.17,110.96 120.18,112.98 123.36,112.98 124.54,114.15 127.1,114.15 v3(128.15,115.2)
  BOTTOM w0.119: RH116.1 58,105.95 57.78,106.17 57.78,106.57 57.95,106.74 v4(57.95,107.12)
PCH_WWAN_WAKE#: length 208.9
  TOP w0.119: v1(198.83,128.44) 201.48,128.44 202.44,129.4 202.44,131.08 203.74,132.37 204.7,132.37 205.75,133.42 205.75,135.58 205.91,135.74 206.11,135.74 208.31,137.94 208.31,142.2 207.48,143.03 206.18,143.03 205.81,142.66 204.55,142.66 204.28,142.92 204.28,143.35 204,143.63 202.86,143.63 202.67,143.44 R4.1
  IN1 w0.084: v1(198.83,128.44) 190.86,128.44 188.76,130.54 188.76,131.08 187.43,132.41 184.99,132.41 183.8,131.23 183.8,130.97 180.78,127.96 170.79,127.96 170,128.74 160.15,128.74 158.64,130.25 156.32,130.25 155.35,131.21 152.37,131.21 151.92,130.76 150.27,130.76 148.82,129.3 148.82,128.37 148.04,127.59 146.1,127.59 143.8,125.29 143.38,125.29 141.4,123.3 137.79,123.3 137.51,123.02 136.44,123.02 133.12,119.7 131.22,119.7 131.06,119.85 123.94,119.85 123.4,119.32 121.81,119.32 121.72,119.41 120.57,119.41 120.31,119.15 120.31,118.78 119.21,117.69 115.82,117.69 115.25,118.25 115.25,119.02 115.05,119.23 115.05,120.58 112.23,123.4 112.23,124.68 111.47,125.44 111.47,126.21 109.19,128.49 107.44,128.49 106.9,129.04 106.39,129.04 104.7,130.72 101.67,130.72 100.47,129.53 97.54,129.53 97.35,129.34 96.1,129.34 94.67,127.91 94.67,127.36 93.82,126.5 93.21,126.5 92.34,125.64 88.89,125.64 88.48,125.23 87.09,125.23 86.97,125.35 86.94,125.35 86.09,126.2 86.09,126.22 85.4,126.91 85.35,126.91 85.3,126.97 80.8,126.97 80.55,126.72 70.86,126.72 70.29,127.29 67.37,127.29 66.54,126.46 64.26,126.46 61.53,123.74 61.53,123.5 60.89,122.86 60.89,122.85 60.76,122.72 60.76,121.99 60.29,121.53 59.14,121.53 58.72,121.12 58.17,121.12 56.06,121.12 55.48,120.53 55.48,118.53 v2(55.8,118.2)
  IN3 w0.06: v10(63.35,117.62) 63.15,117.82 62.77,117.82 62.65,117.7 62.57,117.7 62.17,117.3 60.55,117.3 60.42,117.43 59.89,117.43 59.87,117.45 59.87,117.68 59.58,117.97 59.44,117.97 ; 59.44,117.97 59.44,117.97 59.44,117.97 ; 59.44,117.97 57.15,117.97 56.54,118.58
  IN3 w0.084: v7(55.7,117.71) 55.7,118.1 v2(55.8,118.2) 55.8,118.19 56.19,118.58 56.54,118.58
PCIE_DE1: length 2.6
  TOP w0.119: R135.2 R134.2 211.43,118.56 211.54,118.45 U14.3
PCIE_DE2: length 7.6
  TOP w0.119: U14.16 211.54,113.35 212.04,112.85 213.96,112.85 215.4,111.41 215.4,110.49 R147.2 R153.2
PCIE_ENRXD: length 2.9
  TOP w0.119: R137.2 209.5,118.51 210.25,118.51 210.54,118.21 U14.5
PCIE_EQ1: length 3.4
  TOP w0.119: R136.2 214.12,119.43 R132.2 212.6,118.81 212.2,118.81 212.04,118.65 U14.2
PCIE_EQ2: length 8
  TOP w0.119: U14.17 212.04,113.25 212.22,113.07 214.05,113.07 215.67,111.46 216.13,111.46 216.4,111.19 216.4,110.49 R148.2 R154.2
PCIE_OS1: length 2.8
  TOP w0.119: R138.2 209.63,119.42 R133.2 211.04,118.9 U14.4
PCIE_OS2: length 7.5
  TOP w0.119: U14.15 211.04,113.31 211.26,113.08 211.5,113.08 211.95,112.63 213.85,112.63 214.4,112.08 214.4,110.51 R146.2 R152.2
PCIE_PRX_DTX_N6: length 163.9
  TOP w0.119: v13(205.62,114.38) 205.79,114.55 206.24,114.55 C134.1
  IN2 w0.079: v13(205.62,114.38) 205.38,114.61 203.82,114.61 200.62,111.41 200.62,107.54 197.8,104.72 182.55,104.72 181.98,104.15 158.83,104.15 158.03,104.95 152.94,104.95 152.14,104.15 149.11,104.15 148.19,103.23 146.69,103.23 145.79,104.12 142.51,104.12 137.88,108.75 136.35,108.75 133.2,111.9 132.88,111.9 130.76,114.03 130.76,114.37 129.96,115.17 128.81,115.17 128.11,114.47 122.57,114.47 113.58,105.48 112.51,105.48 111.57,104.54 107.45,104.54 107.32,104.41 106.23,104.41 105.63,105.01 98.13,105.01 95.28,107.86 89.53,107.86 89.3,107.63 83,107.63 81.53,106.16 79.04,106.16 78.71,105.83 76.2,105.83 75.87,106.16 75.76,106.16 75.55,106.37 74.91,106.37 73.93,107.35 72.12,107.35 71.19,106.42 71.19,105.91 70.85,105.57 70.23,105.57 69.86,105.95 69.65,105.95 69.54,105.84 v2(69.54,105.74)
  IN3 w0.06: v3(69.06,105.91) 69.06,106 69.16,106.1 69.33,106.1 69.54,105.89 v2(69.54,105.74)
  IN4 w0.06: v3(69.06,105.91) 69.06,105.99 69.01,106.04 68.84,106.04 68.67,106.21 68.67,107.42 67.87,108.23 67.87,109.67 67.9,109.71 v5(67.99,109.71)
