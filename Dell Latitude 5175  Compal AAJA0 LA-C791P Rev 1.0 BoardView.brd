# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
STROBE_IN: length 7.5
  TOP w0.119: v1(127.37,122.76) R126.2
  IN1 w0.084: v1(127.37,122.76) 127.47,122.76 v2(127.72,123.01) ; v2(130,127.47) 130.16,127.64 v1(130.16,127.78)
  IN3 w0.084: v2(130,127.47) 129.49,127.47 128.63,126.61 128.63,125.75 127.3,124.42 127.3,123.41 127.7,123.01 v2(127.72,123.01)
SUS_ON: length 3
  TOP w0.119: v1(191.35,134.54) 191.39,134.58 191.82,134.58 191.92,134.49 R33.1
  IN1 w0.084: v2(191.29,134.2) 191.35,134.26 v1(191.35,134.54)
  IN3 w0.084: v2(191.29,134.2) 191.35,134.15 191.35,133.76 v3(191.36,133.75)
  IN4 w0.06: v4(191.32,132.74) 191.32,132.81 191.57,133.06 191.57,133.42 191.36,133.62 v3(191.36,133.75)
SUS_ON_EC: length 293.9
  TOP w0.119: v1(110.03,100.64) 110.41,101.01 110.41,108.97 110.42,108.98 110.42,109.3 110.38,109.35 110.38,124.75 110.46,124.84 110.46,130.29 110.24,130.52 107.87,130.52 107.66,130.3 R63.2 107.66,129.77 107.5,129.61 U7.5 ; v14(125.29,119.66) 125.29,117.8 125.79,117.29 PR708.1 126.26,117.2 127.03,116.44 v1(127.67,116.44) ; v1(191.95,135.96) 191.92,135.93 R23.2 191.92,135.05 R33.2 ; v1(78.75,101.93) 79.1,101.93 79.62,102.46 U23.1
  IN1 w0.084: v1(127.67,116.44) 127.8,116.56 128.75,116.56 128.93,116.38 128.93,115.34 128.27,114.68 128.27,113.71 128.82,113.16 129.48,113.16 v2(129.64,112.99) ; v2(198.2,137.02) 197.71,136.54 194.31,136.54 193.73,135.96 v1(191.95,135.96) ; v2(217.46,102.17) 216.1,102.17 215.45,102.82 211.71,102.82 210.88,101.99 202.56,101.99 v2(202.46,101.89) 202.11,101.54 197.35,101.54 196.55,102.34 193.22,102.34 192.59,101.71 190.59,101.71 190.07,102.23 181.18,102.23 178.47,99.52 171.7,99.52 171.01,100.21 166.03,100.21 165.26,100.98 154.47,100.98 152.33,98.84 140.21,98.84 138.73,100.33 136.71,100.33 136.17,100.87 136.08,100.96 135.88,101.16 135.67,101.37 135,101.37 133.61,102.76 133.61,103.5 132.64,104.47 129.53,104.47 v2(129.03,104.97) 128.91,105.1 116.46,105.1 116.1,104.74 115.05,104.74 112.87,102.56 112.32,102.56 110.43,100.66 110.06,100.66 v1(110.03,100.64) 109.92,100.75 105.85,100.75 104.59,102.02 100.57,102.02 99.1,103.48 97.54,103.48 97.33,103.69 95.24,103.69 93.99,104.94 88.55,104.94 88.28,104.66 84.02,104.66 82.36,103 80.26,103 79.19,101.93 v1(78.75,101.93) 78.75,101.92 77.88,101.92 v2(77.34,101.39)
  IN2 w0.079: v2(198.2,137.02) 199.54,137.02 200.08,137.56 201.97,137.56 202.93,138.51 207.42,138.51 209.15,140.24 213.19,140.24 220.02,133.41 220.02,119.55 219.6,119.14 219.6,116.7 219.6,116.52 220.06,116.06 220.06,104.36 217.88,102.17 v2(217.46,102.17)
  IN3 w0.084: v7(202.59,101.51) 202.46,101.64 v2(202.46,101.89) ; v7(129.77,112.64) 129.77,112.87 v2(129.64,112.99) ; v2(77.34,101.39) 76.91,101.39 v3(76.76,101.23) ; v3(129.77,105.7) 129.77,105.52 129.55,105.3 129.36,105.3 129.18,105.12 129.15,105.12 129.03,105 v2(129.03,104.97)
  IN4 w0.089: v4(75.69,97.5) 75.71,97.52 75.71,98.21 75.97,98.47 75.97,99.09 76.85,99.97 76.85,101.14 v3(76.76,101.23) ; v3(129.77,105.7) 129.77,106.17 v4(129.8,106.2)
  BOTTOM w0.119: R465.1 65.63,94.88 65.8,94.71 74.48,94.71 75.27,95.5 75.27,97.07 v4(75.69,97.5) ; v7(202.59,101.51) 202.43,101.35 JUSH1.3 ; v7(129.77,112.64) 129.97,112.44 129.97,106.37 v4(129.8,106.2)
SUSACK#: length 167.6
  IN1 w0.084: v2(51.69,124.34) 52.01,124.66 54.27,124.66 54.81,124.12 56.75,124.12 57.25,123.62 58.24,123.62 60.09,125.47 60.96,125.47 64.68,129.19 66.72,129.19 66.83,129.08 70.4,129.08 70.81,129.5 71.67,129.5 72.41,128.75 77.05,128.75 77.72,129.42 82.91,129.42 83.64,130.15 86.51,130.15 88.17,131.81 89.71,131.81 90.37,131.15 93.12,131.15 93.7,131.73 97.43,131.73 97.68,131.47 99.33,131.47 100.04,132.18 106.26,132.18 106.34,132.1 110.25,132.1 111.8,130.56 111.8,129.52 114.29,127.03 116.67,127.03 117.03,126.67 117.03,126.42 118.5,124.95 118.5,123.38 119.35,122.53 119.5,122.53 120.34,121.69 126.47,121.69 127.25,122.46 128.01,122.46 129.14,123.6 129.42,123.6 130.15,124.33 130.66,124.33 131.94,125.61 132.9,125.61 135.04,127.75 137.85,127.75 138.19,128.09 142.45,128.09 143.11,128.76 143.11,129.43 143.93,130.25 145.21,130.25 145.49,129.96 146.6,129.96 147.39,130.75 148.05,130.75 149.8,132.51 167.85,132.51 167.86,132.5 167.88,132.5 171.81,128.56 180.34,128.56 183.06,131.28 183.06,131.72 184.52,133.18 187.71,133.18 189.5,131.39 189.5,130.84 189.74,130.61 192.31,130.61 v2(194.46,132.77)
  IN3 w0.084: v2(194.46,132.77) 194.5,132.74 v7(194.82,132.74) ; v2(51.69,124.34) 51.74,124.29 v7(51.74,123.99)
  BOTTOM w0.119: T21.1 52.52,123.46 51.99,123.99 v7(51.74,123.99)
SUSACK#_R: length 11.1
  IN4 w0.06: v5(62.61,122.46) 62.5,122.57 62.28,122.57 62.11,122.74 61.95,122.74 61.8,122.89 60.94,122.89 60.87,122.81 60.82,122.81 60.71,122.93 59.9,122.93 59.83,122.86 59.15,122.86 59.13,122.85 59.13,122.85 59.12,122.84 59.11,122.84 59.05,122.79 58.21,122.79 58.08,122.65 57.55,122.65 57.06,123.14 57.06,123.43 56.75,123.74 56.29,123.74
  IN4 w0.089: 56.29,123.74 55.62,123.74 55.57,123.8 55.36,123.8 55.36,123.81 55.14,123.81 54.81,124.14 v4(53.89,124.14)
  BOTTOM w0.119: RH78.2 53.44,124.4 53.01,124.4 RH79.2
SUSCLK: length 245.9
  TOP w0.119: R121.2 54.47,122.72 55.44,123.69 C118.1 55.5,123.97 RH26.2 MC1.2 54.13,124.63 v1(54.53,125.03) ; v1(210.49,130.8) 210.49,131.4 R51.2
  IN1 w0.084: v2(98.04,132.65) 97.96,132.74 87.79,132.74 86.19,131.15 77.87,131.15 77.35,130.63 76.32,130.63 75.38,129.68 72.8,129.68 72.05,130.43 71.08,130.43 70.81,130.7 65.92,130.7 65.57,130.34 64.34,130.34 60.66,126.67 58.88,126.67 58.71,126.5 58.47,126.5 57.98,126.01 57.18,126.01 57.06,125.89 55,125.89 54.53,125.42 v1(54.53,125.03) 52.41,125.03 52.29,124.91 51.44,124.91 v2(50.95,124.42) ; v1(210.49,130.8) 210.49,133.34 208.52,135.32 208.52,140.69 208.7,140.87 208.7,141.48 208.48,141.7 207.29,141.7 204.11,144.87 202.81,144.87 202.34,145.34 v2(197.73,145.34)
  IN3 w0.084: v2(98.04,132.65) 98.04,135.48 96.14,137.38 v3(96.14,137.56) ; v2(50.95,124.42) 50.77,124.6 50.75,124.6 50.59,124.76 50.29,124.76 50.02,124.49 48.63,124.49 47.37,123.23 43.56,123.23 43.43,123.36 43.14,123.36 43.11,123.33 42.79,123.33 42.4,122.94 42.4,121.08 43.43,120.05 43.43,117.06 44.21,116.28 44.21,110.62 v3(44.07,110.48) ; v2(197.73,145.34) v3(197.15,145.34)
  IN4 w0.089: v3(44.07,110.48) 43.27,109.68 41.52,109.68 41.21,109.37 40.07,109.37 40.06,109.39 35.52,109.39 32.67,112.24 30.35,112.24 29.96,111.85 29.06,111.85 28.47,111.26 28.48,111.26 v4(28.49,111.27) ; v3(197.15,145.34) 196.12,145.34 195.53,145.93 186.07,145.93 183.27,143.13 183.27,141.7 182.42,140.85 182.42,138.85 180.43,136.86 179.84,136.86 179.32,136.35 179.32,135.14 177.09,132.91 174.09,132.91 169.75,137.25 135.73,137.25 132.85,134.37 132.13,134.37 130.83,133.07 127.75,133.07 126.99,133.83 126.52,133.83 124.17,136.18 124.17,136.3 123.2,137.28 106.07,137.28 104.66,138.69 97.52,138.69 96.39,137.56 v3(96.14,137.56)
  BOTTOM w0.119: R409.2 26.7,110.12 27.07,110.5 27.49,110.5 C295.1 27.69,110.59 28.37,111.27 v4(28.49,111.27)
SUSCLK_L: length 2.6
  TOP w0.119: v1(208.99,131.89) 209.32,131.56 R51.1
  IN1 w0.084: v1(208.99,131.89) 209.01,131.91 v2(209.36,131.91)
  IN3 w0.084: v7(210.51,131.46) 210.02,131.46 209.57,131.91 v2(209.36,131.91)
SUSWARN#: length 253.2
  IN3 w0.084: v7(51.36,126.25) 51,126.62 48.22,126.62 47.92,126.31 47.39,126.31 47.04,126.65 41.28,126.65 40.87,126.24 40.87,116.91 42.45,115.33 42.45,111.42 41.7,110.67 41.7,96.16 42.7,95.16 42.7,93.87 42.5,93.67 42.5,89.91 v3(42.35,89.77)
  IN4 w0.089: v4(174.47,96.31) 174.5,96.33 175.82,96.33 178.26,98.78 182.6,98.78 186.71,102.89 190.18,102.89 190.76,103.47 195.17,103.47 196.49,104.79 196.49,104.98 198.43,106.91 199.01,106.91 200.08,107.98 200.08,111.91 202.36,114.19 202.36,120.09 203.05,120.78 203.05,124.91 199.61,128.34 198.49,128.34 197.19,129.64 197.19,130.76 196.55,131.4 196.55,131.71 196.12,132.15 196.12,133.48 195.29,134.31 194.39,134.31 v12(194.32,134.24) ; v4(174.44,93.56) 166.94,93.56 166.14,92.77 155.01,92.77 154.37,92.13 111.53,92.13 111.14,92.52 98.16,92.52 97.4,93.28 87.82,93.28 86.59,92.06 86.59,91.82 84.89,90.12 43.75,90.12 43.4,89.77 v3(42.35,89.77)
  BOTTOM w0.119: v4(174.47,96.31) 174.47,93.6 v4(174.44,93.56) ; RH77.1 51.51,125.06 51.36,125.21 v7(51.36,126.25) 51.26,126.35 51.26,126.54 50.88,126.92 50.54,126.92 50.18,127.28 T19.1
SUSWARN#_R: length 11.6
  IN4 w0.06: v5(61.9,123.66) 61.75,123.66 61.55,123.46 61.37,123.46 61.26,123.56 61.26,123.78 61.16,123.88 60.83,123.88 60.78,123.93 60.48,123.93 60.35,123.8 59.58,123.8 59.32,123.55 59.27,123.55 59.23,123.5 58.35,123.5 57.08,124.77 56.25,124.77
  IN4 w0.089: 56.25,124.77 56.18,124.77 55.97,124.98 55.9,125.05 55.77,125.18 55.53,125.18 55.37,125.34 53.76,125.34 53.62,125.48 v4(53.62,125.68)
  BOTTOM w0.119: RH77.2 52.96,124.98 RH78.1 53.77,125.34 53.62,125.49 v4(53.62,125.68) RH70.2
SVID_ALERT#: length 62.1
  TOP w0.119: PR1108.2 PR1115.1 114.21,119.92 113.4,119.92 113.28,120.03 113.28,121.08 114.05,121.85 v1(117.67,121.85)
  IN1 w0.109: v1(117.67,121.85) 117.73,121.85 v2(118.08,121.49)
  IN3 w0.084: v7(80.47,105.7) 80.64,105.88 81.06,105.88 81.11,105.93 81.54,105.93 81.59,105.88 84.32,105.88 84.55,105.65 87.92,105.65 88.39,106.12 89.62,106.12 90.67,107.17 92.47,107.17 92.59,107.04 103.31,107.04 104.3,108.04 106.28,108.04 106.73,107.59 110.97,107.59 111.29,107.9 111.94,107.9 112.46,108.42 114.51,108.42 119.02,112.92 119.02,116.24 119.54,116.76 119.54,118.45 118.3,119.69 118.3,121.27 v2(118.08,121.49)
  BOTTOM w0.119: RC90.2 80.76,104.52 RC79.2 80.04,105.27 v7(80.47,105.7)
SVID_CLK: length 56.4
  TOP w0.119: v1(117.44,121.06) 117.43,121.06 115.67,121.06 115.49,120.88 PR1111.2 PR1117.1
  IN1 w0.109: v2(117.8,120.56) 117.8,120.69 v1(117.44,121.06)
  IN3 w0.084: v2(117.8,120.56) 117.8,119.5 119.07,118.23 119.07,116.95 118.55,116.43 118.55,113.12 114.32,108.88 112.26,108.88 111.75,108.37 111.09,108.37 110.78,108.06 106.92,108.06 106.47,108.5 104.11,108.5 103.15,107.54 98.85,107.54 98.76,107.63 90.55,107.63 89.31,106.39 88.34,106.39 88.16,106.57 88.16,107.05 88.04,107.18 87.29,107.18 86.84,106.72 84.49,106.72 83.93,106.16 79.86,106.16 79.59,105.9 v7(79.59,105.7)
  BOTTOM w0.119: v7(79.59,105.7) 79.59,105.58 79.46,105.45 79.35,105.45 RC80.2
SVID_DAT: length 58
  TOP w0.119: v9(115.49,118.58) 115.43,118.52 PR1113.1
  GND1 w0.119: v9(115.49,118.58) 115.49,119.04 v11(116.14,119.69)
  IN1 w0.109: v2(118.77,120.48) 118.36,120.07 117.14,120.07 116.69,119.62 116.2,119.62 v11(116.14,119.69)
  IN3 w0.084: v7(81.43,105.57) 81.43,105.51 81.55,105.63 84.24,105.63 84.24,105.62 84.25,105.62 84.48,105.39 87.98,105.39 88.47,105.87 90.01,105.87 90.84,106.7 92.28,106.7 92.4,106.58 103.5,106.58 104.49,107.57 106.09,107.57 106.54,107.13 111.17,107.13 111.48,107.44 112.14,107.44 112.65,107.95 114.7,107.95 119.48,112.73 119.48,116.05 120,116.57 120,118.64 119.25,119.4 119.25,119.4 118.77,119.88 v2(118.77,120.48)
  BOTTOM w0.119: v7(81.43,105.57) 81.25,105.57 RC78.2 81.25,104.92 81.25,104 81.18,103.93 RC96.1
SWP: length 5.9
  IN1 w0.084: v2(216.4,97.71) v1(216.08,98.03)
  IN3 w0.084: v7(216.41,97.25) 216.41,97.26 216.41,97.45 216.4,97.46 v2(216.4,97.71)
  BOTTOM w0.119: JNFC1.20 215.14,94.96 216.41,96.23 v7(216.41,97.25)
SYS_PRES#: length 72.5
  TOP w0.119: v14(176.04,117.85) 176.04,118.48 176.41,118.85 v1(178.29,118.85)
  IN1 w0.084: v2(196.04,108.88) 194.64,108.88 194.31,109.21 194.31,111.42 190.5,115.23 182.44,115.23 180.66,117.01 179.96,117.01 178.29,118.67 v1(178.29,118.85)
  IN3 w0.084: v3(195.86,108.55) 195.86,108.7 v2(196.04,108.88)
  IN4 w0.089: v7(154.79,101.21) 154.95,101.04 162.85,101.04 163.21,100.69 165.31,100.69 167.69,103.06 v15(169.02,103.06) 174.88,103.06 176.05,101.89 178.2,101.89 178.97,102.67 182.35,102.67 184.74,105.06 185.17,105.06 185.17,105.06 188.78,105.06 190.21,106.49 194.29,106.49 195.86,108.06 v3(195.86,108.55)
SYS_PWROK: length 219.2
  IN1 w0.084: v2(51.81,115.81) 53.1,117.11 54.39,117.11 55.58,115.92 55.58,115.48 55.03,114.93 55.03,114.31 55.47,113.87 55.47,113.14 55.63,112.99 55.63,112.09 57.86,109.85 57.86,108.91 58.86,107.91 59.8,106.97 60.46,106.97 61.18,106.26 61.18,106.25 61.18,105.75 60.64,105.2 60.64,103.42 62.02,102.03 62.35,102.03 62.7,101.68 63.31,101.68 64.08,100.92 64.08,100.31 65.19,99.2 67.53,99.2 68.43,100.1 72.05,100.1 72.49,99.66 76.91,99.66 77.11,99.86 77.96,99.86 78.67,100.56 79.91,100.56 81.19,101.85 83.37,101.85 84.92,103.4 87.04,103.4 87.12,103.32 88.57,103.32 88.84,103.58 93.73,103.58 94.79,102.52 95.73,102.52 95.99,102.27 95.99,101.96 96.24,101.7 99.26,101.7 100.09,100.87 104.11,100.87 106.21,98.78 113.28,98.78 114.79,100.29 118.53,100.29 119.23,100.99 120.81,100.99 121.88,99.92 135.5,99.92 136.24,99.19 138.26,99.19 139.74,97.7 158.37,97.7 159.64,98.97 168.53,98.97 v2(168.83,98.67)
  IN2 w0.079: v2(47.62,116.19) 47.63,116.18 48.52,116.18 49.22,115.49 50.87,115.49 51.19,115.81 v2(51.81,115.81)
  IN3 w0.084: v3(46.98,116.18) 47.62,116.18 v2(47.62,116.19) ; v2(168.83,98.67) 169.24,99.07 v3(169.24,99.12)
  IN4 w0.089: v3(46.98,116.18) 46.74,116.18 46.33,115.78 45.18,115.78 44.16,114.76 44.16,111.15 44.36,110.95 44.36,110.35 43.5,109.49 41.66,109.49 41.16,108.99 v4(40.89,108.99) ; v3(169.24,99.12) 169.54,99.43 174.74,99.43 175.23,99.92 181.69,99.92 185.8,104.03 189.26,104.03 190.77,105.54 194.84,105.54 197.31,108.01 197.31,111.57 199.86,114.12 199.86,124.59 198.21,126.23 197.02,126.23 195.5,127.76 194.05,127.76 192.16,129.65 192.16,130.91 v4(191.9,131.18)
  BOTTOM w0.119: RH105.2 39.23,108.98 T27.1 39.76,108.99 v4(40.89,108.99) ; v4(191.9,131.18) 191.82,131.26 U34.N7
SYS_RESET#: length 8.3
  BOTTOM w0.119: RH111.2 55.65,106 56.97,107.31 RH106.2 57.25,107.5 57.53,107.78 58.08,107.78 59.33,109.04 59.33,110.23 60.33,111.23 60.49,111.23 60.5,111.23 60.72,111.23 60.72,111.23 60.83,111.23 UC1.H2
TBAT_3V3: length 17.6
  TOP w0.119: v1(148.83,103.38) 148.83,103.96 147.56,105.23 v14(146.23,105.23)
  IN1 w0.084: v1(148.83,103.38) 149.18,103.72 153.97,103.72 v2(154.17,103.53)
  IN3 w0.084: v6(153.46,104.05) 153.64,104.05 v2(154.17,103.53)
  IN4 w0.089: v4(153.99,103.29) 153.46,103.82 v6(153.46,104.05) v4(153.46,104.7)
  BOTTOM w0.119: v4(153.99,103.29) 155.16,103.29 156.04,102.42 JT100.6 ; PD101.2 152.01,105.63 PR109.1 152.81,105.38 153.46,104.72 v4(153.46,104.7)
TMDS_L_TX0N: length 13.8
  TOP w0.119: JHDMI1.11 10.87,51.95 10.92,51.9 11.06,51.9 v13(11.24,52.09)
  IN3 w0.084: v13(11.24,52.09) 11.5,51.83 12.04,51.83 12.38,51.49 12.61,51.49 13.01,51.89 13.3,51.89 13.76,51.43 13.76,51.18 13.2,50.62 13.2,50.44 13.32,50.32 13.5,50.32 14.13,50.96 14.44,50.96 14.66,50.74 14.66,50.43 13.98,49.75 13.98,49.58 14.57,49 14.71,49 14.86,49.15 14.86,49.32 14.65,49.54 14.65,49.69 14.65,49.69 14.65,49.82 14.83,50.01 15.08,50.01 15.27,49.82 16.09,49.82 16.27,50 v7(16.27,50.13)
  BOTTOM w0.119: v7(16.27,50.13) 16.36,50.13 16.66,49.83 16.98,49.83 LX2.3
TMDS_L_TX0P: length 13.9
  TOP w0.119: v13(11.24,51.5) 11.1,51.64 10.92,51.64 10.83,51.55 JHDMI1.9
  IN3 w0.084: v7(16.27,49.27) 16.27,49.52 16.13,49.66 15.2,49.66 15.02,49.84 14.9,49.84 14.81,49.76 14.81,49.61 15.02,49.39 15.02,49.26 15.02,49.08 14.77,48.83 14.64,48.83 14.5,48.83 13.82,49.51 13.82,49.82 14.5,50.5 14.5,50.67 14.37,50.79 14.2,50.79 13.56,50.16 13.25,50.16 13.04,50.38 13.04,50.68 13.6,51.25 13.6,51.36 13.23,51.73 13.08,51.73 12.68,51.33 12.32,51.33 11.98,51.67 11.4,51.67 v13(11.24,51.5)
  BOTTOM w0.119: LX2.2 16.97,49.57 16.6,49.57 16.29,49.27 v7(16.27,49.27)
TMDS_L_TX1N: length 12.8
  IN3 w0.084: v7(16.29,48.4) 16.34,48.35 16.34,48.05 16.24,47.95 15.87,47.95 15.7,48.11 14.67,48.11 11.91,50.87 10.11,50.87 9.3,50.06 8.64,50.06 8.42,50.28 8.42,51.17 8.6,51.35 JHDMI1.8
  BOTTOM w0.119: v7(16.29,48.4) 16.66,48.04 17.03,48.04 LX3.3
TMDS_L_TX1P: length 12.8
  IN3 w0.084: v7(16.29,47.54) 16.29,47.7 16.21,47.78 15.8,47.78 15.63,47.95 14.6,47.95 11.85,50.7 10.17,50.7 9.37,49.9 8.57,49.9 8.26,50.22 8.26,51.04 8.14,51.16 7.79,51.16 JHDMI1.6
  BOTTOM w0.119: v7(16.29,47.54) 16.53,47.78 17,47.78 17.3,47.47 LX3.2
TMDS_L_TX2N: length 10.1
  TOP w0.119: JHDMI1.5 10.78,50.75 10.87,50.66 11.3,50.66 11.67,50.3 11.67,49.94 11.67,49.94 v13(11.79,49.82)
  IN3 w0.084: v7(16.29,46.65) 15.98,46.33 14.49,46.33 11.56,49.27 11.56,49.6 v13(11.79,49.82)
  BOTTOM w0.119: v7(16.29,46.65) 16.29,46.64 16.66,46.27 17.08,46.27 LX4.3
TMDS_L_TX2P: length 10
  TOP w0.119: v13(11.2,49.85) 11.39,50.04 11.39,50.2 11.19,50.4 10.87,50.4 10.82,50.35 JHDMI1.3
  IN3 w0.084: v7(16.29,45.79) 15.91,46.17 14.42,46.17 11.39,49.2 11.39,49.78 11.33,49.85 v13(11.2,49.85)
  BOTTOM w0.119: v7(16.29,45.79) 16.44,45.79 16.66,46.01 16.98,46.01 LX4.2
TMDS_L_TXCN: length 12.3
  IN3 w0.084: JHDMI1.14 7.82,52.31 8.23,52.31 8.3,52.38 8.3,53.27 8.61,53.58 9.98,53.58 10.51,53.06 12.89,53.06 13.03,53.06 14.5,51.58 15.67,51.58 15.95,51.85 16.2,51.85 v7(16.36,52.01)
  BOTTOM w0.119: LX1.3 17.13,51.88 16.96,51.71 16.48,51.71 16.36,51.83 v7(16.36,52.01)
TMDS_L_TXCP: length 12.4
  IN3 w0.084: v7(16.36,51.15) 16.36,51.51 16.18,51.69 16.02,51.69 15.74,51.42 14.44,51.42 12.96,52.89 10.44,52.89 9.92,53.42 8.68,53.42 8.46,53.2 8.46,52.19 8.5,52.15 JHDMI1.12
  BOTTOM w0.119: v7(16.36,51.15) 16.36,51.23 16.57,51.45 16.75,51.45 17.17,51.03 LX1.2
TMDS_TX0N: length 32.5
  TOP w0.119: U25.24 24.92,75.65 v1(24.86,75.71)
  IN1 w0.109: v1(24.86,75.71) 24.95,75.62 25.08,75.62 25.34,75.88 v2(25.35,75.88)
  IN3 w0.084: v7(18.97,50.12) 19.3,49.8 19.71,49.8 19.87,49.96 19.87,50.81 21.26,52.2 21.26,75.01 21.9,75.65 25.12,75.65 v2(25.35,75.88)
TMDS_TX0P: length 32.5
  TOP w0.119: U25.25 24.92,75.25 v1(24.84,75.33)
  IN1 w0.109: v1(24.84,75.33) 24.89,75.39 25.29,75.39 v2(25.36,75.32)
  IN3 w0.084: v2(25.36,75.32) 25.19,75.49 21.97,75.49 21.42,74.94 21.42,52.13 20.03,50.74 20.03,49.89 19.77,49.63 19.33,49.63 v7(18.97,49.27)
TMDS_TX1N: length 32.7
  TOP w0.119: U25.26 24.75,74.85 v1(24.74,74.86)
  IN1 w0.109: v2(25.08,74.86) v1(24.74,74.86)
  IN3 w0.084: v2(25.08,74.86) 24.9,74.68 22.37,74.68 21.82,74.12 21.82,51.98 20.42,50.58 20.42,48.61 19.72,47.91 19.4,47.91 v7(19,48.31)
TMDS_TX1P: length 32.7
  TOP w0.119: U25.27 v1(24.74,74.45)
  IN1 w0.109: v1(24.74,74.45) 24.95,74.45 v2(25.07,74.33)
  IN3 w0.084: v7(19,47.46) 19.29,47.75 19.79,47.75 20.58,48.54 20.58,50.51 21.98,51.91 21.98,74.06 22.44,74.51 24.88,74.51 v2(25.07,74.33)
TMDS_TX2N: length 32.8
  TOP w0.119: v1(24.75,73.65) U25.29
  IN1 w0.109: v2(25.09,73.7) 25.04,73.65 v1(24.75,73.65)
  IN3 w0.084: v2(25.09,73.7) 24.89,73.5 22.93,73.5 22.38,72.94 22.38,51.76 20.97,50.35 20.97,47.47 19.71,46.21 19.33,46.21 v7(19.02,46.52)
TMDS_TX2P: length 32.9
  TOP w0.119: v1(24.79,73.25) U25.30
  IN1 w0.109: v1(24.79,73.25) 25.02,73.25 v2(25.13,73.14)
  IN3 w0.084: v7(19.02,45.67) 19.4,46.04 19.78,46.04 21.14,47.4 21.14,50.29 22.54,51.69 22.54,72.87 23,73.33 24.93,73.33 v2(25.13,73.14)
TMDS_TXCN: length 31.5
  TOP w0.119: U25.21 24.83,76.85 v1(24.78,76.9)
  IN1 w0.109: v1(24.78,76.9) 24.88,76.99 v2(25.11,76.99)
  IN3 w0.084: v2(25.11,76.99) 24.7,76.58 21.32,76.58 20.7,75.96 20.7,52.42 19.97,51.69 19.27,51.69 v7(19.09,51.88)
TMDS_TXCP: length 31.5
  TOP w0.119: v1(24.74,76.45) U25.22
  IN1 w0.109: v2(25.09,76.42) 25.06,76.45 v1(24.74,76.45)
  IN3 w0.084: v2(25.09,76.42) 21.39,76.42 20.86,75.9 20.86,52.35 20.04,51.53 19.46,51.53 19.09,51.15 v7(19.09,51.03)
TP_DDR_DRAM_RST_N: length 6.4
  BOTTOM w0.119: UC1.BP20 65.73,124.83 65.56,125 65.26,125 63.3,126.96 61.32,126.96 TC29.1
TPM_GPIO0: length 11.2
  IN1 w0.084: v2(52.27,134.2) 52.27,134.2 52.27,134.87 52.58,135.17 52.58,135.41 52.89,135.73 53.13,135.73 53.15,135.75 53.43,135.75 53.65,135.97 v1(53.76,135.97)
  IN3 w0.084: v3(52.07,133.19) 52.07,134 v2(52.27,134.2)
  IN4 w0.089: v4(47.27,130.27) 47.27,130.44 47.64,130.81 47.64,131.81 48.08,132.25 51.14,132.25 v3(52.07,133.19)
  BOTTOM w0.119: R358.2 47.47,130.06 v4(47.27,130.27)
TPM_GPIO2: length 58.9
  TOP w0.119: R54.1 v1(25.73,131.19)
  IN1 w0.084: v1(56.06,137.77) 56.35,138.06 57.12,138.06 57.44,137.75 57.44,137.34 57.54,137.25 57.56,137.24 57.66,137.14 57.93,137.14 58.19,137.4 58.19,139.32 56.91,140.6 56.91,145.38 57.55,146.01 57.55,148.82 56.72,149.65 47.27,149.65 46.22,148.6 38.82,148.6 25.02,134.79 25.02,131.9 v1(25.73,131.19)
TPM_GPIO4: length 11
  TOP w0.119: v1(48.82,142.81) 48.41,142.81 48.08,142.48 48.08,140.88 R10.2 ; v1(51.36,142.94) 51.49,142.81 53.58,142.81 53.81,142.59 53.81,142 53.26,141.45 U2.13
  IN1 w0.084: v1(48.82,142.81) 48.82,142.57 49.36,142.03 50.92,142.03 51.36,142.46 v1(51.36,142.94)
TPM_IRQ#: length 48.1
  IN1 w0.084: v2(47.68,124.58) 47.68,125.81 47.26,126.22 47.26,131.5 48.64,132.88 48.64,133.67 49.05,134.08 49.05,134.67 49.54,135.16 49.54,137.33 49.48,137.39 49.48,138.29 v1(50.96,139.77)
  IN2 w0.079: v2(47.68,124.58) 47.68,123.96 47.56,123.84 47.56,123.07 47.08,122.58 46.36,122.58 46.26,122.48 46.26,121.86 46.53,121.58 46.53,116.27 47.43,115.37 47.65,115.37 50.16,112.87 50.83,112.87 51.06,112.64 51.16,112.64 51.17,112.62 51.76,112.62 v2(51.79,112.59)
  IN3 w0.084: v2(51.79,112.59) 51.92,112.46 v3(52.12,112.46)
  IN4 w0.06: 53.16,112.89 53.16,112.89 53.59,113.32 54,113.32 v4(54.23,113.1) 54.62,112.7 55.31,112.7 55.69,113.08 56.3,113.08 56.43,112.94 56.82,112.94 56.96,113.08 57.31,113.08 57.57,113.34 59.6,113.34 60.98,114.72 61.83,114.72 62.03,114.52 62.2,114.52 62.27,114.6 62.44,114.6 62.56,114.48 62.56,114.41 62.81,114.16 62.81,113.99 62.65,113.84 62.65,113.67 62.81,113.52 62.81,113.35 62.65,113.19 62.65,113.03 62.85,112.83 v10(62.85,112.47)
  IN4 w0.089: v3(52.12,112.46) 52.2,112.54 52.81,112.54 53.16,112.89
TS_EN: length 173.4
  IN1 w0.084: v2(53.06,121.3) 53.01,121.25 53.01,120.59 53.31,120.28 53.31,119.26 51.66,117.61 51.66,116.44 51.26,116.03 51.26,115.61 50.63,114.98 50.63,114.71 49,113.08 49,108.11 51.62,105.5 51.62,102.6 53.57,100.64 55.2,100.64 56.52,99.32 61.6,99.32 62.83,98.09 63.9,98.09 64.09,97.91 68.39,97.91 69.13,98.64 71.71,98.64 71.99,98.37 74.38,98.37 74.61,98.14 80.43,98.14 82.39,100.1 84.21,100.1 85.33,101.22 87.89,101.22 88.22,101.55 93.29,101.55 93.38,101.65 94.42,101.65 95.43,100.64 95.95,100.64 96.21,100.9 98.84,100.9 99.6,100.13 102.95,100.13 104.02,99.07 104.76,99.07 105.8,98.03 114.18,98.03 115.86,99.71 121.27,99.71 121.71,99.27 135.34,99.27 136,98.6 137.97,98.6 139.49,97.09 158.81,97.09 159.9,98.19 167.44,98.19 v2(167.46,98.21)
  IN3 w0.084: v3(53.52,121.25) 53.51,121.25 53.46,121.3 v2(53.06,121.3) ; v3(168.21,99.1) 168.21,98.96 v2(167.46,98.21)
  IN4 w0.06: v5(61.37,120.84) 61.33,120.88 61.05,120.88 60.79,120.63 60.41,120.63 60.38,120.6 58.8,120.6 58.72,120.52 56.98,120.52
  IN4 w0.089: v4(181,101.52) 181,101.26 180.04,100.3 175.07,100.3 174.58,99.81 168.83,99.81 168.21,99.19 v3(168.21,99.1) ; 56.98,120.52 55.62,120.52 55.29,120.19 53.95,120.19 53.57,120.57 53.57,121.19 53.52,121.24 v3(53.52,121.25)
  BOTTOM w0.119: U46.3 179.91,102.72 R436.2 181,102.42 v4(181,101.52)
TS_I2C_SCL: length 173.2
  TOP w0.119: R190.1 181.51,100.32 182.29,101.1 184.53,101.1 186.35,102.92 v1(186.35,105.72)
  IN1 w0.109: v1(186.35,105.72) 185.96,106.1 180.72,106.1 180.34,105.72 179.03,105.72 177.07,103.76 168.8,103.76 167.61,104.95 161.2,104.95 160.73,105.42 146.79,105.42 142.66,109.56 136.52,109.56 135.72,108.75 133.17,108.75 133.05,108.87 133.05,110.57 132.27,111.35 131.37,111.35 129.49,109.47 127.02,109.47 125.56,108.01 116.46,108.01 112.62,111.85 111.02,111.85 110.59,112.28 110.59,113.59 110.07,114.11 106.66,114.11 104.04,111.49 104.04,108.37 103.35,107.69 99,107.69 95.91,110.77 85.89,110.77 85.44,110.31 81.91,110.31 80.47,108.87 75.07,108.87 75.04,108.91 72.19,108.91 71.28,109.82 70.71,109.82 70.08,109.18 70.08,108.17 69.82,107.91 68.42,107.91 67.93,107.42 67.93,107.29 67.36,106.72 67.25,106.72 66.97,107 65.79,107 64.33,108.47 64.33,108.83 63.04,110.11 62.1,110.11 61.48,110.73 60.67,110.73 58.06,113.34 57.2,113.34 56.01,114.53 v2(55.56,114.53)
  IN3 w0.06: 56.18,114.45 56.44,114.45 56.66,114.67 58.78,114.67 59.47,115.36 60.37,115.36 60.81,115.8 61.81,115.8 62.04,115.57 62.15,115.57 62.15,115.56 62.2,115.56 62.27,115.49 62.45,115.49 62.52,115.56 62.69,115.56 62.89,115.36 v10(63.1,115.36)
  IN3 w0.084: v7(53.72,114.94) 54.16,114.94 54.47,114.63 55.47,114.63 v2(55.56,114.53) 55.65,114.45 56.18,114.45
TS_I2C_SCL_R: length 18.1
  TOP w0.119: v1(182.09,99.99) 182.24,99.84 182.31,99.84 182.61,99.85 182.84,99.62 183.17,99.62 183.57,100.02 184.15,100.02 184.37,100.23 DI2.3
  IN1 w0.109: v1(182.09,99.99) 181.81,99.71 181.76,99.71 181.76,99.71 v2(181.79,99.71)
  IN2 w0.079: v2(181.79,99.71) 181.94,99.86 182.02,99.86 182.17,99.71 182.17,99.28 181.58,98.69 179.37,98.69 177,96.32 172.43,96.32 171.61,97.13 171.61,97.74 v2(171.81,97.93)
  IN3 w0.084: v2(171.81,97.93) 171.81,98.19 172.03,98.41 v7(172.03,98.48)
TS_I2C_SDA: length 175.2
  TOP w0.119: v1(185.84,105.7) 185.8,105.66 185.8,103.16 184.24,101.61 182.09,101.61 180.95,100.47 180.95,99.79 181.38,99.35 R191.1
  IN1 w0.109: v1(185.84,105.7) 185.73,105.59 180.9,105.59 180.54,105.23 179.24,105.23 177.27,103.27 169,103.27 169,103.27 168.6,103.27 167.41,104.46 160.87,104.46 160.4,104.93 146.35,104.93 142.92,108.36 142.72,108.36 141.9,108.36 141.19,109.07 136.73,109.07 135.92,108.26 132.97,108.26 132.56,108.66 132.56,110.37 132.07,110.86 131.58,110.86 129.69,108.98 127.22,108.98 125.17,106.93 116.31,106.93 116.05,107.19 116.05,107.72 112.41,111.36 110.82,111.36 110.13,112.05 108.03,112.05 106.76,110.78 106.76,106.95 106.09,106.28 104.11,106.28 103.28,107.11 98.81,107.11 95.65,110.27 86.08,110.27 85.62,109.81 82.25,109.81 80.83,108.38 74.85,108.38 74.76,108.47 72.17,108.47 71.16,109.49 70.75,109.49 70.36,109.09 70.36,108.08 69.93,107.65 68.53,107.65 68.19,107.31 68.19,107.18 67.12,106.11 66.4,106.11 66.01,106.11 64.04,108.07 63.82,108.07 62.04,109.85 61.99,109.85 61.38,110.47 60.57,110.47 57.95,113.08 57.09,113.08 56.33,113.85 v2(56.01,113.85)
  IN3 w0.06: v10(62.61,115.36) 62.4,115.36 62.2,115.16 62.03,115.16 61.82,115.37 61.82,115.45 61.7,115.56 60.91,115.56 59.45,114.1 59.27,114.1 58.94,114.43 58.28,114.43 58.23,114.38
  IN3 w0.084: 58.23,114.38 56.92,114.38 56.57,114.02 56.17,114.02 56.01,113.86 v2(56.01,113.85) 55.87,113.71 52.93,113.71 52.89,113.75 52.82,113.75 v7(52.7,113.86)
  BOTTOM w0.119: RC53.1 52.89,114.94 52.75,114.8 52.75,113.9 v7(52.7,113.86)
TS_I2C_SDA_R: length 18.2
  TOP w0.119: DI2.2 184.23,99.75 183.67,99.75 183.28,99.35 182.73,99.35 182.5,99.58 182.22,99.58 182.09,99.46 v1(182.09,99.35)
  IN1 w0.109: v2(182.52,99.71) 182.45,99.71 v1(182.09,99.35)
  IN2 w0.079: v2(182.52,99.71) 182.51,99.71 182.35,99.55 182.35,99.2 181.65,98.5 179.44,98.5 177.07,96.13 172.35,96.13 171.43,97.05 171.43,97.78 v2(171.27,97.93)
  IN3 w0.084: v2(171.27,97.93) 171.64,98.3 171.64,98.37 v7(171.53,98.48)
TS_ID1: length 204.6
  IN2 w0.079: v2(120.65,98.99) 120.42,98.76 120.42,97.07 119.25,95.9 118.89,95.9 118.12,95.13 102.58,95.13 98.45,99.26 96.13,99.26 95.25,100.14 93.55,100.14 93.27,99.87 91.33,99.87 90.67,100.53 88.92,100.53 88.54,100.15 85.66,100.15 82.2,96.68 82.2,94.06 79.65,91.51 46.83,91.51 45.87,92.47 44.53,92.47 43.71,91.66 42.93,91.66 v2(41.88,90.62)
  IN3 w0.084: v2(41.88,90.62) 41.88,90.63 42.31,91.06 42.31,94.5 41.47,95.34 41.47,107.41 41.52,107.46 41.52,110.74 42.27,111.5 42.27,115.25 40.68,116.83 40.68,126.31 41.2,126.84 47.12,126.84 47.46,126.49 47.84,126.49 48.16,126.81 51.21,126.81 51.64,126.38 v3(51.74,126.38)
  GND3 w0.084: v2(120.65,98.99) 120.68,99.01 121.07,99.01 v8(121.31,98.78)
  IN4 w0.06: v4(58.55,123.84) 58.35,123.84 57.14,125.05 56.49,125.05 56.07,125.48
  IN4 w0.089: v4(172.53,98.33) 172.39,98.19 163.09,98.19 161.4,96.5 151.52,96.5 148.14,99.88 143,99.88 142.42,100.45 139.72,100.45 138.56,99.29 133.93,99.29 133.29,98.66 121.43,98.66 v8(121.31,98.78) ; v3(51.74,126.38) 51.76,126.38 52.05,126.09 52.6,126.09 52.65,126.14 53.94,126.14 54.06,126.01 54.54,126.01 54.71,125.84 55.6,125.84 v4(55.74,125.69) 55.85,125.69 56.07,125.48
  BOTTOM w0.06: UC1.BJ1 60.56,123.2 60.13,123.2 59.92,123.41 59.25,123.41 58.82,123.84 v4(58.55,123.84)
TS_ID2: length 199.3
  IN2 w0.079: v2(119.98,98.99) 120.03,98.99 120.22,98.8 120.22,97.21 119.32,96.32 118.87,96.32 117.87,95.31 102.66,95.31 98.53,99.45 96.21,99.45 95.33,100.33 93.47,100.33 93.2,100.05 91.41,100.05 90.75,100.71 88.85,100.71 88.47,100.33 85.59,100.33 82.01,96.76 82.01,94.14 79.61,91.73 46.87,91.73 45.69,92.92 44.95,92.92 v2(44.92,92.94)
  IN3 w0.084: v3(49.76,125.64) 49.6,125.8 48.59,125.8 48.25,125.46 47.11,125.46 46.88,125.69 46.88,125.69 46.72,125.86 44.58,125.86 43.37,124.65 42.7,124.65 42.39,124.34 42.39,123.19 42.22,123.02 42.22,121 42.59,120.63 42.59,120.25 42.4,120.05 42.4,117.59 43.99,116.01 43.99,110.78 43.8,110.59 43.8,110.37 43.8,109.86 43.96,109.7 43.96,108.56 43.43,108.03 43.43,102.28 44.8,100.9 44.8,97.41 44.44,97.05 44.44,93.42 v2(44.92,92.94)
  GND3 w0.084: v2(119.98,98.99) 119.94,99.02 119.69,99.02 v8(119.56,98.89)
  IN4 w0.06: v5(61.47,123.23) 61.43,123.23 61.21,123.45 60.73,123.45 60.69,123.41 60.44,123.41 60.29,123.56 59.68,123.56 59.42,123.31 59.37,123.31 59.33,123.26 58.25,123.26 58.2,123.31 57.56,123.31 56.69,124.17 56.29,124.17
  IN4 w0.089: v3(49.76,125.64) 50.47,125.64 51.25,124.87 51.92,124.87 52.02,124.77 55.13,124.77 55.3,124.6 55.42,124.6 v4(55.61,124.41) 55.85,124.17 56.29,124.17 ; v8(119.56,98.89) 119.64,98.81 120.89,98.81 121.23,98.47 133.37,98.47 134,99.1 138.64,99.1 139.8,100.26 142.3,100.26 142.88,99.68 148.06,99.68 151.44,96.31 161.48,96.31 163.17,98 172.7,98 v4(173.03,98.33)
  BOTTOM w0.119: v4(55.61,124.41) 55.74,124.54 RH76.1
TS_ID3: length 249.6
  IN1 w0.084: v2(25.14,114.77) 25.19,114.77 25.42,114.54 27.81,114.54 28.34,114.01 28.34,109.59 27.97,109.22 27.97,105.98 v2(28.4,105.55) ; v2(118.59,96.92) 117.63,95.95 103.34,95.95 101.99,97.29 86.2,97.29 85.82,96.92 84.08,96.92 82.33,95.16 82.33,94.94 81.57,94.18 78.73,94.18 78.2,93.65 61.45,93.65 60.76,94.34 60.7,94.34 60.52,94.51 59.29,94.51 58.19,95.61 55.66,95.61 53.82,97.46 51.33,97.46 50.41,98.38 47.88,98.38 46.84,97.34 41.06,97.34 41.02,97.3 39.78,97.3 38.41,98.66 38.41,99.39 36.27,101.53 32.3,101.53 v2(31.83,101.06)
  IN2 w0.079: v2(28.4,105.55) 28.52,105.43 28.52,104.08 31.55,101.06 v2(31.83,101.06)
  IN3 w0.084: v3(118.92,97.09) 118.77,97.09 v2(118.59,96.92) ; v3(24.85,115.01) 24.91,115.01 v2(25.14,114.77)
  IN4 w0.06: v5(61.04,123.23) 60.98,123.17 60.51,123.17 60.24,123.44 59.73,123.44 59.43,123.14 58.2,123.14 58.15,123.19 57.51,123.19 56.7,123.99 56.38,123.99 56.37,123.98 56.29,123.98
  IN4 w0.089: v3(24.85,115.01) 24.55,115.01 23,116.55 23,119.84 22.42,120.43 22.42,126.24 23.22,127.03 23.22,128.77 30.92,136.48 42.79,136.48 44.75,134.51 44.75,131.32 44.13,130.7 44.13,127.05 43.5,126.42 43.5,126.16 43.63,126.03 44.09,126.03 44.28,126.22 46.79,126.22 46.92,126.09 48.93,126.09 49.36,126.51 50.7,126.51 51.24,125.97 51.54,125.97 51.6,126.04 51.83,126.04 52.07,125.79 53.32,125.79 53.48,125.95 53.85,125.95 54.05,125.74 v4(54.05,125.62) ; 56.29,123.98 55.66,123.98 55.2,124.44 54.28,124.44 v4(54.23,124.49) ; v3(118.92,97.09) 118.95,97.09 119.09,97.24 120.29,97.24 120.84,96.7 131.89,96.7 132.4,96.19 132.69,96.19 133.38,95.5 135.64,95.5 135.95,95.81 141.11,95.81 144.22,98.92 146.46,98.92 147.75,97.62 147.75,95.24 148.5,94.49 165.67,94.49 166.89,95.72 172.82,95.72 173.29,95.24 175.23,95.24 v4(175.37,95.38)
  BOTTOM w0.119: v4(54.23,124.49) 54.23,124.82 RH75.1 54.47,125.1 54.05,125.52 v4(54.05,125.62) ; v4(175.37,95.38) 176.03,96.04 176.03,98.33 JTS1.2
TS_INT#: length 142.6
  TOP w0.119: v1(169.9,98.19) 170.33,98.62 R194.1
  IN1 w0.084: v1(169.9,98.19) 168.77,98.19 168.21,98.74 159.96,98.74 159.75,98.74 158.47,97.46 139.64,97.46 138.13,98.97 136.15,98.97 135.45,99.68 121.82,99.68 120.72,100.78 119.31,100.78 118.61,100.08 115.71,100.08 114.04,98.41 105.94,98.41 104.91,99.44 104.29,99.44 103.22,100.5 99.83,100.5 99.01,101.32 96.05,101.32 95.94,101.21 95.38,101.21 93.4,103.19 89,103.19 88.76,102.95 87.28,102.95 87.02,102.69 84.73,102.69 83.52,101.48 81.36,101.48 80.07,100.19 79.01,100.19 78.3,99.48 77.27,99.48 77.07,99.28 72.33,99.28 71.91,99.7 68.65,99.7 67.75,98.8 65.06,98.8 63.71,100.15 63.71,100.67 63.07,101.31 62.55,101.31 62.49,101.37 62.16,101.37 58.93,104.6 58.93,106.45 58.21,107.18 57.88,107.5 57.88,107.5 57.46,107.92 56.77,108.61 56.77,108.74 56.42,109.09 54.73,110.77 54.73,111 v2(53.96,111.78)
  IN3 w0.06: 57.52,111.89 58.03,112.4 59.47,112.4 60,112.94 60,113.3 60.77,114.07 61.5,114.07 61.71,114.28 62.69,114.28 62.87,114.09 62.87,114.02 63.1,113.79 v10(63.1,113.43)
  IN3 w0.084: v2(53.96,111.78) 53.99,111.75 54.3,111.75 v7(54.38,111.83) 54.53,111.83 54.83,112.12 55.7,112.12 55.92,111.89 57.52,111.89
TS_INT#_R: length 14
  TOP w0.119: v1(177.77,98.67) 178.2,99.1 DI1.3 178.14,99.62 177.14,98.62 R194.2
  IN1 w0.084: v1(177.77,98.67) 173.68,98.67 173.15,98.14 v2(173.15,97.91)
  IN3 w0.084: v7(173.53,98.33) 173.34,98.33 173.15,98.14 v2(173.15,97.91)
TS_PD#: length 151
  TOP w0.119: v1(170.28,97.75) 170.54,98.01 R201.1
  IN1 w0.084: v1(170.28,97.75) 170.28,97.55 169.64,96.91 161.45,96.91 160.78,97.58 159.56,97.58 158.89,96.91 139.41,96.91 137.9,98.42 135.92,98.42 135.26,99.08 121.63,99.08 121.19,99.52 115.94,99.52 114.26,97.84 105.72,97.84 104.68,98.88 103.95,98.88 102.88,99.95 99.39,99.95 98.63,100.71 96.31,100.71 96.05,100.45 93.54,100.45 92.82,99.73 89.74,99.73 89.55,99.92 89.55,100.31 89.41,100.45 89.04,100.45 88.84,100.25 87.68,100.25 87.29,100.64 85.53,100.64 84.44,99.55 83,99.55 80.8,97.35 70.84,97.35 70.43,96.95 70.03,96.95 69.64,97.34 63.87,97.34 63.69,97.52 62.59,97.52 61.38,98.73 56.32,98.73 54.97,100.08 53.34,100.08 50.94,102.49 49.77,102.49 49.39,102.87 49.39,104.88 50.09,105.58 v2(50.09,105.78)
  IN3 w0.06: 58.66,110.16 58.76,110.16 59.81,111.2 60.44,111.2 61.44,112.2 61.85,112.2 62,112.06 62.52,112.06 v10(62.61,112.14)
  IN3 w0.084: 58.66,110.16 57.34,110.16 55.17,107.99 55.17,107.75 54.8,107.37 53.69,107.37 53.01,106.69 53.01,106.63 52.97,106.59 52.97,106.39 v7(52.91,106.32) 52.66,106.32 51.78,105.45 51.78,105.13 51.52,104.87 50.88,104.87 50.42,105.33 50.42,105.45 v2(50.09,105.78)
  BOTTOM w0.119: v7(52.91,106.32) 52.79,106.21 RC76.2
TS_PD#_R: length 5.2
  TOP w0.119: R201.2 171.49,97.97 170.97,97.45 170,97.45 v1(169.87,97.58)
  IN1 w0.084: v2(169.39,97.27) 169.57,97.27 v1(169.87,97.58)
  IN3 w0.084: v7(170.33,97.27) v2(169.39,97.27)
  BOTTOM w0.119: JTS1.12 171.03,97.56 170.74,97.27 v7(170.33,97.27)
TS_RST#: length 148.9
  TOP w0.119: v1(178.51,98.69) 179.1,99.28 179.1,100.32 178.8,100.62 DI1.2 177.67,100.09 176.55,100.09 176.46,99.99 176.46,99.77 175.83,99.14 v1(170.64,99.14)
  IN1 w0.109: v2(61.19,104.66) 61.21,104.64 61.21,104.34 63.2,102.35 63.83,102.35 64.3,101.88 64.3,101.57 64.73,101.14 65.57,101.14 65.75,100.96 68.6,100.96 68.83,100.73 72.03,100.73 72.44,100.32 76.96,100.32 77.16,100.52 77.69,100.52 78.39,101.23 79.63,101.23 80.92,102.52 82.64,102.52 84.2,104.08 88.37,104.08 88.73,104.45 93.8,104.45 95.05,103.2 97.04,103.2 97.29,102.95 98.96,102.95 100.37,101.54 104.39,101.54 106.45,99.48 112.96,99.48 113.39,99.9 113.39,102.33 115.32,104.26 116.39,104.26 116.48,104.36 127.65,104.36 128.49,103.52 129.15,103.52 132.07,100.6 135.77,100.6 136.28,100.08 136.52,99.85 138.53,99.85 140.02,98.36 152.53,98.36 154.62,100.45 158.45,100.45 159.17,99.74 170.42,99.74 170.64,99.51 v1(170.64,99.14) ; v2(173.71,97.91) 173.71,97.93 173.96,98.19 178,98.19 v1(178.51,98.69)
  IN3 w0.084: v2(173.71,97.91) 174.03,98.23 v7(174.03,98.33) ; v7(60.95,104.35) 61.19,104.59 v2(61.19,104.66)
  IN4 w0.06: 60.84,106.14 60.92,106.21 60.92,106.8 60.78,106.94 60.78,107.46 60.92,107.6 60.92,108.38 61.84,109.3 61.84,109.44 62.47,110.07 62.47,110.35 62.59,110.47 62.59,110.93 v5(62.75,111.08)
  IN4 w0.084: v7(60.95,104.35) 60.88,104.41 60.88,104.78 60.64,105.02 60.64,105.94 60.84,106.14
  BOTTOM w0.119: v7(60.95,104.35) 60.92,104.37 60.92,104.89 60.93,104.9 RH118.1
TX_BLANKING: length 1.6
  IN1 w0.084: v2(211.81,136.46) 211.48,136.46 v1(211.48,136.46)
  IN3 w0.084: v7(210.51,136.46) 210.91,136.46 210.91,136.46 v2(211.81,136.46)
TX_DE_0: length 2.9
  TOP w0.119: R228.2 R226.2 42.32,61.18 41.73,61.77 U27.16
TX_DE_1: length 3.4
  TOP w0.119: U27.18 41.74,62.77 42.04,63.06 42.04,63.52 42.37,63.85 R220.2 R218.2
TX_EQ_0: length 2.7
  TOP w0.119: R221.2 R224.2 42.63,62.27 U27.17
TX_EQ_1: length 4.2
  TOP w0.119: R232.2 R230.2 42.39,59.4 42.21,59.58 42.21,60.9 41.85,61.27 U27.15
UART2_CTS#: length 27.4
  IN4 w0.06: 53.16,115.24 53.24,115.24 53.35,115.35 53.35,115.36 53.92,115.36 54.3,114.98 57.63,114.98 57.86,115.21 58.31,115.21 59.1,116 59.15,116 59.16,116.01 60.61,116.01 60.94,116.33 61.58,116.33 61.78,116.13 61.95,116.13 62.03,116.21 62.2,116.21 62.32,116.09 62.53,116.09 v10(62.61,116.01)
  IN4 w0.089: v4(46.81,103.85) 46.55,104.11 46.55,105.44 47.12,106.01 47.12,107.28 48.41,108.58 48.41,109.29 48.91,109.79 48.91,112.54 49.63,113.27 50.25,113.27 51.15,114.16 51.24,114.16 52.22,115.14 52.23,115.14 52.33,115.24 53.16,115.24
  BOTTOM w0.119: v4(46.81,103.85) 47.05,103.85 TC74.1 47.38,103.41 48.01,102.78 RC112.2
UART2_RXD: length 89.3
  IN1 w0.084: v1(24.05,64.15) 24.23,63.98 24.86,63.98 26.19,62.65 29.29,62.65 30.04,63.4 34.69,63.4 35.26,63.97 35.26,65.02 v2(35.71,65.47)
  IN3 w0.084: v3(35.56,65.85) 35.71,65.7 v2(35.71,65.47)
  IN4 w0.06: v5(61.62,116.01) 61.42,116.21 60.99,116.21 60.66,115.88 59.15,115.88 58.36,115.09 57.91,115.09 57.24,114.42 56.12,114.42 v4(56.03,114.51) 54.57,114.51 54.14,114.94
  IN4 w0.089: v3(35.56,65.85) 35.67,65.96 35.67,72.54 36.2,73.08 36.2,74.69 38.8,77.29 38.8,84.43 34.92,88.32 34.92,92.53 34.49,92.95 34.49,97.29 39.88,102.68 42.08,102.68 42.98,103.58 46.92,103.58 47.08,103.74 47.08,103.96 46.74,104.3 46.74,105.36 47.31,105.93 47.31,107.21 48.6,108.5 48.6,109.22 49.1,109.71 49.1,112.46 49.71,113.08 50.33,113.08 51.23,113.97 51.32,113.97 52.3,114.95 52.31,114.95 52.41,115.05 53.24,115.05 53.26,115.07 53.29,115.07 53.39,115.17 53.91,115.17 54.14,114.94
  BOTTOM w0.119: v4(56.03,114.51) RC54.2
UART2_TXD: length 89.5
  IN1 w0.084: v2(35.76,64.86) 35.47,64.57 35.47,63.92 34.76,63.21 30.11,63.21 29.36,62.46 26.12,62.46 24.78,63.79 24.19,63.79 v1(24.05,63.65)
  IN3 w0.084: v3(35.41,65.06) 35.61,64.86 v2(35.76,64.86)
  IN4 w0.06: 53.16,114.67 53.19,114.67 53.26,114.6 54.08,114.6 54.54,114.14 v4(55.42,114.14) 57.57,114.14 57.97,114.54 58.82,114.54 59.35,115.07 59.51,115.07 60.09,115.64 60.76,115.64 60.93,115.81 61.21,115.81 61.29,115.89 61.46,115.89 61.54,115.81 61.7,115.81 61.82,115.92 62.03,115.92 v5(62.11,116.01)
  IN4 w0.089: v3(35.41,65.06) 35.87,65.53 35.87,72.46 36.39,72.99 36.39,74.61 38.99,77.21 38.99,84.51 35.11,88.4 35.11,92.61 34.68,93.03 34.68,97.21 39.96,102.49 42.16,102.49 42.56,102.89 46.82,102.89 47.46,103.53 47.46,104.12 47.13,104.46 47.13,105.21 47.73,105.81 47.73,107.08 48.98,108.34 48.98,109.06 49.48,109.55 49.48,112.3 49.87,112.7 50.17,112.7 50.49,112.7 51.39,113.59 51.48,113.59 52.45,114.57 52.47,114.57 52.57,114.67 53.16,114.67
UF_HCLK: length 2.6
  TOP w0.119: C49.1 115.67,131.12 L26.1 115.66,130.6 v1(115.72,130.54)
  IN1 w0.084: v1(115.72,130.54) 115.66,130.54 115.34,130.85 v2(115.02,130.85)
  IN3 w0.084: v7(114.86,130.55) 114.86,130.69 v2(115.02,130.85)
UF_HCLK_R: length 21.7
  TOP w0.119: C41.1 115.79,131.73 L26.2 115.66,132.37 v1(115.72,132.44)
  IN1 w0.084: v2(120.01,132.93) 120.29,132.66 120.29,131.48 119.77,130.96 119.77,128.94 120.44,128.26 120.86,128.26 121.76,127.37 122.4,127.37 122.5,127.26 124.63,127.26 125.15,126.74 127.95,126.74 128.38,127.17 128.38,127.18 128.55,127.35 128.93,127.35 v1(128.96,127.38) ; v1(115.72,132.44) 115.48,132.68 v2(115.48,132.73)
  IN3 w0.084: v2(115.48,132.73) 115.73,132.73 116.33,132.13 116.99,132.13 117.84,132.98 119.96,132.98 v2(120.01,132.93)
UF_I2C_CLK: length 70.3
  IN1 w0.109: v1(117.13,131.5) 117.03,131.5 v2(116.84,131.31) ; v2(105.23,127.47) 105.23,127.46 104.75,126.98 103.24,126.98 103.21,127.01 99.49,127.01 98.75,126.27 98.75,126.27 97.71,125.23 96.22,125.23 95.15,124.15 95.15,123.45 94.47,122.77 92.9,122.77 92.76,122.91 86.16,122.91 85.8,123.27 81.58,123.27 81.33,123.51 77.52,123.51 76.38,124.66 70,124.66 69.43,125.23 68.29,125.23 67.35,124.29 66.06,124.29 62.77,121 62.77,120.39 61.33,118.95 v2(60.91,118.95)
  IN3 w0.06: v2(60.91,118.95) 60.76,118.8 v3(60.76,118.63)
  IN3 w0.084: v7(117.32,131.31) v2(116.84,131.31) 116.51,131.64 116.15,131.64 115.53,132.27 112,132.27 111.2,131.46 111.2,129.28 109.8,127.87 108.09,127.87 107.69,127.47 v2(105.23,127.47)
  IN4 w0.06: v5(61.87,118.91) 61.66,118.91 61.57,118.82 61.46,118.71 61.29,118.71 61.29,118.71 61.21,118.78 60.91,118.78 v3(60.76,118.63)
  BOTTOM w0.119: JUFC.10 116.06,130.96 116.05,130.97 116.38,131.31 v7(117.32,131.31)
UF_I2C_DATA: length 71.2
  IN1 w0.109: v2(104.55,127.47) 103.44,127.47 103.08,127.83 101.4,127.83 101.16,127.59 99.25,127.59 97.38,125.72 96.02,125.72 94.66,124.35 94.66,123.65 94.34,123.34 93.06,123.34 92.33,124.06 89.56,124.06 88.89,123.4 86.45,123.4 85.55,124.3 77.43,124.3 76.58,125.15 70.21,125.15 69.63,125.72 68.09,125.72 67.15,124.78 65.48,124.78 62.58,121.88 62.58,121.51 62.28,121.2 62.28,120.59 61.12,119.44 60.84,119.44 v2(60.37,118.97) ; v2(116.87,132.57) 116.87,132.32 117.07,132.12 v1(117.07,132.08)
  IN3 w0.06: v2(60.37,118.97) 60.4,118.95 v3(60.4,118.63)
  IN3 w0.084: v2(104.55,127.47) 104.7,127.47 105.17,127.94 107.51,127.94 107.9,128.34 109.5,128.34 110.64,129.48 110.64,131.56 111.87,132.79 115.02,132.79 115.31,133.08 115.83,133.08 v7(116.13,132.78) 116.34,132.57 v2(116.87,132.57)
  IN4 w0.06: v5(61.37,118.91) 60.68,118.91 v3(60.4,118.63)
  BOTTOM w0.119: v7(116.13,132.78) 115.76,133.15 JUFC.9
UF_SENSOR_RST#: length 7.8
  TOP w0.119: R41.2 120.52,132.32 R40.2 120.51,132.08 120.57,132.02 R56.1 120.5,131.56 120.19,131.87 v1(120.01,131.87)
  IN1 w0.084: v2(118.77,132.4) 118.69,132.32 118.69,132.1 119.13,131.66 119.81,131.66 v1(120.01,131.87)
  IN3 w0.084: v2(118.77,132.4) 118.68,132.49 v7(118.21,132.49)
  BOTTOM w0.119: JUFC.11 116.36,133.27 116.81,132.82 117.88,132.82 v7(118.21,132.49)
UF_SENSOR_RST#_R: length 10.8
  GND1 w0.112: v9(128.56,127.38) 128.53,127.35 v11(128.17,127.35)
  IN1 w0.084: v11(128.17,127.35) 127.67,127.35 127.58,127.26 125.29,127.26 124.82,127.73 122.69,127.73 122.59,127.83 121.95,127.83 121.05,128.73 120.64,128.73 120.26,129.11 120.26,130.33 v1(120.57,130.65)
UIM_CLK: length 39.4
  IN3 w0.084: v3(216.01,110.31) 216.39,110.68 220.74,110.68 220.93,110.88 v7(221.51,110.88)
  IN4 w0.089: v3(216.01,110.31) 215.72,110.61 215.72,111.96 215.65,112.02 215.65,112.48 214.02,114.12 214.02,116.31 213.7,116.63 213.7,118.53 214.08,118.91 214.08,131.4 213.11,132.37 213.11,138.37 211.19,140.3 210.67,140.3 v4(210.51,140.46)
  BOTTOM w0.119: JIO1.47 v7(221.51,110.88)
UIM_DATA: length 40.4
  IN3 w0.084: v3(215.58,109.93) 215.58,110.75 216,111.17 220.54,111.17 221.05,111.68 v7(221.5,111.68)
  IN4 w0.089: v3(215.58,109.93) 215.25,110.26 215.25,111.76 215.18,111.82 215.18,112.29 213.48,113.99 213.48,116.18 213.23,116.44 213.23,118.73 213.61,119.11 213.61,131.21 212.45,132.37 212.45,138.37 210.86,139.96 v4(210.51,139.96)
  BOTTOM w0.119: v7(221.5,111.68) 221.51,111.68 JIO1.43
UIM_DET: length 28
  TOP w0.119: R43.2 211.43,132.3 v1(211.48,132.35)
  IN1 w0.084: v2(211.96,132.35) v1(211.48,132.35)
  IN3 w0.084: v2(211.96,132.35) 213.43,132.35 213.75,132.67 v3(214.45,132.67)
  IN4 w0.089: v3(214.45,132.67) 214.52,132.61 215.06,132.07 215.06,117.51 215.4,117.16 215.4,115.92 217.69,113.63 217.69,111.75 217.14,111.2 v4(217.14,111.01)
  BOTTOM w0.119: JIO1.48 217.51,110.88 217.37,111.01 v4(217.14,111.01)
UIM_DET#: length 1
  IN1 w0.084: v1(209.6,132.3) 209.96,132.3 v2(209.98,132.27)
  IN3 w0.084: v7(210.51,131.96) 210.29,131.96 v2(209.98,132.27)
UIM_RESET: length 33.9
  IN4 w0.089: v4(210.51,140.96) 210.76,141.21 211.68,141.21 214.09,138.81 214.09,137.97 214.09,133.81 215.4,132.5 215.4,117.75 217.23,115.92 217.23,115.42 218.03,114.62 218.03,111.55 v4(217.81,111.32)
UPD_I2C_ALERT#: length 280.8
  TOP w0.119: v1(198.85,114.44) 198.85,113.62 203.75,108.72 203.75,107.54 204.72,106.57 204.72,104.74 206.17,103.29 206.17,102.1 206.55,101.72 206.55,101.18 207.77,99.96 v1(207.77,99.85) ; v1(43.76,43.5) 43.69,43.42 R490.1
  IN1 w0.084: v1(43.76,43.5) 43.88,43.61 43.88,49.81 43.34,50.35 43.34,50.9 44.16,51.72 44.16,57.62 43.37,58.41 43.37,71.52 38.58,76.31 38.58,84.15 39.17,84.74 39.17,86 39.83,86.67 39.83,88.4 39.25,88.98 38.33,88.98 38.14,89.16 38.14,89.87 40.13,91.86 43.78,91.86 44.12,92.19 44.51,92.19 45.07,91.64 81.89,91.64 83.35,93.11 84.38,93.11 86.81,95.53 98.11,95.53 98.12,95.53 98.62,95.53 99.91,94.24 117.66,94.24 118.09,93.81 169.66,93.81 169.74,93.88 178.34,93.88 181.29,96.84 198.84,96.84 198.98,96.98 207.21,96.98 207.5,97.27 207.5,99.49 207.77,99.76 v1(207.77,99.85) ; v2(198.91,130.05) 198.88,130.08 v1(198.4,130.08) ; v2(198.76,115.97) 198.76,114.53 v1(198.85,114.44)
  IN3 w0.084: v2(198.76,115.97) 198.76,116.34 199.5,117.08 199.5,126.95 199.09,127.36 199.09,127.95 199.41,128.26 199.41,129.51 198.91,130.01 v2(198.91,130.05) 198.91,131.49 198.1,132.29 195.32,132.29 195.04,132.02 193.5,132.02 192.1,130.62 190.84,130.62 189.71,129.49 188.94,129.49 188.67,129.76 188.67,131.09 v7(190.32,132.74)
UPD_TD_SMBCLK: length 312.2
  TOP w0.119: v1(205.93,99.86) 205.93,100.08 204.85,101.16 204.85,102.74 203.31,104.27 v1(203.31,105.21) ; v1(40.22,48.01) R492.1
  IN1 w0.084: v2(32.52,46.22) 32.1,46.65 v1(31.81,46.65) ; v1(40.22,48.01) 41.55,48.01 41.9,48.36 41.9,49.83 41.68,50.05 41.27,50.05 v2(40.92,49.7) 40.86,49.76 40.86,54.98 42.77,56.9 42.77,71.33 38.22,75.88 37.61,75.88 33.05,80.45 33.05,84.28 31.38,85.94 31.38,87.46 31.14,87.7 31.14,87.85 31.15,87.85 31.15,88.56 31.17,88.58 31.55,88.96 31.55,88.96 32.19,89.6 34.13,89.6 38.79,94.26 40.55,94.26 41.37,95.08 42.03,95.08 43.28,96.33 46.12,96.33 47.98,98.19 50.33,98.19 51.25,97.27 53.74,97.27 55.58,95.43 58.11,95.43 59.21,94.33 60.44,94.33 60.62,94.15 60.69,94.15 61.39,93.45 78.26,93.45 78.81,94 81.95,94 82.63,94.68 83.85,94.68 86.27,97.11 101.92,97.11 103.26,95.76 117.7,95.76 118.36,96.43 119.87,96.43 120.47,97.03 132.2,97.03 132.57,97.4 134.71,97.4 135.27,96.84 137.24,96.84 138.75,95.33 174.46,95.33 175.6,96.47 179.03,96.47 180.69,98.14 198.28,98.14 198.97,98.83 204.62,98.83 205.65,99.86 v1(205.93,99.86) ; v2(202.95,105.22) 203.3,105.22 v1(203.31,105.21)
  IN2 w0.079: v2(32.52,46.22) 32.98,46.68 32.98,47.37 35.18,49.57 35.97,49.57 36.17,49.77 36.17,50.27 36,50.43 36,51.01 36.2,51.21 40.18,51.21 40.92,50.47 v2(40.92,49.7) ; v2(202.95,105.22) 203.33,105.6 203.33,106.03 203.23,106.13 203.23,112.03 204.53,113.33 206.34,113.33 208.65,115.65 208.65,120.23 208.97,120.55 208.97,125.87 206.7,128.14 201.29,128.14 200.93,128.5 189.52,128.5 188.79,129.24 187.24,129.24 186.81,128.81 v2(186.81,128.59)
  IN3 w0.084: v2(186.81,128.59) 186.84,128.62 186.84,129.45 v7(186.21,130.09)
  IN4 w0.089: v4(189.32,132.74) 189.32,132.6 189.06,132.34 189.06,132.09 188.93,131.96 188.68,131.96 187.52,130.8 186.92,130.8 v7(186.21,130.09)
  BOTTOM w0.119: R352.1 185.72,130.57 v7(186.21,130.09)
UPD_TD_SMBDAT: length 306.2
  TOP w0.119: v1(205.77,99.46) 205.53,99.69 205.53,100.17 204.63,101.07 204.63,102.65 202.92,104.35 202.92,105.38 v1(203.32,105.78)
  IN1 w0.084: v1(205.77,99.46) 205.51,99.46 204.65,98.59 198.99,98.59 198.35,97.96 180.77,97.96 179.1,96.29 175.68,96.29 174.53,95.14 138.68,95.14 137.16,96.65 135.19,96.65 134.63,97.21 132.65,97.21 132.28,96.85 120.55,96.85 119.94,96.24 118.44,96.24 117.74,95.54 103.22,95.54 101.84,96.92 86.35,96.92 83.92,94.49 82.71,94.49 82.03,93.81 78.89,93.81 78.34,93.26 61.31,93.26 60.61,93.96 60.54,93.96 60.36,94.14 59.13,94.14 58.03,95.24 55.51,95.24 53.66,97.09 51.18,97.09 50.26,98.01 48.06,98.01 46.18,96.13 43.34,96.13 42.11,94.9 41.45,94.9 40.63,94.08 38.87,94.08 34.2,89.41 32.26,89.41 31.63,88.77 31.62,88.77 31.36,88.51 31.36,88.51 31.33,88.48 31.33,87.77 31.57,87.54 31.57,86.02 33.23,84.35 33.23,80.53 37.68,76.08 38.29,76.08 42.96,71.41 42.96,56.75 41.2,54.99 41.2,51.01 v2(41.21,50.99) 41.21,50.49 v1(41.16,50.43) 41.29,50.3 41.9,50.3 42.09,50.12 42.09,48.26 40.98,47.15 40.74,47.15 40.68,47.09 40.45,47.09 v1(40.2,46.84) ; v1(32.7,46.65) 32.7,46.91 v2(32.54,47.07) ; v2(202.94,105.77) 203.3,105.77 v1(203.32,105.78)
  IN2 w0.079: v2(202.94,105.77) 203.05,105.87 203.05,112.11 204.46,113.52 206.26,113.52 208.47,115.72 208.47,120.31 208.78,120.63 208.78,125.79 206.62,127.96 201.21,127.96 200.85,128.32 189.39,128.32 188.66,129.05 187.76,129.05 187.33,128.62 v2(187.32,128.62) ; v2(41.21,50.99) 40.68,50.99 40.06,51.62 36.35,51.62 35.82,51.08 35.82,50.47 32.54,47.19 v2(32.54,47.07)
  IN3 w0.084: v7(187.12,129.99) 187.12,128.82 187.33,128.62 v2(187.32,128.62)
  IN4 w0.089: v4(189.32,132.24) 189.27,132.19 189.27,131.96 189.08,131.77 188.76,131.77 187.43,130.43 187.43,130.29 v7(187.12,129.99)
USB2_COMP: length 5.9
  BOTTOM w0.203: UC1.N2 60.28,112.47 60.11,112.29
  BOTTOM w0.254: RC61.1 55.91,111.09 58.91,111.09 60.11,112.29
USB3RN1: length 87.4
  IN1 w0.109: v2(38.2,66.39) 38.27,66.32 38.27,66.03 v1(38.2,65.97)
  IN2 w0.079: v2(38.2,66.39) 38.38,66.56 38.38,66.88 37.99,67.27 28.8,67.27 28.34,67.74 26.93,69.15 24.82,69.15 23.92,70.04 23.92,80.13 29.13,85.35 29.13,85.82 36.75,93.44 37.25,93.44 40.22,96.4 40.87,96.4 41.38,96.91 42.61,96.91 42.86,96.66 47.12,96.66 47.59,97.13 49.17,97.13 49.45,96.85 51.89,96.85 52.17,97.13 52.52,97.13 52.88,96.76 52.88,96.54 v2(53.03,96.38)
  IN3 w0.084: v2(53.03,96.38) 52.98,96.38 52.81,96.56 52.81,96.81 53.02,97.03 57.85,97.03 58.04,96.84 58.83,96.84 59.11,97.12 59.11,97.39 v3(59.18,97.46)
  IN4 w0.06: v5(64.44,109.95) 64.44,109.74 64.18,109.48 64.18,108.42 63.84,108.09 63.17,108.09 62.27,107.19 62.27,104.01 62.38,103.9 62.38,103.65
  IN4 w0.089: v3(59.18,97.46) 59.24,97.41 59.87,97.41 60.37,97.9 60.37,98.39 60.37,98.39 60.37,98.57 61.79,99.99 61.79,101.05 62.38,101.64 62.38,103.65
USB3RN1_C: length 1.9
  TOP w0.119: U27.23 38.25,64.08 38.37,64.2 38.37,64.92 38.2,65.09 C192.1
USB3RN1_RP: length 33.9
  TOP w0.119: v1(21.52,39.39) 21.52,39.39 21.52,39 21.62,38.89 21.84,38.89 22.05,39.11 U31.27
  IN1 w0.109: v1(21.52,39.39) 21.6,39.31 21.6,39.09 21.52,39 21.32,39 21.02,39.31 21.02,41.17 20.93,41.27 20.93,42.71 21.68,43.46 27.52,43.46 28.66,44.6 28.66,48.38 31.76,51.48 31.76,53.21 34.93,56.37 36.29,56.37 37.74,57.82 38.41,57.82 38.54,57.69 38.54,57.35 38.38,57.19 v1(38.2,57.19)
