# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE4#_R: length 16.3
  TOP w0.119: R32.2 54.6,134.63 v1(54.96,134.63)
  IN1 w0.109: v2(56.26,134.48) 56.11,134.33 55.26,134.33 v1(54.96,134.63)
  IN3 w0.084: v7(54.76,145.89) 54.92,145.73 56.12,145.73 56.89,144.95 56.89,141.31 55.4,139.82 55.4,136.02 55.8,135.62 55.8,134.43 55.93,134.31 56.08,134.31 v2(56.26,134.48)
CLK_PCIE4_R: length 16.3
  TOP w0.119: R37.2 54.6,133.83 v1(54.96,133.83)
  IN1 w0.109: v2(56.26,133.95) 56.11,134.1 55.24,134.1 v1(54.96,133.83)
  IN3 w0.084: v7(54.76,145.39) 54.92,145.56 56.05,145.56 56.73,144.89 56.73,141.38 55.23,139.88 55.23,135.96 55.64,135.55 55.64,134.37 55.86,134.14 56.04,134.14 56.24,133.95 v2(56.26,133.95)
CLK_REQ2#: length 261.4
  IN1 w0.084: v2(96.98,137.19) 96.91,137.26 94.4,137.26 93.83,136.69 86.22,136.69 84.63,135.09 80.53,135.09 79.9,135.73 69.01,135.73 68.61,136.13 66.23,136.13 65.83,135.73 61.95,135.73 61.33,135.11 58.14,135.11 57.72,135.53 56.98,135.53 56.68,135.82 55.23,135.82 54.45,136.61 52.99,136.61 51.99,135.62 51.99,135.37 51.55,134.93 51.55,134.09 51.26,133.79 51.26,132.46 51.21,132.41 51.21,131.98 51.09,131.86 51.09,131.3 49.67,129.88 49.59,129.88 49.35,129.64 49.35,128.83 49.36,128.82 49.36,127.68 v2(49.25,127.57) ; v2(212.41,106.81) 212.18,107.04 v1(212.18,110.53)
  IN3 w0.084: v2(49.25,127.57) 48.94,127.57 48.87,127.51 v7(48.87,127.36) ; v6(212.41,106.44) v2(212.41,106.81) ; v2(96.98,137.19) 97.02,137.24 v3(97.02,137.69)
  IN4 w0.06: v5(62.85,122.12) 62.85,122.24 62.95,122.34 62.95,122.95 62.86,123.04 62.84,123.06 62.75,123.06 62.63,123.18 62.63,123.22 62.37,123.49 62.37,124.07 61.37,125.08 59.26,125.08 59.22,125.12 59.01,125.12 58.86,125.28 57.83,125.28 57.59,125.52 57.59,125.61 57,126.2 56.36,126.2 55.82,126.74 55.67,126.74 55.49,126.92 55.49,126.92 55.29,127.12 54.58,127.12
  IN4 w0.089: v6(212.41,106.44) 213.16,105.69 214.26,105.69 217.26,108.69 217.55,108.69 218.55,109.69 218.55,110.51 218.38,110.68 218.38,114.76 217.58,115.56 217.58,116.17 217.25,116.49 v7(217.25,116.77) ; v7(48.87,127.36) 49.14,127.09 51.26,127.09 51.59,127.42 54.28,127.42 54.58,127.12 ; v3(97.02,137.69) 97.82,138.5 104.58,138.5 105.99,137.09 123.12,137.09 123.98,136.23 123.98,136.1 126.44,133.64 126.91,133.64 127.67,132.88 130.91,132.88 132.21,134.18 132.92,134.18 135.81,137.06 169.67,137.06 174.01,132.72 177.17,132.72 179.51,135.06 179.51,136.27 179.92,136.67 180.5,136.67 182.61,138.77 182.61,140.77 183.46,141.62 183.46,143.05 186.14,145.74 195.45,145.74 196.12,145.07 198.11,145.07 200.46,147.42 208.38,147.42 209.15,146.65 v4(214.51,146.65)
  BOTTOM w0.119: JIO1.18 217.36,116.88 v7(217.25,116.77) 217.14,116.88 215.74,116.88 214.51,118.11 v4(214.51,146.65)
CLK_REQ3#: length 65.1
  TOP w0.119: RH44.2 50.04,116.47 v1(50.34,116.17)
  IN1 w0.084: v2(47.72,121.14) 47.58,121.01 47.58,118.63 48.93,117.28 48.93,116.74 49.49,116.19 50.32,116.19 v1(50.34,116.17)
  IN3 w0.084: v3(44.01,107.61) 44.03,107.61 44.53,108.11 44.53,109.88 44.53,109.9 44.53,110.29 44.58,110.35 44.58,116.43 44.53,116.49 44.53,118.53 45.7,119.71 45.97,119.71 47.4,121.14 v2(47.72,121.14) v3(48.05,121.14)
  IN4 w0.06: 54,119.56 54.43,119.56 54.7,119.29 55.55,119.29 55.97,119.72 58.43,119.72 58.95,120.24 60.56,120.24 60.64,120.32 61.21,120.32 61.35,120.46 61.56,120.46 v5(61.62,120.52)
  IN4 w0.089: v3(48.05,121.14) 48.95,121.14 49.91,122.1 51.7,122.1 52.96,120.84 52.96,120.27 53.67,119.56 54,119.56 ; v3(44.01,107.61) 44.01,107.08 43.7,106.78 v4(36.39,106.78)
  BOTTOM w0.119: v4(36.39,106.78) 29.07,106.78 28.46,106.17 28.46,103.11 30.28,101.29 JNGFF2.52
CLK_REQ4#: length 58.1
  TOP w0.119: v1(47.73,116.75) 47.73,116.3 47.93,116.09 49,116.09 RH43.2
  IN1 w0.084: v1(47.73,116.75) 47.59,116.89 47.59,117.61 v2(47.44,117.75) 46.86,117.75 46.25,117.14 45.4,117.14 45.12,117.43 45.12,118.66 45.17,118.71 45.17,120.52 45.29,120.64 45.29,120.92 45.78,121.41 45.82,121.41 46.26,121.84 46.26,122.36 46.26,122.36 46.26,122.81 46.99,123.54 46.99,131.63 48.45,133.09 48.45,133.76 48.87,134.18 48.87,134.74 49.36,135.23 49.36,137.25 49.29,137.32 49.29,138.48 50.97,140.16 51.47,140.16 53.04,141.73 53.04,145.73 53.62,146.31 v2(53.62,146.37)
  IN3 w0.084: v2(53.62,146.37) v7(53.62,146.75) ; v2(47.44,117.75) 47.42,117.73 47.42,118.08 v3(47.42,118.08)
  IN4 w0.06: v5(62.11,120.52) 61.9,120.52 61.7,120.32 61.69,120.32 61.57,120.2 61.57,120.11 61.46,120 61.29,120 61.29,120 61.21,120.07 60.88,120.07 60.8,120 59.05,120 58.53,119.48 56.3,119.48 55.83,119.01 54.48,119.01 54.31,119.18 54,119.18
  IN4 w0.089: 54,119.18 52.71,119.18 51.9,118.37 51.83,118.37 51.55,118.09 50.04,118.09 49,119.13 47.86,119.13 47.42,118.69 v3(47.42,118.08)
  BOTTOM w0.119: v7(53.62,146.75) 53.76,146.89 JNGFF3.53
CLK_SMB: length 9.2
  TOP w0.119: v14(158.5,103.85) 158.36,103.71 v1(157.84,103.71)
  IN1 w0.109: v1(157.84,103.71) 157.56,103.71 v2(157.38,103.52)
  IN3 w0.084: v6(156.83,103.52) v2(157.38,103.52)
  IN4 w0.089: v4(156.63,104.95) 156.63,104.73 156.66,104.7 156.66,103.75 156.83,103.58 v6(156.83,103.52) v4(156.83,103.23)
  BOTTOM w0.119: v4(156.83,103.23) 158.06,103.23 158.54,102.74 JT100.4 ; v4(156.63,104.95) 156.61,104.97 PD100.2 157.54,106.57 PR106.1
CLKOUT_LPC0: length 7.6
  IN4 w0.06: v4(57.43,126.1) 57.71,125.82 57.71,125.57 57.88,125.4 58.06,125.4 58.12,125.45 58.86,125.45 59.07,125.24 59.27,125.24 59.31,125.2 61.42,125.2 62.49,124.12 62.49,123.6 v5(62.83,123.26)
  BOTTOM w0.119: v4(57.43,126.1) 57.35,126.18 RH69.1
CLKOUT_LPC1: length 6.9
  IN1 w0.109: v2(56.86,122.98) 56.69,123.14 v1(56.69,123.41)
  IN3 w0.06: v2(56.86,122.98) 56.74,122.98 v3(56.57,123.15)
  IN4 w0.06: v3(56.57,123.15) 56.6,123.12 56.6,122.77 56.71,122.67 57.02,122.67 57.4,122.29 57.88,122.29 57.88,122.29 58.73,122.29 59,122.02 59.67,122.02 60.1,122.45 60.5,122.45 60.7,122.25 61.04,122.25 61.04,122.25 61.21,122.25 61.22,122.25 61.29,122.33 61.5,122.33 v5(61.62,122.45)
CLKRUN#: length 182.9
  IN1 w0.084: v2(49.69,128.97) 50.09,129.36 50.09,129.77 51.51,131.19 51.51,131.73 51.58,131.81 51.58,132.26 51.63,132.31 51.63,133.64 51.92,133.93 51.92,134.78 52.39,135.25 52.39,135.49 53.14,136.24 54.29,136.24 55.08,135.45 56.53,135.45 56.82,135.16 57.57,135.16 57.99,134.74 61.55,134.74 61.92,135.11 65.73,135.11 66.38,135.75 68.46,135.75 68.96,135.25 72.62,135.25 72.71,135.34 79.77,135.34 80.38,134.72 84.78,134.72 86.37,136.31 94.05,136.31 94.54,136.8 96.13,136.8 96.49,136.44 98.07,136.44 98.25,136.62 110.22,136.62 110.32,136.52 122.93,136.52 123.59,135.86 123.59,135.09 123.49,134.99 123.49,133.61 124.67,132.43 125.95,132.43 126.54,131.84 127.43,131.84 127.64,131.63 130.28,131.63 130.47,131.44 131.45,131.44 132.48,132.47 134.39,132.47 138.52,136.6 169.09,136.6 173.47,132.22 177.32,132.22 179.41,134.31 179.41,134.55 181.49,136.63 181.49,137.68 v2(181.47,137.7)
  IN3 w0.084: v2(49.69,128.97) 49.47,128.74 v7(49.47,128.54) ; v3(187.27,137.9) 187.12,137.74 185.85,137.74 185.04,138.55 183.01,138.55 182.43,137.98 182.43,137.78 182.29,137.64 181.95,137.64 181.89,137.7 v2(181.47,137.7)
  IN4 w0.06: v5(63.16,123.01) 63.16,123.22 63.08,123.3 63.07,123.3 62.96,123.42 62.96,123.42 62.89,123.49 62.82,123.49 62.61,123.69 62.61,124.17 61.47,125.32 59.36,125.32 58.64,126.04 58.32,126.04 57.91,126.45 56.81,126.45 56.59,126.67 56.59,126.79 55.62,127.76 54.88,127.76
  IN4 w0.089: v3(187.27,137.9) 189.48,137.9 190.05,137.33 190.05,137.11 190.21,136.95 190.41,136.95 190.53,136.83 190.53,136.15 190.74,135.94 191.04,135.94 193,133.98 193.42,133.98 193.67,133.74 v10(193.82,133.74) ; v7(49.47,128.54) 49.64,128.36 49.79,128.36 50.59,127.56 51.22,127.56 51.42,127.76 54.88,127.76
CMSRC:
  vias: v1(143.46,112.41) v1(143.71,112.19) v2(144.25,112) v7(144.2,113.1) v7(144.42,112.97)
CODEC_MUTE#: length 191.3
  TOP w0.119: v1(34.39,85.05) UA2.11 ; RA23.1 136.02,104.89 135.38,104.26 135.38,103.95 134.47,103.04 v1(134.47,101.34)
  IN1 w0.084: v1(34.39,85.05) 34.05,85.4 33.16,85.4 31.76,86.79 31.76,87.6 31.52,87.84 31.52,88.41 31.54,88.43 31.7,88.59 31.7,88.59 32.17,89.05 v2(33.2,89.05) 34.11,89.05 38.95,93.89 40.7,93.89 41.53,94.71 42.18,94.71 43.12,95.65 45.96,95.65 48.14,97.82 50.18,97.82 51.1,96.9 53.47,96.9 55.33,95.04 57.97,95.04 59.05,93.96 60.29,93.96 61.17,93.08 78.41,93.08 78.96,93.63 82.11,93.63 82.79,94.31 84,94.31 86.43,96.74 101.76,96.74 103.14,95.36 117.82,95.36 118.52,96.06 120.02,96.06 120.63,96.66 132.88,96.66 v2(133.08,96.87) ; v1(134.47,101.34) 132.74,101.34 132.38,101.69 v2(132.36,101.69)
  IN1 w0.109: v1(22.45,127.73) 22.05,127.32 20.83,127.32 v2(20.43,127.71)
  IN2 w0.079: v2(25.76,95.24) 25.73,95.21 25.55,95.21 22.31,98.46 22.31,110.21 22.77,110.68 22.77,114.16 23.58,114.96 23.58,121.69 23.2,122.07 23.2,122.38 21.3,124.29 21.3,126.85 v2(20.43,127.71) ; v2(133.08,96.87) 132.14,97.81 132.14,101.47 v2(132.36,101.69)
  IN3 w0.084: v7(13.95,134.43) 13.95,134.3 14.64,133.61 15.95,133.61 16.41,134.07 18.59,134.07 18.72,134.2 v7(19.38,134.2) ; v2(33.2,89.05) 32.8,89.45 31.74,89.45 26.08,95.11 ; v2(20.43,127.71) 20.07,128.08 v7(20,128.08)
  IN3 w0.086: v2(25.76,95.24) 25.95,95.24 26.08,95.11
  BOTTOM w0.119: UA3.52 13.78,134.31 13.89,134.43 v7(13.95,134.43) ; v7(20,128.08) RA52.2 19.58,128.6 19.34,128.85 19.34,128.85 18.99,129.2 18.99,129.9 18.86,130.03 18.86,130.73 19.15,131.02 RA49.1 19.28,134.1 v7(19.38,134.2)
CONTACTLESS_DET#: length 211.1
  IN1 w0.084: v2(207.9,104.27) 207.89,104.28 202.18,104.28 201.02,103.12 197.99,103.12 196.12,104.99 196.12,106 195.35,106.76 193.95,106.76 193.26,106.08 189.85,106.08 189.32,106.61 179.24,106.61 177.1,104.46 173.29,104.46 171.42,106.34 171.42,107.12 170.68,107.85 169.18,107.85 167.76,106.43 165.63,106.43 165,105.8 161.71,105.8 161.09,106.42 151.19,106.42 150.85,106.76 150.13,106.76 149.73,106.36 148.43,106.36 147.34,107.46 146.06,107.46 143.11,110.4 135.36,110.4 132.05,113.71 129.05,113.71 128.83,113.93 128.83,114.39 130.05,115.61 130.05,116.35 129.09,117.3 123.57,117.3 123.4,117.14 121.6,117.14 120.2,115.74 120.2,115.42 119.24,114.46 115.91,114.46 114.22,116.14 114.22,116.43 110.88,119.77 110.88,124.12 110.23,124.77 109.59,124.77 109.03,125.34 101.85,125.34 101.27,124.76 99.3,124.76 98.11,123.57 97.99,123.57 97.61,123.19 97.61,121.66 96.78,120.83 96.16,120.83 95.71,121.29 88.21,121.29 87.57,120.64 86.36,120.64 85.2,121.81 82.41,121.81 82.24,121.64 81.53,121.64 81.16,122 79.68,122 79.34,122.34 77.22,122.34 76.25,123.31 66.28,123.31 65.68,122.71 65.68,121.71 65.43,121.46 65.43,119.82 65,119.39 64.63,119.39 64.35,119.67 64.17,119.67 63.91,119.93 63.63,119.93 62.1,118.4 62.1,118.24 60.64,116.77 v2(60.11,116.77)
  IN3 w0.06: v10(63.1,116.65) 63.1,116.63 62.92,116.45 62.42,116.45 62.09,116.77 v2(60.11,116.77) 59.94,116.59 v3(59.84,116.59)
  IN3 w0.084: v2(207.9,104.27) 207.9,104.27 207.9,103.47 205.67,101.24 198.89,101.24 197.04,99.4 195.44,99.4 194.62,98.58 192.32,98.58 v7(192.05,98.84)
  IN4 w0.06: v3(59.84,116.59) 59.73,116.49 59.2,116.49 58.87,116.82 58.49,116.82 58.2,117.11 57.86,117.11 57.49,116.74 57.13,116.74 56.33,115.93 54.77,115.93 v4(54.25,116.45)
  BOTTOM w0.119: v4(54.25,116.45) RH89.1 ; v7(192.05,98.85) 192.05,98.87 192.43,99.26 JUSH1.23
CPU_B+:
  vias: v2(107.05,124.59) v2(107.25,124.23) v2(107.47,124.57) v2(107.68,124.22) v2(107.89,124.57) v2(108.1,124.22) v2(108.31,124.57) v2(108.52,124.22) v2(108.73,124.58) v4(106.27,111.43) v4(106.26,110.82) v4(106.27,110.28) v4(106.27,109.73) v4(106.3,111.99) v4(106.67,111.43) v4(106.65,110.82) v4(106.67,110.28) v4(106.67,109.73) v4(106.69,111.99) v4(107.07,111.43) v4(107.06,110.82) v4(107.07,110.28) v4(107.07,109.73) v4(107.1,111.99) v4(107.56,111.99) v4(107.53,111.43) v4(107.52,110.82) v4(107.53,110.28) v4(107.53,109.73) v4(107.98,110.82) v4(108.01,111.99) v4(107.99,111.43) v4(107.99,110.28) v4(107.99,109.73) v9(106.95,123.64) v9(107.11,123.89) v9(107.1,123.38) v9(107.22,123.64) v9(107.38,123.88) v9(107.37,123.38) v9(107.52,123.63) v9(107.64,123.87) v9(107.64,123.37) v9(107.79,123.64) v9(107.92,123.88) v9(107.91,123.37) v9(108.07,123.63) v9(108.23,123.87) v9(108.22,123.36) v9(108.37,123.64) v9(108.5,123.88) v9(108.5,123.37) v9(108.65,123.65) v9(108.79,123.37) v10(112.33,121.2) v10(112.33,120.7) v10(112.33,120.2) v10(112.33,119.7) v10(112.33,119.2) v10(112.33,118.7) v10(112.33,118.2) v10(112.33,117.7) v15(108.48,115.23) v15(108.91,124.02) v15(108.91,123.68) v15(109.23,125.07) v15(109.25,124.74) v15(109.21,123.94) v15(109.22,123.62) v15(109.31,115.23) v15(109.47,123.75) v15(109.47,122.18) v15(109.47,121.73) v15(109.47,121.26) v15(109.46,120.45) v15(109.46,120) v15(109.46,119.53) v15(109.41,118.75) v15(109.41,118.3) v15(109.41,117.83) v15(109.42,116.99) v15(109.44,116.56) v15(109.45,116.13) v15(109.52,125.06) v15(109.52,124.73) v15(109.74,124.88) v15(109.75,124.59) v15(109.69,123.97) v16(107.25,122.72)
CPU_POPIRCOMP: length 8.6
  BOTTOM w0.089: UC1.BN17 64.77,124.56 62.95,126.38 59.61,126.38 58.87,127.12 58.69,127.12
  BOTTOM w0.119: 58.69,127.12 58.1,127.71 RC35.1
CPU_XDP_TCK: length 14.8
  TOP w0.119: v14(74.84,103.51) 74.41,103.51 73.89,102.99 v1(73.75,102.99)
  IN1 w0.084: v2(74.09,103.14) 73.94,102.99 v1(73.75,102.99)
  IN3 w0.084: v7(73.96,103.8) 74.09,103.67 v2(74.09,103.14)
  IN4 w0.06: v4(78.66,106.8) 78.66,107.32 78.13,107.86 78.13,108.89 77.82,109.2 77.23,109.2 77.19,109.23 76.85,109.23 76.6,109.49 76.6,109.69 76.48,109.8 76.48,109.98 76.36,110.1 v5(76.36,110.2)
  BOTTOM w0.119: v7(73.96,103.8) 74.88,103.8 75.35,104.27 RC92.1 75.65,104.74 76.5,104.74 RC93.1 77.32,104.26 77.79,104.73 77.79,105.71 77.82,105.73 77.82,105.75 77.91,105.84 78.54,105.84 78.66,105.97 v4(78.66,106.8)
CPU_XDP_TDI: length 26.8
  TOP w0.119: v1(92.9,108.71) 92.93,108.71 v14(94.06,109.84)
  IN1 w0.084: v1(92.9,108.71) 92.76,108.57 92.76,108.57 92.68,108.49 v2(92.42,108.49)
  IN3 w0.06: 84.75,108.59 81.33,108.59 80.79,108.04 80.59,108.04 80.31,108.32 79.86,108.32 79.6,108.58 79.3,108.58 79.25,108.62 78.27,108.62 v3(77.48,109.41)
  IN3 w0.084: 84.75,108.59 84.88,108.72 85.58,108.72 85.76,108.54 92.3,108.54 92.35,108.49 v2(92.42,108.49) 92.72,108.79 93.38,108.79 93.64,108.54 93.64,108.13 v3(93.57,108.07)
  IN4 w0.06: v3(77.48,109.41) 76.84,109.41 76.72,109.54 76.72,109.92 v5(76.68,109.95)
  IN4 w0.089: v4(93.73,103.44) 93.51,103.66 93.51,107.95 93.57,108.02 v3(93.57,108.07)
  BOTTOM w0.119: RC109.1 93.88,103.29 v4(93.73,103.44)
CPU_XDP_TDO: length 23.5
  TOP w0.119: v1(78.51,105.6) v16(77.86,105.6)
  IN1 w0.084: v2(78.99,105.6) v1(78.51,105.6)
  IN3 w0.06: 78.59,105.88 77.32,105.88 75.75,107.45 75.75,108.19 75.37,108.57 75.37,108.92 75.04,109.26 75.04,109.26 74.75,109.55 v10(74.75,110.94)
  IN3 w0.084: v7(89.13,105.48) 88.41,105.48 88.08,105.15 84.28,105.15 84.1,105.32 82.16,105.32 81.97,105.13 81.11,105.13 81.06,105.18 80.81,105.18 80.77,105.21 79.86,105.21 79.83,105.18 79.42,105.18 v2(78.99,105.6) 78.71,105.88 78.59,105.88
  BOTTOM w0.119: v7(89.13,105.48) 89.34,105.48 89.6,105.21 90.01,104.81 90.01,104.27 RC95.2 90.93,103.34 RC116.1
CPU_XDP_TMS: length 11.6
  TOP w0.119: v1(80.37,105.58) v14(81,105.58)
  IN1 w0.084: v1(80.37,105.58) 80.35,105.56 v2(80.03,105.56)
  IN3 w0.084: v6(79.98,105.9) 79.98,105.56 v2(80.03,105.56)
  IN4 w0.06: 80.46,104.87 79.98,105.34 v6(79.98,105.9) 79.7,106.17 79.7,107.14 78.73,108.11 78.73,109.19 78.03,109.9 v5(78.03,110.06)
  IN4 w0.089: v4(80.89,103.19) 80.89,104.05 80.89,104.42 80.46,104.85 80.46,104.87
  BOTTOM w0.119: RC119.2 79.16,102.48 79.48,102.8 79.48,103.08 RC105.1 v4(80.89,103.19)
CPU_XDP_TRST#: length 10.8
  TOP w0.119: v14(76.09,106.69) 76.09,106.69 76.46,107.06 v1(76.57,107.06)
  IN1 w0.084: v1(76.57,107.06) 76.58,107.05 v2(76.9,107.05)
  IN3 w0.06: v2(76.9,107.05) 76.66,107.3 v6(76.66,107.36)
  IN4 w0.06: v4(76.99,103.52) 76.92,103.59 76.92,105.3 76.66,105.56 v6(76.66,107.36) 76.52,107.49 76.19,107.49 75.56,108.12 75.56,108.94 75.11,109.39 75.11,109.59 75.06,109.64 75.03,109.64 74.95,109.72 74.95,110.03 74.88,110.11 74.88,110.12 74.76,110.24 74.67,110.24 74.57,110.35 74.55,110.36 74.43,110.48 v10(74.43,110.69)
  BOTTOM w0.119: RC101.1 77.39,103.77 RC104.1
CSI2_COMP: length 2.7
  BOTTOM w0.254: RC65.2 64.36,107.79 63.16,108.99 UC1.A11
D1_PVCC_GT: length 5
  IN1 w0.254: v1(109.54,123.38) 109.85,123.7 v2(110.15,123.7)
  IN3 w0.254: v2(110.15,123.7) 110.36,123.92 v3(110.36,124.23)
  IN4 w0.254: v4(112.8,122.02) 112.17,122.02 111.24,122.95 111.24,123.36 v3(110.36,124.23)
D7_BOOT_IA: length 2.3
  IN3 w0.254: v7(112.83,118.2) 112.83,117.43 112.04,116.64 v7(112.04,116.25)
D8_PVCC_IA: length 5
  IN1 w0.254: v1(109.52,119.41) v2(109.93,119.41)
  IN2 w0.508: v2(112.58,116.23) 109.93,118.88 v2(109.93,119.41)
  IN3 w0.254: v2(112.58,116.23) 112.58,116.49 v7(112.65,116.55)
DAT_SMB: length 7.7
  TOP w0.119: v1(155.93,103.71) v14(156.34,103.71)
  IN1 w0.109: v2(155.56,103.71) v1(155.93,103.71)
  IN3 w0.084: v6(155.91,103.85) 155.77,103.71 v2(155.56,103.71)
  IN4 w0.089: v4(156.28,103.19) 156.28,103.37 155.91,103.74 v6(155.91,103.85) v4(155.91,104.77)
  BOTTOM w0.119: v4(155.91,104.77) 155.91,104.96 155.61,105.26 PD100.3 154.7,106.54 PR108.1 ; JT100.5 157.29,102.23 157.07,102.45 156.9,102.45 156.33,103.02 156.33,103.15 v4(156.28,103.19)
DCTRL: length 11.3
  TOP w0.119: PC408.1 131.22,103.49 131.21,103.5 PR405.1 130.33,103.5 130.32,103.49 PR403.2 129.45,103.49 129.45,105.51 127.96,107 127.96,109.62 v1(127.41,110.18)
  IN1 w0.084: v2(127.69,109.95) 127.69,109.97 127.48,110.18 v1(127.41,110.18)
  IN3 w0.084: v2(127.69,109.95) 128.02,110.28 128.47,110.28 128.8,109.95 v7(128.8,109.94)
DDCBUF: length 7.1
  TOP w0.119: U25.14 28.69,80.72 28.23,81.18 28.23,81.77 R203.2 27.35,82.65 26.48,82.65 R202.2
DDR_0_DQ_VREF: length 11.1
  IN1 w0.508: 88.51,130.21 88.51,128.03 89.57,126.96 91.8,126.96 92.53,127.7 93.28,127.7 93.29,127.7 v2(93.3,127.7)
  IN3 w0.254: v10(93.88,127.8) 93.47,127.8 93.37,127.7 93.28,127.7 93.28,127.7 v2(93.3,127.7) ; v10(88.59,131.59) 88.59,131 88.87,130.72 v2(88.9,130.72)
  BOTTOM w0.254: v10(88.59,131.59) 88.39,131.79 U35.U8
  BOTTOM w0.305: v10(93.88,127.8) 93.88,127.48 93.6,127.2 92.99,127.2 U35.H17
  vias: v1(88.34,130.47) v1(88.59,130.47)
DDR_1_DQ_VREF: length 38.1
  TOP w0.508: 60.24,135.44 61.54,134.13 65.77,134.13 67.04,132.86 73.5,132.86 76.47,129.9 77.58,129.9 ; v1(78.23,129.9) v1(78.69,129.9)
  IN1 w0.508: 82.11,129.91 79.22,129.91
  IN4 w0.381: v4(64.85,143.12) 64.24,143.73 61.85,143.73 60.07,141.95 60.07,138.38
  BOTTOM w0.508: 66.28,140.46 66.28,141.49 64.85,142.93 v4(64.85,143.12) ; U33.U8 61.23,135.28 60.07,136.44 60.07,136.79
  vias: v1(60.07,137.81) v1(60.07,137.56) v1(82.49,129.9) v1(82.75,129.89) v2(59.74,137.73) v12(60.07,137.91) v12(60.07,137.58)
DDR_CHA_EN: length 12.1
  TOP w0.119: RH47.1 53.31,115.98 53.37,116.03 RH40.1
  IN1 w0.084: v2(53.23,114.69) 53.42,114.88 v1(53.42,115.05)
  IN3 w0.084: v3(52.96,114.37) 52.96,114.43 v2(53.23,114.69)
  IN4 w0.06: v5(61.87,115.69) 61.76,115.58 61.55,115.58 61.46,115.49 61.29,115.49 61.21,115.56 61.04,115.56 60.88,115.4 60.81,115.4 59.38,113.98 55.71,113.98 55.43,113.69 54.77,113.69 54.48,113.98 53.52,113.98 53.33,114.16 53.16,114.16
  IN4 w0.089: v3(52.96,114.37) 53.16,114.16
DDR_CHB_EN: length 14.4
  TOP w0.119: v1(52.4,113.83) 52.43,113.83 52.67,114.07 52.67,115.13 52.49,115.31 RH46.1 51.64,115.31 RH45.1
  IN1 w0.084: v1(52.4,113.83) 52.43,113.81 52.43,113.78 52.76,113.45 52.76,113.4 v2(52.76,113.4)
  IN3 w0.06: v10(61.62,115.36) 60.88,115.36 59.5,113.99 59.22,113.99 58.89,114.31 58.35,114.31 58.29,114.25 56.98,114.25 56.44,113.71 56.36,113.71 56.18,113.53 56.18,113.52
  IN3 w0.084: 56.18,113.52 55.87,113.21 55.87,113.18 55.77,113.08 55.59,113.08 55.15,113.52 52.88,113.52 v2(52.76,113.4)
DDR_RCOMP_0: length 4.7
  BOTTOM w0.305: UC1.BF64 79.47,122.45 81.02,120.9 82.57,120.9 83.08,120.39 RC46.1
DDR_RCOMP_1: length 6
  BOTTOM w0.305: RC45.1 83.97,120.61 83.67,120.92 83.13,120.92 82.74,121.31 81.35,121.31 79.5,123.15 UC1.BJ64
DDR_RCOMP_2: length 3.6
  BOTTOM w0.305: UC1.BC64 79.39,121.81 80.7,120.5 81.65,120.5 81.76,120.39 RC47.1
DDR_VREF_CA: length 48.6
  TOP w0.508: 79.88,128.59 79.88,129.9 79.12,130.66 76.57,130.66 73.69,133.54 73.69,133.82
  IN1 w0.508: v1(79.88,127.98) 79.98,128.08 83.53,128.08 83.79,128.34 84.36,128.34 84.48,128.46 v2(84.98,128.46) 86.03,128.46 87.38,127.12 87.38,126.35
  IN2 w0.508: v2(66.34,128.29) 66.97,127.66 77.07,127.66 79.4,129.98 83.46,129.98 v2(84.98,128.46)
  GND3 w0.254: v15(89.61,122.6) 89.68,122.6 v2(90.41,123.33) ; v15(84.55,128.42) 84.59,128.46 v2(84.98,128.46) ; v2(73.25,134.2) 73.18,134.28 v7(73.18,134.53) ; v2(66.34,128.29) 66.3,128.29 66.29,128.3 66.29,128.31 66.25,128.35 v15(66.25,128.69)
  BOTTOM w0.254: v15(84.55,128.42) 84.55,128.14 U35.J1 ; U35.A10 89.37,123.77 89.37,122.84 v15(89.61,122.6)
  BOTTOM w0.305: 66.11,130.76 65.78,131.09 U33.J1
  BOTTOM w0.508: 70.62,135.88 71.97,134.53 72.28,134.53 ; C268.1 66.18,130.69 66.11,130.76
  vias: v1(87.96,126.28) v1(88.21,126.28) v9(73,133.85) v9(73.28,133.85) v9(90.07,123.31) v9(90.14,123.56)
DDR_VTT_CNTL: length 8.4
  TOP w0.119: v9(74.65,123.94) 78.46,123.94 78.77,123.64 78.77,122.06 78.62,121.92 UC2.2
  GND1 w0.06: v2(74.65,124.3) 74.62,124.3 74.65,124.27 v9(74.65,123.94)
  GND3 w0.06: v2(74.65,124.3) 74.65,124.48 74.4,124.73 74.4,124.7 74.37,124.68 v12(74.37,124.75)
  BOTTOM w0.06: UC1.BN47 74.43,124.7 v12(74.37,124.75)
DEBUG_CTL1: length 15.7
  TOP w0.119: U32.E4 v1(38.25,41.17)
  IN1 w0.084: v1(38.25,41.17) 38.51,40.91 38.51,40.45 39.08,39.88 40.28,39.88 43.53,43.13 43.79,43.13 44.06,43.41 44.06,50.12 v1(43.79,50.39)
DEBUG_CTL2: length 15.9
  IN1 w0.084: v1(43.79,50.95) 44.25,50.49 44.25,43.33 43.86,42.95 43.61,42.95 40.35,39.69 39,39.69 38.19,40.51 v1(38.19,40.67)
DEBUG_UART_TX: length 195
  TOP w0.119: v1(190,140.16) 189.89,140.16 186.85,137.12 186.85,129.64 185.35,128.14 v1(185.35,127.98)
  IN1 w0.084: v2(59.35,114.51) 58.41,114.51 57.84,115.08 57.84,116.58 57.48,116.93 57.48,118.25 56.72,119.01 56.72,119.26 56.71,119.26 56.71,120.63 57.01,120.93 58.09,120.93 58.09,120.93 58.85,120.93 59.26,121.34 60.37,121.34 60.94,121.91 60.94,122.64 61.07,122.77 61.07,122.78 61.72,123.43 61.72,123.66 64.33,126.27 66.61,126.27 67.45,127.11 70.21,127.11 70.78,126.54 80.63,126.54 80.87,126.78 85.22,126.78 85.27,126.73 85.32,126.73 85.91,126.15 85.91,126.12 86.86,125.16 86.89,125.16 87.01,125.04 87.33,125.04 88.56,125.05 88.97,125.45 92.42,125.45 92.77,125.81 94.14,125.81 94.4,126.06 94.4,126.78 94.86,127.24 94.86,127.83 96.18,129.15 97.43,129.15 97.61,129.34 100.64,129.34 101.84,130.54 104.62,130.54 106.31,128.85 106.82,128.85 107.39,128.28 109.12,128.28 110.91,126.49 110.91,125.57 111.92,124.55 111.92,122.47 112.45,121.94 113.41,121.94 114.86,120.49 114.86,119.15 115.07,118.94 115.07,118.18 115.93,117.32 115.93,116.76 116.43,116.25 117.12,116.25 117.5,116.63 119.17,116.63 121.67,119.13 123.48,119.13 124.01,119.67 126.3,119.67 126.94,119.02 129.94,119.02 130.33,118.63 134.13,118.63 135.13,119.64 135.13,120.59 136.61,122.06 138.35,122.06 138.89,121.53 140.78,121.53 143.5,124.25 145.64,124.25 145.92,124.53 145.92,127.14 146.16,127.38 148.1,127.38 148.88,128.17 149.67,128.17 150.69,129.19 152.02,129.19 152.89,128.32 152.89,127.16 154.1,125.95 163.65,125.95 166.83,122.77 170.92,122.77 171.16,122.53 172.23,122.53 173.63,123.93 180.9,123.93 184.95,127.98 v1(185.35,127.98) ; v2(190.43,140.66) 190.43,140.59 v1(190,140.16)
  IN3 w0.06: v2(59.35,114.51) 59.44,114.59 v3(59.44,114.85)
  IN3 w0.084: v7(196.63,146.6) 196.63,145.88 195.5,144.75 192.95,144.75 192.42,144.22 192.42,144.14 190.43,142.14 v2(190.43,140.66)
  IN4 w0.06: v3(59.44,114.85) 59.51,114.92 59.54,114.92 60.14,115.52 60.81,115.52 60.98,115.69 61.37,115.69 v5(61.37,115.69)
DEVSLP0: length 44
  IN4 w0.06: 61.24,104.75 61.24,105.1 61.14,105.19 61.14,105.56 61.2,105.61 61.2,105.91 61.12,105.98 61.12,106.76 60.9,106.99 60.9,107.41 61.04,107.55 61.04,108.33 61.96,109.25 61.96,109.39 62.62,110.05 62.62,110.27 62.83,110.49 v5(62.83,110.69)
  IN4 w0.089: v4(36.93,94.08) 38.43,95.58 39.84,95.58 40.69,96.43 42.5,96.43 43.92,97.84 46.2,97.84 46.64,98.28 51.58,98.28 51.76,98.47 58.96,98.47 61,100.51 61,101.58 61.24,101.82 61.24,104.61 v5(61.24,104.61) 61.24,104.75
  BOTTOM w0.119: v4(36.93,94.08) 34.33,94.08 33.78,94.64 JNGFF2.38
DISPOFF#: length 20.4
  BOTTOM w0.119: D37.1 112.39,105.87 R419.1 113.01,105.41 113.28,105.15 113.77,105.15 114.06,104.86 118.76,104.86 119.01,105.1 119.36,105.1 119.83,104.64 129.36,104.64 129.77,105.04 129.77,105.71 PR406.1
DMIC_CLK1: length 73.4
  IN1 w0.084: v2(9.99,164.56) 10.01,164.58 v1(10.33,164.58) ; v2(4.24,115.97) 4.29,115.92 v1(4.29,115.59)
  IN3 w0.084: v2(9.99,164.56) 9.99,163.25 12.24,161 12.24,157.73 17.15,152.83 17.15,141.53 24.08,134.6 24.08,132.93 23.9,132.76 23.9,132.26 22.61,130.96 22.36,130.96 v7(22.35,130.98) 22.02,130.65 20.82,130.65 19.96,129.8 v7(19.61,129.8) 19.46,129.94 19.46,130.39 18.92,130.94 15.91,130.94 15.03,130.05 15.03,126.15 14.48,125.6 14.48,122.01 13.15,120.68 6.37,120.68 4.86,119.17 4.86,116.59 v2(4.24,115.97)
  BOTTOM w0.119: CA49.1 19.58,130.11 RA48.2
DMIC_CLK1_R: length 10.1
  IN3 w0.084: v7(20.01,134.23) 19.77,134.47 18.69,134.47 18.47,134.26 16.33,134.26 15.87,133.79 14.99,133.79 v7(14.35,134.43)
  BOTTOM w0.119: RA48.1 19.99,132.02 19.68,132.34 19.68,133.56 20.01,133.9 v7(20.01,134.23) ; UA3.53 14.18,134.21 14.35,134.38 v7(14.35,134.43)
DMIC_CLK2: length 182.4
  TOP w0.119: RA13.2 v1(23.11,130.53)
  IN1 w0.084: v2(22.54,131.52) 23.11,130.95 v1(23.11,130.53)
  IN2 w0.079: v2(100.43,137.81) 99.98,138.26 96.53,138.26 96.39,138.11 73.69,138.11 60.59,151.21 41.29,151.21 24.4,134.33 24.4,132.47 23.46,131.52 v2(22.54,131.52)
  IN3 w0.084: v3(100.2,137.43) 100.43,137.67 v2(100.43,137.81) 101.08,138.45 101.93,138.45 102.16,138.23 102.16,137.23 102.55,136.85 108.89,136.85 110.7,135.04 111.66,135.04 111.91,134.79 v7(111.91,134.47) ; v2(22.54,131.52) 22.35,131.71 v7(22.1,131.71)
  IN4 w0.089: v4(151.71,134.79) 151.57,134.93 138.74,134.93 136.68,132.87 136.24,132.87 135.84,132.46 134.73,132.46 134.54,132.27 134.04,132.27 133.81,132.05 133.1,132.05 131.8,130.75 126.79,130.75 126.03,131.51 124.89,131.51 121.44,134.95 102.86,134.95 101.47,136.34 101.47,137.04 101.07,137.43 v3(100.2,137.43)
  BOTTOM w0.119: JDMIC1.3 150.61,131.48 150.72,131.59 151.45,131.59 151.95,132.09 151.95,134.55 v4(151.71,134.79) ; v7(111.91,134.47) 111.91,134.91 112.19,135.18 121.39,135.18 121.76,134.81 JUFC.29
DMIC_CLK2_R: length 8.3
  TOP w0.119: RA13.1 23.11,132.45 v13(22.73,132.83)
  IN3 w0.084: v13(22.73,132.83) 21.87,133.69 17.57,133.69 17.25,133.37 v7(17.25,133.21)
  BOTTOM w0.119: v7(17.25,133.21) 17.25,132.96 16.7,132.42 UA3.2
DMIC_DATA1: length 73.1
  IN1 w0.084: v2(5.1,115.61) 5.11,115.61 v1(5.47,115.61) ; v2(10.35,163.62) v1(10.35,163.26)
  IN3 w0.084: v2(10.35,163.62) 10.35,163.15 12.43,161.07 12.43,157.81 17.34,152.9 17.34,141.6 24.43,134.5 24.43,132.7 24.13,132.4 24.13,132.22 22.8,130.89 22.8,130.86 v7(22.35,130.42) 21.32,130.42 21.32,130.41 v7(20.57,129.66) 20.33,129.42 19.6,129.42 19.28,129.73 19.28,130.32 18.84,130.75 15.99,130.75 15.21,129.98 15.21,126.07 14.66,125.52 14.66,121.91 13.19,120.43 6.38,120.43 5.07,119.13 5.07,115.65 v2(5.1,115.61)
  BOTTOM w0.119: RA47.2 20.85,129.94 v7(20.57,129.66) 20.31,129.66 CA48.1
DMIC_DATA1_R: length 10.9
  IN3 w0.084: v7(14.75,134.44) 14.75,134.43 15.21,133.98 15.79,133.98 16.26,134.44 18.35,134.44 18.57,134.66 20.14,134.66 v7(20.57,134.23)
  BOTTOM w0.119: RA47.1 20.85,131.47 19.97,132.35 19.97,133.35 20.55,133.92 20.55,134.2 v7(20.57,134.23) ; UA3.54 14.58,134.18 14.75,134.36 v7(14.75,134.44)
DMIC_DATA2: length 179.9
  TOP w0.119: v1(21.81,130.55) 21.81,131.09 RA11.2
  IN1 w0.084: v1(21.81,130.55) 21.81,131.12 v2(21.46,131.46)
  IN2 w0.079: v2(21.46,131.46) 22,131.99 23.05,131.99 23.7,132.64 23.7,133.94 41.16,151.4 60.88,151.4 73.99,138.29 96.31,138.29 96.46,138.44 100.06,138.44 100.34,138.15 100.57,138.15 100.58,138.15 101.57,138.15 v2(101.66,138.07)
  IN3 w0.084: v2(101.66,138.07) 101.66,137.57 v3(101.85,137.38) ; v7(21.08,131.74) 21.18,131.74 v2(21.46,131.46)
  IN4 w0.089: v3(101.85,137.38) 101.85,136.54 v4(102.88,135.51) 103.25,135.14 121.52,135.14 124.97,131.7 126.11,131.7 126.86,130.94 131.72,130.94 133.02,132.24 133.73,132.24 133.96,132.46 134.46,132.46 134.65,132.66 135.76,132.66 136.16,133.06 136.6,133.06 138.66,135.12 151.87,135.12 v4(152.17,134.81)
  BOTTOM w0.119: JDMIC1.2 151.61,131.44 152.17,131.99 v4(152.17,134.81) ; JUFC.28 121.46,129.88 120.31,128.74 109.66,128.74 v4(102.88,135.51)
DMIC_DATA2_R: length 6.7
  TOP w0.119: RA11.1 21.64,132.53 v13(21.33,132.84)
  IN3 w0.084: v7(17.02,131.96) 17.16,131.96 18.48,133.27 20.91,133.27 21.34,132.84 v13(21.33,132.84)
  BOTTOM w0.119: v7(17.02,131.96) 16.99,131.96 16.65,131.62 UA3.4
DOCK_PWR_EN: length 133
  TOP w0.119: v1(131.72,104.17) 131.72,104.92 131.19,105.45 R163.1 ; v1(150.7,100.19) 149.89,100.19 149.55,100.52 149.55,104.36 149.03,104.88 149.03,105.77 150.19,106.93 150.93,106.93 150.93,106.92 ; R155.2 150.93,107.43 150.93,106.92 ; 150.93,106.92 U17.3
  IN1 w0.084: v1(131.72,104.17) 131.62,104.27 129.63,104.27 v2(129.29,103.93) ; v1(150.7,100.19) 150.77,100.19 150.98,99.99 v2(151.18,99.99)
  IN2 w0.079: v2(127.79,102.91) 128.17,102.91 129.18,103.93 v2(129.29,103.93)
  IN3 w0.084: v3(151.66,99.63) 151.65,99.65 151.52,99.65 v2(151.18,99.99) ; v2(127.79,102.91) 127.91,102.78 v3(127.91,102.5)
  IN4 w0.089: v4(192.82,132.24) 192.82,131.87 192.35,131.4 192.35,129.72 193.87,128.21 194.13,127.95 195.58,127.95 197.1,126.42 198.29,126.42 200.05,124.66 200.05,114.04 197.53,111.52 197.53,107.96 195.54,105.97 195.54,105.19 195.21,104.86 190.81,104.86 189.78,103.84 185.92,103.84 181.81,99.73 175.31,99.73 174.82,99.24 169.99,99.24 169.6,98.85 168.58,98.85 168.48,98.75 168.18,98.75 167.94,98.99 167.94,99.23 169.6,100.89 169.6,101.91 169.42,102.09 168.19,102.09 165.85,99.75 162.8,99.75 160.87,97.82 153.48,97.82 v3(151.66,99.63) 150.24,99.63 148.69,101.18 143.59,101.18 142.67,102.1 138.84,102.1 137.35,100.61 129.53,100.61 127.91,102.22 v3(127.91,102.5)
DP_CFG0: length 3
  BOTTOM w0.119: U47.59 50.04,100.22 49.97,100.29 48.4,100.29 R444.2
DP_CFG1: length 3.4
  IN4 w0.089: v4(47.99,99.91) 48.27,100.19 48.74,100.19 48.88,100.06 48.88,99.84 49.07,99.64 49.51,99.64 v4(49.83,99.96)
  BOTTOM w0.119: U47.58 49.98,99.82 v4(49.83,99.96)
DP_LANE_CNT_EC: length 229.2
  IN3 w0.084: v3(49.89,94.87) 49.81,94.94 49.81,97.67 v3(50.85,98.71) ; v7(128.68,103.05) 128.7,103.05 128.96,102.8 129.47,102.8 130.19,103.52 132.17,103.52 132.66,104.02 136.23,104.02 136.4,104.19 143.24,104.19 143.64,104.58 148.12,104.58 148.67,104.03 v3(149.6,104.03) ; v3(54.69,99) 54.08,99.6 54.08,103.72 54.31,103.95 54.89,103.95 55.7,104.76 56.93,104.76 58.13,105.97 v3(58.13,106.21)
  IN4 w0.06: v5(61.62,112.14) 61.58,112.11 61.37,112.11 61.21,111.94 60.81,111.94 58.38,109.51 58.38,106.73 58.13,106.48 v3(58.13,106.21)
  IN4 w0.089: v3(149.6,104.03) 150.08,103.55 150.27,103.55 150.72,103.1 153.32,103.1 153.8,102.62 155.29,102.62 155.72,102.19 165.12,102.19 167.32,104.38 171.09,104.38 171.9,105.19 174.74,105.19 175.69,104.24 178.16,104.24 178.38,104.47 180.75,104.47 182.75,106.48 184.61,106.48 185.39,107.26 188.4,107.26 191.71,110.57 193.02,110.57 194.31,111.85 194.31,114.23 195.33,115.25 195.33,123.07 194,124.4 192.74,124.4 191.75,125.39 185.96,125.39 185.16,126.19 185.16,130.62 184.56,131.22 184.56,132.62 184.72,132.77 185.47,132.77 185.93,132.31 186.84,132.31 187.48,132.95 187.48,133.64 187.81,133.97 189.56,133.97 189.82,134.23 v4(189.82,134.24) ; v4(99.16,98.15) 99.06,98.25 95.83,98.25 94.16,96.59 86.4,96.59 85.9,96.09 82.45,96.09 81.23,94.87 77.84,94.87 77.47,95.24 75.7,95.24 75.26,94.8 74.44,94.8 74.07,94.43 60.67,94.43 60.28,94.05 59.83,94.05 59.57,94.32 59.27,94.32 58.36,93.41 52.08,93.41 51.02,94.48 50.28,94.48 v3(49.89,94.87) ; v3(50.85,98.71) 51.37,98.71 51.83,99.16 54.52,99.16 v3(54.69,99)
  BOTTOM w0.119: v7(128.68,103.05) 128.73,103.05 128.99,102.78 128.99,102.51 128.8,102.31 127.05,102.31 126.17,101.43 120.37,101.43 116.66,97.72 116.66,94 115.4,92.75 99.95,92.75 99.25,93.44 99.25,98.06 v4(99.16,98.15)
DP_LANE_CNT_PD: length 112
  TOP w0.119: R303.2 38.4,32.22 37.74,32.88 36.8,32.88 v1(36.72,32.97)
  IN1 w0.084: v1(36.72,32.97) 36.65,33.04 v2(36.65,33.44)
  IN3 w0.084: v2(36.65,33.44) v3(33.11,33.44)
  IN4 w0.06: v10(61.37,111.82) 60.86,111.82 58.5,109.46 58.5,106.19 58.29,105.98 57.75,105.98 57.4,105.63
  IN4 w0.089: 57.4,105.63 57.23,105.46 57.23,105.22 56.84,104.83 55.48,104.83 54.88,104.23 51.71,104.23 51.07,103.58 51.07,101.76 51.32,101.51 51.32,100.13 50.08,98.89 46.98,98.89 46.12,98.03 43.84,98.03 42.42,96.62 38.85,96.62 36.39,94.16 36.39,88.72 39.62,85.49 39.62,77.03 36.96,74.38 36.96,72.72 36.47,72.23 36.47,66.35 36.74,66.08 36.74,65.3 36.04,64.59 34.84,64.59 34.65,64.4 34.65,51.29 35.56,50.37 37.05,50.37 37.27,50.15 37.27,37.46 33.26,33.45 33.12,33.45 v3(33.11,33.44)
DP_MUX_SEL: length 202.5
  TOP w0.119: v1(198.91,112.46) 199.66,112.46 203.53,108.59 203.53,107.45 204.5,106.48 204.5,104.65 205.95,103.2 205.95,101.82 v1(206.26,101.51)
  IN1 w0.084: v1(206.26,101.51) 206.17,101.61 203.29,101.61 202.86,101.17 197.2,101.17 196.4,101.97 193.38,101.97 192.74,101.34 190.43,101.34 189.92,101.86 181.33,101.86 178.62,99.15 171.49,99.15 170.62,98.28 170.4,98.28 170.03,97.91 168.78,97.91 168.13,98.56 159.88,98.56 158.6,97.28 139.56,97.28 138.05,98.79 136.08,98.79 135.37,99.49 121.75,99.49 120.64,100.6 119.39,100.6 118.69,99.89 115.79,99.89 114.1,98.21 105.88,98.21 104.84,99.25 104.21,99.25 103.14,100.32 99.73,100.32 98.97,101.08 96.08,101.08 96.02,101.03 95.3,101.03 94.5,101.83 93.31,101.83 93.22,101.74 88.15,101.74 87.81,101.41 85.25,101.41 84.13,100.29 82.32,100.29 80.35,98.32 74.69,98.32 74.46,98.55 72.06,98.55 71.78,98.84 69,98.84 68.25,98.09 64.17,98.09 63.92,98.34 62.84,98.34 61.61,99.57 59.22,99.57 v2(57.53,101.26) ; v1(198.91,112.46) 198.91,112.64 v2(198.4,113.15)
  IN3 w0.084: v3(198.15,112.79) 198.15,112.89 v2(198.4,113.15) ; v2(57.53,101.26) 57.53,101.34 v7(58.26,102.07)
  IN4 w0.089: v3(198.15,112.79) 199.67,114.32 199.67,124.51 198.14,126.04 197.73,126.04 197.73,126.04 196.4,126.04 194.89,127.55 193.99,127.55 192.86,128.68 192.04,128.68 191.13,129.59 191.13,130.5 190.91,130.72 v4(190.91,130.81)
  BOTTOM w0.119: U47.18 v7(58.26,102.07) ; U34.N10 190.32,131.39 190.89,130.81 v4(190.91,130.81)
DP_RP_RST#: length 2.2
  TOP w0.119: UV1.35 130.14,111.96 RV3.2 130.9,112.02 CV9.1
DP_USBC_HPD: length 96.2
  IN1 w0.084: v1(24.01,50.54) 24.79,49.76 28.7,49.76 30.22,51.28 v2(30.22,52.14)
  IN3 w0.084: v3(36.78,66.44) 35.66,66.44 30.72,61.5 30.72,56.13 31.1,55.75 31.1,53.02 v2(30.22,52.14)
  IN4 w0.06: 61.64,104.33 61.86,104.11 61.86,103.65 ; v5(63.16,109.95) 63.04,109.95 62.97,109.88 62.79,109.88 62.2,109.29 62.2,109.15 61.49,108.45 v4(61.49,108.19) 61.49,108.01 61.44,107.95 61.44,107.34 61.82,106.95 61.82,105.83
  IN4 w0.089: 61.82,105.83 61.82,105.39 61.64,105.21 61.64,104.33 ; v3(36.78,66.44) 36.78,66.45 36.72,66.51 36.72,72.18 37.23,72.7 37.23,74.26 39.82,76.86 39.82,85.6 36.8,88.63 36.8,93.55 38.64,95.39 39.92,95.39 40.77,96.24 42.58,96.24 43.97,97.62 46.53,97.62 46.89,97.98 48.11,97.98 48.35,97.74 50.13,97.74 50.46,98.06 51.62,98.06 51.84,98.28 59.04,98.28 61.19,100.43 61.19,101.34 61.8,101.94 61.8,102.47 61.86,102.53 61.86,103.65
  BOTTOM w0.119: v4(61.49,108.19) 61.74,107.95 61.74,107.29 62.05,106.97 RC73.2
DPRP_ADDR: length 8.4
  TOP w0.119: UV2.3 22.38,53.54 22.17,53.76 22.17,55.56 23.16,56.56 23.48,56.56 RV25.2 24.47,57.54 24.47,58.4 24.03,58.84 RV26.2
DPRP_CFG0: length 8.8
  TOP w0.119: UV2.5 22.33,52.54 21.72,53.15 21.72,56.8 RV18.2 22.49,57.57 22.49,58.39 RV19.2
DPRP_CFG1: length 4.1
  TOP w0.119: UV2.40 28.81,58.54 RV27.2 RV28.2
DPRP_PEQ: length 8.5
  TOP w0.119: UV2.4 22.27,53.04 21.94,53.37 21.94,56.01 RV23.2 23.48,57.54 23.48,58.41 RV24.2
DPRP_RST#: length 2.6
  TOP w0.119: UV2.35 32.06,54.04 32.3,54.28 RV29.2 32.8,53.76 CV33.1
DS4_VSYNC: length 46.8
  TOP w0.119: v1(115.32,129.8) 115.54,130.03 116.67,130.03 116.9,130.25 C354.1 117.25,130.08 117.25,130.03 117.44,129.83 118.74,129.83 119,129.57 R69.1 120.5,129.2 v1(120.56,129.2) ; v1(140.18,132.18) 140.04,132.32 C353.1
  IN1 w0.084: v2(114.86,129.73) 114.86,129.74 114.9,129.78 115.3,129.78 v1(115.32,129.8) ; v1(140.18,132.18) 139.27,132.18 136.59,129.5 134.92,129.5 133.19,127.77 130.83,127.77 130.17,127.12 129.82,127.12 129.64,127.29 129.64,127.57 129.54,127.68 128.78,127.68 128.62,127.84 127.22,127.84 127.11,127.73 125.48,127.73 125.01,128.19 122.88,128.19 122.78,128.3 122.14,128.3 121.24,129.2 v1(120.56,129.2)
  IN3 w0.084: v7(115.21,129.67) 115.15,129.73 v2(114.86,129.73)
  BOTTOM w0.119: v7(115.21,129.67) 115.2,129.67 114.53,129 110.06,129 103.08,135.98 JCAM3.8
DSW_ON: length 201
  TOP w0.119: U22.3 50.53,103.02 50.7,103.2 51.14,103.2 R169.2 51.22,102.86 v1(50.9,102.86)
  IN1 w0.084: v1(50.9,102.86) 50.9,102.79 53.42,100.27 55.05,100.27 56.39,98.92 61.45,98.92 62.66,97.71 63.77,97.71 63.95,97.52 69.72,97.52 70.1,97.13 70.36,97.13 70.76,97.54 80.54,97.54 82.74,99.73 84.36,99.73 85.45,100.82 87.39,100.82 87.77,100.43 88.77,100.43 89.13,100.8 90.98,100.8 91.73,100.05 92.21,100.05 92.62,100.45 v2(92.66,100.45)
  IN3 w0.084: v3(93.04,100.45) 92.81,100.45 v2(92.66,100.45) ; v3(106.37,98.52) 105.87,99.02 v3(103.53,99.02)
  IN4 w0.089: v3(93.04,100.45) 94.66,100.45 95,100.11 97.72,100.11 98.3,99.53 103.02,99.53 v3(103.53,99.02) ; v3(106.37,98.52) 107.91,96.98 115.57,96.98 116.98,98.39 120.69,98.39 120.99,98.08 132.05,98.08 132.72,97.41 133.12,97.41 134.22,98.5 139.19,98.5 140.37,99.68 142.06,99.68 142.64,99.11 147.83,99.11 151.2,95.74 165.37,95.74 166.44,96.81 175.91,96.81 178.07,98.97 182.52,98.97 186.63,103.08 190.1,103.08 190.68,103.66 195.09,103.66 196.3,104.87 196.3,105.06 198.35,107.11 198.93,107.11 199.89,108.06 199.89,111.99 202.17,114.27 202.17,125.52 199.53,128.15 198.41,128.15 196.36,130.2 196.36,131.63 195.85,132.14 195.85,133.41 195.19,134.08 v4(195.17,134.08) 194.66,134.08 v4(194.32,133.74)
  BOTTOM w0.119: v4(195.17,134.08) 195.83,134.08 196.1,133.8 196.1,133.29 196.25,133.14 197.31,133.14 197.62,132.82 R347.1
DTDK2_ACOK: length 55.8
  IN4 w0.089: v5(193.32,137.24) 194.03,137.94 194.44,137.94 195.49,138.99 197.53,138.99 199.56,141.03 199.56,141.5 201.54,143.48 208.09,143.48 208.84,142.73 208.84,137.48 207.01,135.65 207.01,119.96 203.88,116.83 203.88,108.87 v4(204.11,108.64)
  BOTTOM w0.119: R500.1 v4(204.11,108.64)
DTDK_ACOK: length 105.6
  TOP w0.119: v13(188.71,100.42) 187.17,101.96 187.17,107.69 185.79,109.07 185.79,111.16 185.59,111.36 183.41,111.36 182.91,111.86 PU151.1
  IN2 w0.254: v2(133.15,94.57) 135.29,94.57 136.37,95.65 136.37,100.52 133.96,102.93 133.96,105.59 v2(133.31,106.24)
  IN3 w0.254: v2(133.15,94.57) 133.15,94.81 132.44,95.52 v3(132.44,95.65) ; v2(133.31,106.24) 133.53,106.02 v7(133.69,106.02)
  IN4 w0.089: v3(132.44,95.65) 132.97,95.12 135.8,95.12 136.11,95.43 141.27,95.43 144.38,98.54 146.3,98.54 147.37,97.47 147.37,94.87 148.13,94.11 165.94,94.11 166.61,94.78 176.12,94.78 178.84,97.49 183.88,97.49 186.81,100.42 v13(188.71,100.42)
  IN4 w0.254: v3(132.44,95.65) 132.28,95.65 131.7,96.23 v4(131.3,96.23)
  BOTTOM w0.119: v4(131.3,96.23) 131.3,96.34 132.72,97.76 JIO4.41
  BOTTOM w0.254: PD506.2 133.81,108.85 133.17,108.22 133.17,106.53 v7(133.69,106.02)
DTDK_PLUG#: length 10.2
  IN3 w0.084: v7(19.08,126.51) 19.05,126.48 18.03,126.48 17.42,127.09 17.12,127.09 16.74,127.47 v7(15.62,127.47)
  BOTTOM w0.119: UA3.8 15.8,130.02 15.62,129.83 v7(15.62,127.47) ; RA54.2 19.95,126.91 RA53.2 19.08,127.18 v7(19.08,126.51)
DWL_REQ: length 239
  IN1 w0.084: v2(214.93,98.38) 214.93,98.3 v1(215.19,98.03)
  IN3 w0.084: v7(214.57,98.35) 214.59,98.38 v2(214.93,98.38) ; v3(107.99,91.81) 107.31,92.49 98.28,92.49 97,93.76 87.17,93.76 86.36,92.96 86.36,91.06 85.98,90.68 63.4,90.68 62.68,89.96 48.08,89.96 45.47,92.57 44.77,92.57 44.26,93.09 44.26,97.13 44.62,97.49 44.62,99.9 43.06,101.46 43.06,108.2 43.59,108.73 43.59,109.55 43.43,109.71 43.43,110.21 43.43,110.75 43.62,110.94 43.62,115.85 42.03,117.44 42.03,120.33 v3(42.14,120.44)
  IN4 w0.06: v5(61.13,121.81) 60.59,121.81 60.57,121.78 60.03,121.78 59.86,121.61 58.9,121.61 58.75,121.76 58.53,121.76 58.28,121.51 57.18,121.51 56.32,122.37 54.44,122.37 54.42,122.35 54.34,122.35 54.34,122.35 54.27,122.35
  IN4 w0.089: v3(42.14,120.44) 42.82,120.44 44.21,121.82 46.32,121.82 46.98,122.48 47.93,122.48 48.07,122.62 48.07,123.91 47.8,124.18 47.8,124.98 47.95,125.14 50.44,125.14 51.29,124.29 51.95,124.29 52.1,124.15 52.1,123.74 53.46,122.37 54.09,122.37 54.11,122.35 54.27,122.35 ; v3(107.99,91.81) 108.65,91.15 154.81,91.15 155.41,91.75 174.81,91.75 178.11,95.05 201.58,95.05 202.83,96.3 v4(202.83,98.86)
  BOTTOM w0.119: JNFC1.6 213.97,97.76 v7(214.57,98.35) 214.68,98.46 214.68,99.75 214.19,100.24 208.3,100.24 206.92,98.85 202.84,98.85 202.84,98.86 v4(202.83,98.86)
E1_IMON_GT: length 4.1
  BOTTOM w0.254: PR1151.1 PC1144.1 113.53,123.78 113.53,121.4 PU1101.E1
E2_FCCM_SA: length 15.1
  TOP w0.254: PU1100.7 v13(107.22,109.13)
  IN3 w0.06: 112.52,117.57 112.54,117.57 112.55,117.58 112.55,119.85 113.33,120.63 v7(113.33,120.7)
  IN3 w0.084: 112.52,117.57 112.36,117.41 112.17,117.41 112.1,117.34
  IN3 w0.254: v13(107.22,109.13) 107.35,109.27 107.35,110.19 109.47,112.31 109.47,114.71 112.1,117.34
E3_PWM_SA: length 20.1
  TOP w0.254: PU1100.3 107.72,105.68 107.99,105.41 109.72,105.41 109.92,105.62 v1(109.92,106.21)
  IN1 w0.254: v2(111.79,109.87) 111.79,108.08 v1(109.92,106.21)
  IN3 w0.06: 113.62,117.89 113.51,118 113.51,118.28 113.11,118.68 113.11,119.32 113.21,119.42 113.41,119.42 113.56,119.57 113.56,119.96 v7(113.33,120.2)
  IN3 w0.254: 113.62,117.89 113.62,116.86 113.59,116.83 113.59,116 112.81,115.22 111.99,115.22 111.63,114.86 111.63,113.2 111.79,113.05 v2(111.79,109.87)
E4_LG: length 16.1
  TOP w0.254: PR1112.1 110.12,107.27 110.12,109.04 110.03,109.13 v13(110.03,109.14)
  IN3 w0.254: v7(113.33,119.7) 113.15,119.7 112.83,119.37 112.83,118.91 112.89,118.85 112.89,118.58 113.22,118.25 113.22,117.16 113.24,117.15 113.24,116.14 112.67,115.57 111.25,115.57 110.12,114.44 110.12,109.24 110.03,109.15 v13(110.03,109.14)
E8_IMON_IA: length 3.6
  BOTTOM w0.254: PR1152.1 113.31,115.14 113.31,116.04 113.47,116.19 PC1138.1 113.33,116.99 PU1101.E8
EC_ALWON: length 9.3
  IN1 w0.084: v1(198.02,143.13) v2(198.35,143.13)
  IN2 w0.079: v2(198.35,143.13) 198.35,139.78 195.97,137.4 195.82,137.4 195.33,136.91 v2(195.33,136.16)
  IN3 w0.084: v7(194.82,135.74) 194.83,135.74 195.25,136.16 v2(195.33,136.16)
EC_GPIO222: length 3.1
  IN4 w0.089: v4(191.82,132.24) 191.82,132.17 191.11,131.46 191.04,131.46 190.44,130.86 190.44,130.32 v4(190.07,129.95)
EC_IN_VOLUMEDOWN#: length 222.6
  TOP w0.119: v1(6.5,121.68) 7.34,121.68 7.52,121.86 C123.1 7.54,122.19 R124.1
  IN1 w0.084: v2(6.55,121.1) 6.55,121.63 v1(6.5,121.68)
  IN2 w0.079: v2(6.55,121.1) 6.57,121.11 6.85,121.11 7.73,120.23 13.46,120.23 15.16,121.93 15.16,138.51 15.55,138.9 28.05,138.9 40.73,151.58 60.95,151.58 74.06,138.47 96.24,138.47 96.4,138.64 103.83,138.64 v2(104.19,138.28)
  IN3 w0.084: v3(180,135.88) 184.37,135.88 184.73,135.52 185.34,135.52 v7(185.36,135.5) ; v2(104.19,138.28) 104.23,138.23 v3(104.23,137.86)
  IN4 w0.089: v5(189.32,135.74) 187.26,135.74 187.02,135.5 v7(185.36,135.5) ; v3(104.23,137.86) 105.39,136.71 122.96,136.71 123.6,136.07 123.6,135.94 126.28,133.26 126.76,133.26 127.51,132.5 131.07,132.5 132.37,133.8 133.08,133.8 133.31,134.03 133.81,134.03 135.37,135.58 135.37,135.77 136.28,136.68 169.51,136.68 173.85,132.34 177.33,132.34 180,135 v3(180,135.88)
EC_IN_VOLUMEUP#: length 240.5
  TOP w0.119: R21.1 6.73,136.38 C31.1
  IN1 w0.084: v2(6.2,136.18) 6.35,136.34 v1(6.73,136.34)
  IN2 w0.079: v2(104.8,138.27) 104.69,138.27 104.14,138.82 96.33,138.82 96.17,138.66 74.19,138.66 61.09,151.76 40.35,151.76 27.71,139.12 15.53,139.12 15.5,139.09 15.48,139.09 14.98,138.59 14.98,138.56 14.96,138.55 14.96,121.99 13.39,120.41 7.91,120.41 6.87,121.45 5.61,121.45 5.31,121.76 5.31,125.51 3.67,127.15 3.67,127.59 6.2,130.11 v2(6.2,136.18)
  IN3 w0.084: v3(104.67,137.86) 104.82,138.01 104.82,138.25 v2(104.8,138.27) ; v10(189.82,135.74) 189.09,135.74 187.73,137.1 187.01,137.1 185.99,136.08 v7(185.36,136.08) 184.69,136.08 184.53,136.25 180.07,136.25 v3(179.98,136.34)
  IN4 w0.089: v3(104.67,137.86) 105.64,136.9 123.04,136.9 123.79,136.15 123.79,136.02 126.36,133.45 126.83,133.45 127.59,132.69 130.99,132.69 132.29,133.99 133,133.99 135.89,136.87 169.59,136.87 173.93,132.53 177.25,132.53 179.7,134.98 179.7,136.06 v3(179.98,136.34)
EC_PROCHOT#: length 3.5
  TOP w0.119: Q6.2 190.15,131.96 v1(190.25,131.87)
  IN1 w0.084: v1(190.25,131.87) v2(190.53,131.59)
  IN3 w0.084: v3(190.99,131.92) 190.99,131.93 190.65,131.59 v2(190.53,131.59)
  IN4 w0.06: v4(191.32,133.24) 191.32,133.14 191.08,132.91 191.08,132.19 190.99,132.1 v3(190.99,131.92)
EC_SLP_S0IX#: length 3.7
  IN4 w0.089: v4(187.93,133.16) 188.51,133.74 v4(189.32,133.74)
  BOTTOM w0.119: R349.2 R348.2 187.3,132.53 v4(187.93,133.16)
EC_VR_ON: length 8.9
  IN1 w0.084: v2(199.29,132.38) 199.29,132.37 199.4,132.26 v1(199.4,131.02)
  IN3 w0.084: v10(193.82,134.74) 193.82,134.73 193.56,134.47 193.56,134.14 193.52,134.1 193.52,133.69 193.72,133.5 193.78,133.5 193.86,133.42 194.82,133.42 195.21,133.04 198.63,133.04 199.28,132.38 v2(199.29,132.38)
EDP_AUXN: length 39.9
  IN1 w0.109: v1(106.4,104.73) 106.4,105 v2(106.34,105.06)
  IN3 w0.06: v10(72.82,111.43) 72.82,111.22 73.02,111.02 73.02,110.86 73.02,110.85 72.94,110.77 72.94,110.58 73.56,109.96 73.56,109.07 74.18,108.45 74.18,108.32 74.78,107.72 74.78,107.6 74.99,107.39 74.99,107.15 76.9,105.23 76.9,104.84
  IN3 w0.084: v2(106.34,105.06) 106.53,104.87 106.53,104.79 106.28,104.54 96.56,104.54 96.49,104.48 90.86,104.48 90.59,104.21 89.85,104.21 89.44,103.8 83.41,103.8 82.98,103.36 78.34,103.36 76.9,104.81 76.9,104.84
EDP_AUXN_CONN: length 8.3
  IN1 w0.109: v2(106.45,102.15) 106.48,102.12 v1(106.48,101.8)
  IN2 w0.079: v2(109.89,99.84) 109.89,99.83 110.05,99.99 110.05,100.19 109.93,100.31 108.15,100.31 107.92,100.54 107.12,100.54 106.63,101.02 106.63,101.97 v2(106.45,102.15)
  IN3 w0.084: v7(109.89,98.88) 110.08,99.08 110.08,99.64 v2(109.89,99.84)
  BOTTOM w0.119: v7(109.89,98.88) 110.1,98.68 110.1,98.48 110.3,98.27 110.3,98.16 110.13,97.99 JEDP1.14
EDP_AUXN_R: length 1.2
  TOP w0.119: C149.2 106.52,104.02 106.52,103.67 106.6,103.59 106.6,103.36 106.48,103.24 L12.4
EDP_AUXP: length 39.8
  IN1 w0.109: v1(106.96,104.73) 106.96,104.96 v2(106.88,105.05)
  IN3 w0.06: v10(72.82,110.94) 72.82,110.94 72.82,110.53 73.44,109.91 73.44,109.02 74.06,108.4 74.06,108.27 74.66,107.67 74.66,107.55 74.87,107.34 74.87,107.1 76.78,105.18 76.78,104.92 76.74,104.88 76.74,104.84
  IN3 w0.084: 76.74,104.84 76.74,104.74 78.28,103.2 83.05,103.2 83.48,103.63 89.51,103.63 89.92,104.04 90.65,104.04 90.92,104.32 96.56,104.32 96.62,104.38 106.34,104.38 106.73,104.76 106.73,104.9 106.78,104.95 v2(106.88,105.05)
EDP_AUXP_CONN: length 8.2
  IN1 w0.109: v1(106.98,101.8) 106.98,102.13 v2(106.98,102.13)
  IN2 w0.079: v2(106.98,102.13) 106.82,101.97 106.82,101.1 107.19,100.73 108,100.73 108.23,100.5 110.01,100.5 110.24,100.27 110.24,100.05 v2(110.45,99.84)
  IN3 w0.084: v7(110.49,98.88) 110.25,99.13 110.25,99.64 v2(110.45,99.84)
  BOTTOM w0.119: JEDP1.12 110.73,98.11 110.56,98.28 110.56,98.38 110.36,98.59 110.36,98.75 v7(110.49,98.88)
EDP_AUXP_R: length 1.2
  TOP w0.119: L12.1 106.98,103.19 106.86,103.32 106.86,103.7 106.78,103.77 106.78,103.96 C150.2
EDP_CAB_DET#: length 89.2
  IN1 w0.084: v2(54.69,114.14) 55.29,113.53 55.29,113.07 55.44,112.91 55.44,112.01 57.68,109.78 57.68,108.83 58.67,107.84 59.72,106.79 60.39,106.79 61,106.17 61,105.82 60.45,105.28 60.45,103.34 62.22,101.58 62.55,101.58 62.63,101.5 63.15,101.5 63.89,100.75 63.89,100.23 65.11,99.01 67.65,99.01 68.53,99.89 71.99,99.89 72.41,99.47 76.99,99.47 77.19,99.67 78.03,99.67 78.74,100.38 79.99,100.38 81.28,101.67 83.44,101.67 84.74,102.96 87.03,102.96 87.2,103.14 88.67,103.14 88.93,103.39 93.46,103.39 95.45,101.4 95.82,101.4 95.94,101.51 99.19,101.51 100.02,100.69 104.04,100.69 106.13,98.6 113.59,98.6 v2(114.24,99.24)
  IN3 w0.06: v10(62.11,115.36) 62.11,115.37 62.04,115.45 61.99,115.45 61.87,115.57 61.87,115.57 61.75,115.68 60.86,115.68 60.42,115.24 59.52,115.24 58.83,114.55 56.84,114.55 56.51,114.21 56.18,114.21
  IN3 w0.084: v7(113.6,98.94) 113.91,99.24 v2(114.24,99.24) ; v7(52.45,114.14) 52.8,114.14 52.87,114.07 53.17,114.07 53.35,113.89 54.44,113.89 v2(54.69,114.14) 54.73,114.18 55.67,114.18 55.69,114.21 56.18,114.21
  BOTTOM w0.119: v7(113.6,98.94) 113.73,98.8 JEDP1.2 ; RH91.1 53.16,115.71 53,115.55 52.8,115.55 52.45,115.2 v7(52.45,114.14)
EDP_DISP: length 3.3
  BOTTOM w0.254: RC71.2 72.76,106.89 TC56.1 72.82,108.42 72.81,108.42 72.17,109.06 UC1.A40
EDP_HPD: length 63.9
  IN1 w0.084: v2(91.54,105.65) 91.39,105.5 88.29,105.5 88.04,105.25 83.79,105.25 82.09,103.56 80.03,103.56 79.14,102.67 77.5,102.67 76.47,101.64 75.47,101.64 74.77,100.94 72.69,100.94 72.27,101.36 69.29,101.36 68.42,102.23 66.62,102.23 66.57,102.28 64.78,102.28 64.07,102.99 63.44,102.99 62.34,104.09 62.34,106.61 v2(62.09,106.86)
  IN3 w0.084: v3(91.17,105.57) 91.26,105.65 v2(91.54,105.65)
  IN3 w0.119: v7(61.49,106.77) 62,106.77 v2(62.09,106.86)
  IN4 w0.089: v4(108.28,101.08) 107.26,102.1 101.47,102.1 100.67,101.3 96.55,101.3 96.46,101.39 95.72,101.39 94.75,102.37 93.29,102.37 92.35,103.31 92.1,103.31 91.68,103.73 91.68,105.06 v3(91.17,105.57)
  BOTTOM w0.119: JEDP1.18 108.93,99.01 108.28,99.66 v4(108.28,101.08) ; RC74.2 v7(61.49,106.77) 61.49,107.64 61.24,107.89 61.24,108.65 61.97,109.38 UC1.A7
EDP_TXN_P0: length 41.3
  IN1 w0.109: v1(108.36,104.73) 108.31,104.78 108.31,105.04 v2(108.38,105.12)
  IN3 w0.06: v10(73.78,111.18) 73.9,111.07 73.9,110.86 74.32,110.44 74.32,109.39 74.96,108.76 74.96,108.5 75.51,107.95 75.51,107.35 77.85,105.01 78.18,105.01 78.42,105.25 78.56,105.25 78.58,105.27 78.59,105.27
  IN3 w0.084: 78.59,105.27 78.82,105.27 79.15,104.94 79.92,104.94 79.96,104.98 80.67,104.98 80.71,104.94 80.96,104.94 81.01,104.9 82.07,104.9 82.22,105.05 83.91,105.05 84.07,104.89 88.92,104.89 89.43,105.39 90.19,105.39 90.96,106.16 91.88,106.16 92.47,105.58 96.04,105.58 96.1,105.64 105.27,105.64 105.82,106.2 107.38,106.2 107.56,106.02 107.63,106.02 107.81,106.2 108.08,106.2 108.23,106.05 108.23,105.27 v2(108.38,105.12)
