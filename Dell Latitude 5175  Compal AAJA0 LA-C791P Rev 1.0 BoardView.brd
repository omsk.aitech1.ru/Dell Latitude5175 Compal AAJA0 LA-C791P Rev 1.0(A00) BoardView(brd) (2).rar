# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCC_GT on VCC: 74.27,112.85 74.03,113.1 74.03,120.16 74.12,120.25 76.33,120.25 77.33,121.25 77.37,121.25 77.52,121.4 77.52,123.68 79.02,125.16 79.02,130.92 79.33,131.23 88.85,131.23 89.18,130.9 89.18,126.8 89.92,126.05 102.08,126.05 102.08,117.93 101.75,117.59 91.56,117.59 87.02,113.05 82.29,113.05 82.14,112.9 82.14,112.85
+VCC_GT on IN4: outline of 163 points within 72.89,112.36 103.16,125.08 ; 1 cut-out
+VCC_SA on BOTTOM (solid shape): 102.05,109.08 102.05,106.61 101.95,106.51 99.4,106.51 99.15,106.76 99.15,109.11 99.22,109.19 101.94,109.19
+VCC_SA on IN1 (solid shape): 68.65,119.3 68.7,119.28 68.72,119.23 68.75,119.13 68.8,119.05 68.8,118.34 68.72,118.14 68.8,117.93 68.8,117.21 68.74,116.9 69,116.71 69.06,116.67 69.09,116.6 69.09,116.29 69.06,116.22 69,116.19 68.72,115.88 69,115.58 69.06,115.55 69.09,115.48 69.09,115.18 69.06,115.11 69,115.08 68.72,114.78 69,114.47 69.06,114.44 69.09,114.37 69.09,114.07 69.06,114 69,113.97 68.72,113.66 69,113.36 69.06,113.33 69.09,113.26 69.47,112.88 69.47,112.59 69.46,112.58 69.46,112.34 69.37,112.25 69,112.25 68.98,112.26 68.89,112.35 68.58,112.35 68.55,112.35 68.32,112.58 68.32,112.7 68.32,112.71 68.34,112.82 68.32,112.93 68.32,112.94 68.32,114.12 68.32,114.12 68.34,114.23 68.32,114.34 68.32,114.34 68.32,114.97 68.32,114.98 68.34,115.08 68.32,115.18 68.32,115.19 68.32,116.71 68.32,116.72 68.34,116.82 68.32,116.92 68.32,116.93 68.32,118.03 68.34,118.14 68.33,118.24 68.32,118.25 68.32,119.15 68.34,119.2 68.44,119.3
+VCC_SA on IN2 (solid shape): 68.73,119.17 68.73,118.22 68.72,118.14 68.73,118.06 68.73,117.09 68.72,117.01 68.73,116.93 68.73,115.96 68.72,115.88 68.73,115.8 68.73,114.86 68.72,114.78 68.73,114.7 68.73,113.75 68.72,113.66 68.73,113.58 68.73,113.43 69.47,112.69 69.47,112.27 69.14,112.27 69.1,112.24 68.33,113.02 68.33,114.13 68.33,114.14 68.34,114.23 68.33,114.32 68.33,114.33 68.33,114.98 68.33,114.99 68.34,115.08 68.33,115.17 68.33,115.18 68.33,116.72 68.33,116.73 68.34,116.82 68.33,116.91 68.33,116.92 68.33,118.04 68.33,118.05 68.34,118.14 68.33,118.23 68.33,118.24 68.33,119.12 68.45,119.24 68.66,119.24
+VCC_SA on IN3 (solid shape): 68.73,119.73 68.73,113.27 69.47,112.54 69.47,112.33 69.32,112.18 69.19,112.18 69.11,112.26 68.93,112.26 68.41,112.78 68.41,112.97 68.33,113.05 68.33,119.62 68.45,119.75 68.71,119.75
+VCC_SA on IN4 (solid shape): 68.81,119.82 68.81,119.4 68.96,119.24 69.14,119.24 69.18,119.2 69.18,118.72 69.15,118.65 69.06,118.63 68.86,118.46 69.06,118.29 69.15,118.27 69.18,118.19 69.18,117.61 69.15,117.53 69.06,117.51 68.86,117.34 69.06,117.17 69.15,117.15 69.18,117.07 69.18,116.49 69.15,116.41 69.06,116.39 68.86,116.22 69.06,116.06 69.15,116.03 69.18,115.96 69.18,115.37 69.15,115.29 69.06,115.27 68.86,115.1 69.06,114.94 69.15,114.92 69.18,114.84 69.18,114.25 69.15,114.18 69.06,114.15 68.86,113.99 69.06,113.82 69.15,113.8 69.18,113.72 69.18,113.14 69.15,113.06 69.06,113.04 68.86,112.87 69.06,112.7 69.15,112.68 69.18,112.6 69.18,112.41 69.37,112.23 69.37,112.09 69.09,111.81 68.87,111.81 68.78,111.9 68.78,112.09 68.79,112.1 68.77,112.27 68.61,112.34 68.59,112.34 68.48,112.45 68.47,112.46 68.43,112.54 68.34,112.58 68.33,112.59 68.33,117.09 68.32,117.1 68.32,119.84 68.4,119.92 68.71,119.92
+VCC_SA on TOP: 82.89,103.32 81.8,104.41 75.96,104.41 75.49,104.88 73.09,104.88 72.86,104.65 71.44,104.65 71.2,104.41 69.06,104.41 67.94,105.53 67.94,116.07 68.04,116.17 68.73,116.17 68.85,116.05 68.85,112.18 68.8,112.13 68.35,112.13 68.3,112.08 68.3,110.87 68.37,110.8 68.86,110.8 68.94,110.88 68.94,111.37 69.02,111.45 69.36,111.45 69.42,111.39 69.42,110.99 69.65,110.76 70.08,110.76 71.83,109.01 79.68,109.01 80.35,108.33 83.35,108.33 83.96,107.72 88.42,107.72 88.48,107.66 94.3,107.66 94.36,107.72 94.8,107.72 95.87,108.79 98.87,108.79 99.3,109.22 101.97,109.22 102.06,109.13 102.06,107.93 102.53,107.46 104.73,107.46 104.94,107.24 104.94,105.53 104.36,104.95 104.36,104.1 104.3,104.05 103.62,104.05 102.88,104.79 101.92,104.79 98.42,104.79 97.17,103.53 96.3,103.53 96.09,103.32
+VCC_SA on VCC: 66.07,104.31 65.73,104.64 65.73,111.44 66.04,111.75 66.04,111.84 66.84,112.64 66.84,116.57 66.88,116.61 68.99,116.61 69.05,116.55 69.05,112.84 69.38,112.51 69.38,109.77 69.39,109.76 69.34,109.72 69.34,109.51 73.18,105.73 73.18,104.62 72.87,104.31
+VCC_SA_DDR on TOP (solid shape): 69.39,124.86 69.39,124.46 69.21,124.29 69.21,123.42 69.09,123.29 68.47,123.29 68.41,123.35 68.41,124.82 68.53,124.93 69.32,124.93
+VCC_SA_DDR on TOP (solid shape): 96.98,103.24 96.98,102.25 96.9,102.17 96.09,102.17 95.86,102.4 95.35,102.4 95.3,102.45 95.3,102.96 95.35,103.01 96.21,103.01 96.55,103.34 96.88,103.34
+VCC_SA_DDR on IN1 (solid shape): 97.12,102.5 98.15,102.5 98.27,102.39 98.27,102.12 98.2,102.05 96.36,102.05 96.32,102.1 96.32,102.53 96.47,102.68 96.94,102.68
+VCCAPLLEBB_1P0 on IN1 (solid shape): 64.44,113.14 64.44,112.29 64.33,112.17 62.58,112.17 62.53,112.22 62.53,112.88 62.6,112.94 63.85,112.94 64.1,113.19 64.39,113.19
+VCCCLK2 on IN3 (solid shape): 65.75,114.61 65.75,113.99 65.11,113.35 64.92,113.35 64.79,113.48 64.79,113.63 65.38,114.22 65.38,114.66 65.43,114.71 65.66,114.71
+VCCCLK3 on BOTTOM (solid shape): 68.02,108.24 68.02,107.99 67.94,107.91 67.54,107.91 67.28,107.66 66.22,107.66 66.17,107.71 66.17,108.14 66.47,108.45 67.82,108.45
+VCCCOREG0 on TOP (solid shape): 71.91,116.12 71.91,112.99 71.75,112.83 70.8,112.83 70.76,112.86 70.76,116.09 70.84,116.17 71.86,116.17
+VCCCOREG0 on BOTTOM (solid shape): 70.71,115.82 70.71,112.71 70.66,112.66 70.36,112.66 70.32,112.7 70.32,115.83 70.36,115.86 70.66,115.86
+VCCCOREG0 on BOTTOM (solid shape): 71.7,115.81 71.7,112.72 71.64,112.67 71.34,112.67 71.31,112.7 71.31,115.83 71.34,115.87 71.64,115.87
+VCCCOREG0 on IN1 (solid shape): outline of 222 points within 70.26,112.64 71.89,116.01
+VCCCOREG0 on IN2 (solid shape): outline of 146 points within 70.28,112.61 71.78,115.31
+VCCCOREG0 on IN3 (solid shape): outline of 146 points within 70.28,112.61 71.78,115.31
+VCCCOREG0 on IN4 (solid shape): 71.69,115.66 71.69,112.82 71.62,112.76 71.28,112.76 71.24,112.76 71.22,112.78 71.2,112.8 71.19,112.82 71.18,112.88 71.17,112.91 71.16,112.95 71.14,112.98 71.11,113.01 71.08,113.03 71.05,113.04 71.01,113.04 70.97,113.04 70.94,113.03 70.9,113.01 70.88,112.98 70.86,112.95 70.84,112.91 70.84,112.88 70.83,112.82 70.82,112.8 70.8,112.78 70.78,112.76 70.74,112.76 70.42,112.76 70.33,112.85 70.33,114.08 70.79,114.08 70.79,113.33 70.93,113.2 71.11,113.2 71.25,113.33 71.25,114.05 71.11,114.19 70.9,114.19 70.79,114.08 70.33,114.08 70.33,115.22 70.79,115.22 70.79,114.43 70.9,114.32 71.11,114.32 71.25,114.45 71.25,115.2 71.11,115.33 70.9,115.33 70.79,115.22 70.33,115.22 70.33,115.69 70.41,115.77 71.58,115.77
+VCCCOREG0 on VCC: 70.79,112.78 70.47,113.1 70.47,116.35 70.49,116.36 72.2,116.36 72.29,116.27 72.3,116.27 72.3,113.12 71.96,112.78
+VCCCOREG1 on TOP (solid shape): 72.44,119.52 72.44,119.14 72.39,119.09 72.01,119.09 71.88,118.96 71.88,116.37 71.78,116.27 71.5,116.27 71.45,116.32 71.45,116.78 71.37,116.86 70.89,116.86 70.79,116.96 70.79,119.45 70.92,119.57 72.39,119.57
+VCCCOREG1 on BOTTOM (solid shape): 70.71,119.73 70.71,116.62 70.66,116.58 70.36,116.58 70.32,116.61 70.32,119.74 70.36,119.78 70.66,119.78
+VCCCOREG1 on BOTTOM (solid shape): 71.7,119.72 71.7,116.62 71.65,116.57 71.34,116.57 71.3,116.61 71.3,119.73 71.34,119.77 71.65,119.77
+VCCCOREG1 on IN1 (solid shape): outline of 206 points within 70.28,116.52 71.87,119.65
+VCCCOREG1 on IN2 (solid shape): outline of 190 points within 70.28,116.55 71.77,119.75
+VCCCOREG1 on IN3 (solid shape): outline of 190 points within 70.28,116.55 71.77,119.75
+VCCCOREG1 on IN4 (solid shape): outline of 97 points within 70.33,116.67 71.69,119.68
+VCCCOREG1 on VCC: 70.33,116.49 70.19,116.63 70.19,119.32 70.38,119.51 71.88,119.51 72.3,119.09 72.3,116.55 72.29,116.55 72.24,116.49
+VCCPRIM_1P0 on TOP (solid shape): 64.08,118.81 64.08,118.48 64.03,118.43 62.56,118.43 62.48,118.51 62.48,119.22 62.65,119.38 63.51,119.38
+VCCPRIM_1P0 on TOP (solid shape): 56.29,121.53 56.29,121.17 56.39,121.07 57.81,121.07 57.86,121.02 57.86,120.03 57.78,119.95 56.44,119.95 56.24,119.75 55.55,119.75 55.47,119.83 55.47,121.58 55.52,121.63 56.18,121.63
+VCCPRIM_1P0 on BOTTOM (solid shape): 60.4,114.57 60.6,114.47 60.81,114.56 60.93,114.56 60.97,114.52 61.01,114.5 61.04,114.48 61.04,114.32 61.01,114.3 60.91,114.2 60.87,114.06 60.86,114.02 60.83,114 60.76,113.98 60.7,113.93 58.47,113.93 58.37,114.04 58.37,114.52 58.42,114.57
+VCCPRIM_1P0 on GND1 (solid shape): 57.78,120.69 57.78,119.41 57.68,119.32 57.29,119.32 56.86,119.75 56.86,120.52 57.08,120.74 57.72,120.74
+VCCPRIM_1P0 on IN1 (solid shape): 57.73,120.66 57.73,119.42 57.59,119.27 56.9,119.27 56.86,119.32 56.86,120.52 57.08,120.74 57.66,120.74
+VCCPRIM_1P0 on IN2 (solid shape): outline of 1175 points within 56.92,113.78 66.45,121.02
+VCCPRIM_1P0 on GND3 (solid shape): 65.43,118.32 65.43,117.82 65.69,117.56 65.69,117.26 65.64,117.21 65.53,117.21 65.45,117.29 65.18,117.29 65.1,117.21 64.98,117.21 64.93,117.25 64.93,118.52 65.01,118.59 65.16,118.59
+VCCPRIM_1P0 on IN4 (solid shape): 65.23,118.56 65.23,117.57 65.28,117.52 65.66,117.52 65.71,117.46 65.71,117.24 65.66,117.19 64.95,117.19 64.9,117.24 64.9,118.56 64.95,118.61 65.18,118.61
+VCCPRIM_3P3 on BOTTOM (solid shape): 58.09,116.35 60.08,116.35 60.26,116.16 60.72,116.16 60.78,116.12 60.85,116.1 60.9,116.05 60.9,116.03 60.93,115.9 61.02,115.8 61.05,115.79 61.05,115.66 60.92,115.53 60.79,115.53 60.66,115.66 59.88,115.66 59.75,115.79 57.74,115.79 57.49,116.04 56.84,116.04 56.69,116.19 56.69,117.09 56.77,117.16 57.28,117.16
+VCCPRIM_3P3 on VCC (solid shape): 66,118.33 66,117.83 65.73,117.57 64.84,117.57 64.78,117.63 64.78,118.07 65.1,118.4 65.93,118.4
+VCCPRIM_3P3 on VCC (solid shape): 57.6,116.88 59.21,116.88 59.21,116.45 58.88,116.12 55.91,116.12 55.7,116.32 55.7,117.08 55.78,117.16 57.33,117.16
+VCCPRIM_3P3 on GND3 (solid shape): 57.57,116.75 57.57,116.4 57.71,116.26 58,116.26 58.14,116.12 58.14,115.82 58.09,115.78 57.27,115.78 56.72,116.33 56.72,116.65 56.89,116.82 57.5,116.82
+VCCPRIM_3P3 on IN4 (solid shape): 65.71,118.61 65.71,118.18 65.81,118.07 66.14,118.07 66.22,118 66.22,117.24 66.17,117.19 65.89,117.19 65.84,117.24 65.84,117.57 65.73,117.67 65.43,117.67 65.38,117.72 65.38,118.61 65.43,118.66 65.66,118.66
+VCCPRIM_CORE on TOP (solid shape): 56.72,119.19 56.72,118.94 56.95,118.71 56.95,117.77 56.84,117.67 55.65,117.67 55.52,117.8 55.52,119.14 55.63,119.24 56.67,119.24
+VCCPRIM_CORE on TOP (solid shape): 65.79,119.53 65.79,116.22 65.55,115.98 64.69,115.98 64.48,116.19 64.48,116.69 64.49,116.7 64.49,117.66 64.48,117.68 64.48,118.94 63.95,119.47 63.95,120.12 64.04,120.22 65.1,120.22
+VCCPRIM_CORE on VCC (solid shape): outline of 109 points within 55.55,118.09 64.7,120.22
+VCCPRIM_CORE on GND1 (solid shape): 65.79,117.13 65.79,116.38 65.61,116.19 64.97,116.19 64.77,116.4 64.77,117.06 64.91,117.2 65.72,117.2
+VCCPRIM_CORE on IN1 (solid shape): 65.79,117.13 65.79,116.38 65.61,116.19 64.97,116.19 64.77,116.4 64.77,117.06 64.91,117.2 65.72,117.2
+VCCSRAM_1P0 on TOP (solid shape): 57.99,115.76 57.99,115.28 57.98,115.27 57.98,114.99 57.61,114.62 56.18,114.62 56.11,114.7 56.11,115.71 56.21,115.81 57.94,115.81
+VCCSRAM_1P0 on TOP (solid shape): 66.84,119.41 66.84,115.96 66.4,115.52 66.4,115.03 66.35,114.98 65.58,114.98 65.49,115.06 65.49,115.67 65.9,116.09 65.9,119.44 65.96,119.5 66.75,119.5
+VCCSRAM_1P0 on VCC (solid shape): 63.18,116.35 63.33,115.95 63.49,116.35 64.84,116.35 64.95,116.32 65.05,116.35 65.84,116.35 66.34,115.84 66.34,115.28 66.19,115.13 65.66,115.13 65.57,115.22 65.57,115.5 65.4,115.66 61.49,115.66 61.19,115.36 59.74,115.36 59.61,115.23 57.15,115.23 57.07,115.31 57.07,115.74 57.18,115.84 58.98,115.84 59.21,116.07 60.96,116.07 61.24,116.35
+VDDQ_CPU_CLK on TOP (solid shape): 73.33,122.7 73.33,122.27 73.15,122.09 71.83,122.09 71.81,122.11 71.81,122.52 71.83,122.54 72.42,122.54 72.67,122.8 73.23,122.8
AGND on TOP (solid shape): 143.59,101.89 144.4,101.89 144.42,101.87 144.42,101.46 144.4,101.44 143.36,101.44 142.72,102.07 142.39,102.07 142.22,102.24 142.22,102.61 142.27,102.66 142.82,102.66
AGND on TOP (solid shape): 135.69,103.47 135.69,101.4 135.7,101.4 135.7,100.76 135.93,100.52 138.66,100.52 138.86,100.73 138.86,101.21 138.91,101.26 139.47,101.26 139.52,101.21 139.52,100.65 139.65,100.52 141.45,100.52 141.53,100.6 141.53,101.26 141.63,101.36 141.96,101.36 142.13,101.2 142.13,100.26 141.83,99.96 135.45,99.96 135.19,100.22 135.19,103.42 135.31,103.54 135.62,103.54
AGND on BOTTOM (solid shape): 134.82,99.46 134.82,98 134.91,97.91 134.91,97.39 134.3,96.78 133.62,96.78 133.55,96.71 133.55,96.32 133.82,96.05 133.92,96.05 134.43,95.54 134.43,94.95 134.37,94.88 133.88,94.88 133.82,94.95 133.82,95.6 133.29,96.13 133.29,97.22 133.43,97.36 133.43,98.85 133.63,98.85 133.63,97.6 133.92,97.31 134.28,97.31 134.72,97.75 134.72,97.93 134.62,98.03 134.62,98.8 134.51,98.92 133.7,98.92 133.63,98.85 133.43,98.85 133.43,99.91 133.71,100.19 134.09,100.19
AGND on IN1 (solid shape): 142.42,103.81 145.48,103.81 145.74,103.55 145.74,103.01 145.67,102.94 143.08,102.94 142.04,101.9 137.5,101.9 137.41,101.99 137.41,102.12 137.42,102.12 137.49,102.18 137.49,102.66 137.25,102.89 135.45,102.89 135.28,103.06 135.28,103.55 135.49,103.76 136.71,103.76 137.44,104.49 141.74,104.49
AGND on IN4 (solid shape): outline of 304 points within 8.02,121.25 13.44,144.54
AGND on IN4 (solid shape): outline of 364 points within 5.71,122.27 8.59,130.84
AGND on TOP: 145.25,104.44 145.25,104.32 147.97,101.6 147.97,101.31 147.88,101.22 147.62,101.22 147.5,101.09 147.5,100.31 147.43,100.24 147.14,100.24 147.05,100.33 147.05,101.02 147.17,101.13 147.17,101.81 146.02,102.95 144.77,102.95 144.69,103.03 144.69,104.42 144.75,104.48 145.21,104.48
AGND on VCC: 7.72,129.02 7.52,129.23 7.52,139.49 7.14,139.87 5.92,139.87 5.87,139.95 5.87,140.78 6.38,141.29 6.38,143.32 6.76,143.7 6.76,144.57 3.83,144.57 3.83,144.77 3.67,145.3 3.09,145.74 3.03,145.91 3.03,146.3 3.12,146.51 3.33,146.6 13.56,146.6 14.26,147.2 13.76,147.97 13.76,153.43 14.26,154.2 13.56,154.8 2.48,154.8 2.27,154.89 2.18,155.1 2.18,155.5 2.35,156.13 2.81,156.61 13.2,156.61 15.77,154.04 15.77,145.94 12.39,142.56 11.35,142.56 11.1,142.31 11.1,142 10.94,141.85 10.41,141.85 10.06,141.5 10.06,139.38 10.38,139.06 11.08,138.22 11.86,138.22 11.96,138.11 11.96,135.55 11.81,135.4 11.5,135.4 10.87,134.77 10.87,133.32 10.66,133.11 10.21,133.11 9.91,132.81 9.91,129.36 9.57,129.02
AGND on GND1: 7.72,129.02 7.52,129.23 7.52,139.49 7.14,139.87 5.92,139.87 5.87,139.95 5.87,140.78 6.38,141.29 6.38,143.32 6.76,143.7 6.76,144.57 3.83,144.57 3.83,144.77 3.67,145.3 3.09,145.74 3.03,145.91 3.03,146.3 3.12,146.51 3.33,146.6 13.56,146.6 14.26,147.2 13.76,147.97 13.76,153.43 14.26,154.2 13.56,154.8 2.48,154.8 2.27,154.89 2.18,155.1 2.18,155.5 2.35,156.13 2.81,156.61 13.2,156.61 15.77,154.04 15.77,145.94 12.39,142.56 11.35,142.56 11.1,142.31 11.1,142 10.94,141.85 10.41,141.85 10.06,141.5 10.06,139.38 10.38,139.06 11.08,138.22 11.86,138.22 11.96,138.11 11.96,135.55 11.81,135.4 11.5,135.4 10.87,134.77 10.87,133.32 10.66,133.11 10.21,133.11 9.91,132.81 9.91,129.36 9.57,129.02
AGND on GND2: 9.71,121.25 9.65,121.3 9.65,121.91 9.3,122.27 6.02,122.27 5.71,122.57 5.71,129.15 7.52,130.95 7.52,144.04 6.99,144.57 3.83,144.57 3.83,144.77 3.67,145.3 3.09,145.74 3.03,145.91 3.03,146.3 3.12,146.51 3.33,146.6 13.56,146.6 14.26,147.2 13.76,147.97 13.76,153.43 14.26,154.2 13.56,154.8 2.48,154.8 2.27,154.89 2.18,155.1 2.18,155.5 2.36,156.14 2.82,156.62 3.55,156.61 13.2,156.61 15.77,154.04 15.77,145.94 12.39,142.56 11.35,142.56 11.1,142.31 11.1,142 10.94,141.85 10.41,141.85 10.06,141.5 10.06,139.38 10.38,139.06 11.08,138.22 11.86,138.22 11.96,138.11 11.96,135.55 11.81,135.4 11.5,135.4 10.87,134.77 10.87,133.32 10.66,133.11 10.21,133.11 9.91,132.81 9.91,127.6 10.28,127.22 13.2,127.22 13.28,127.14 13.28,125.98 13.08,125.77 13.08,122.64 13.21,122.52 13.21,121.81 12.65,121.25
AGND on GND3: 9.71,121.25 9.65,121.3 9.65,121.91 9.3,122.27 6.02,122.27 5.71,122.57 5.71,129.15 7.52,130.95 7.52,144.04 6.99,144.57 3.83,144.57 3.83,144.77 3.67,145.3 3.09,145.74 3.03,145.91 3.03,146.3 3.12,146.51 3.33,146.6 13.56,146.6 14.26,147.2 13.76,147.97 13.76,153.43 14.26,154.2 13.56,154.8 2.48,154.8 2.27,154.89 2.18,155.1 2.18,155.5 2.35,156.13 2.81,156.61 13.12,156.61 15.77,153.95 15.77,145.94 12.39,142.56 11.35,142.56 11.1,142.31 11.1,142 10.94,141.85 10.41,141.85 10.06,141.5 10.06,139.38 10.38,139.06 11.08,138.22 11.86,138.22 11.96,138.11 11.96,135.55 11.81,135.4 11.5,135.4 10.87,134.77 10.87,133.32 10.66,133.11 10.21,133.11 9.91,132.81 9.91,127.6 10.28,127.22 12.89,127.22 12.96,127.28 13.26,127.28 13.44,127.1 13.44,125.96 13.22,125.75 13.22,123.67 13.08,123.53 13.08,122.64 13.21,122.52 13.21,121.81 12.65,121.25
GND on TOP (solid shape): 109.22,128.41 109.22,127.42 105.64,127.42 105.54,127.52 105.54,128.34 105.64,128.44 109.19,128.44
GND on TOP (solid shape): 27.33,119.9 27.33,118.25 27.25,118.18 24.54,118.18 24.41,118.3 24.41,119.95 24.51,120.06 27.18,120.06
GND on TOP (solid shape): 44.37,139.87 44.12,139.61 44.12,138.62 44.07,138.57 43.76,138.57 43.76,140.38 43.84,140.45 44.37,140.45
GND on TOP (solid shape): 45.84,104.02 45.84,102.59 45.82,102.58 45.21,102.58 45.17,102.62 45.17,104.07 45.22,104.11 45.75,104.11
GND on TOP (solid shape): 99.11,117.16 99.11,115.46 99.03,115.38 95.81,115.38 95.53,115.66 95.53,117.06 95.73,117.26 99.01,117.26
GND on TOP (solid shape): 108.94,111.46 108.94,110.48 108.74,110.28 107.02,110.28 106.91,110.39 106.91,111.48 106.98,111.56 108.84,111.56
GND on TOP (solid shape): 42.57,102.71 42.57,101.48 42.47,101.39 40.94,101.39 40.72,101.62 40.72,102.73 40.79,102.81 42.47,102.81
GND on TOP (solid shape): 58.69,104.96 58.69,102.91 58.53,102.75 56.52,102.75 56.36,102.91 56.36,104.96 56.44,105.03 58.61,105.03
GND on TOP (solid shape): 49.1,137.63 49.1,136.77 46.43,136.77 46.28,136.92 46.28,137.63 46.3,137.66 49.07,137.66
GND on TOP (solid shape): 58.27,123.41 58.27,122.44 58.25,122.42 57.08,122.42 57.05,122.45 57.05,123.38 57.09,123.42 57.9,123.42 57.97,123.49 58.19,123.49
GND on TOP (solid shape): 87.48,108.93 87.48,108.22 87.3,108.04 84,108.04 83.49,108.55 80.29,108.55 80.24,108.6 80.24,109.03 80.29,109.08 87.32,109.08
GND on TOP (solid shape): 89.51,123.71 89.51,123.13 89.69,122.95 89.69,122.44 89.66,122.42 89.33,122.42 88.79,122.96 88.79,123.68 88.85,123.74 89.48,123.74
GND on TOP (solid shape): 105.38,129.28 106.04,129.28 106.12,129.2 106.12,128.79 105.97,128.64 105.41,128.64 105.16,128.89 104.29,128.89 104.19,129 104.19,129.45 104.24,129.5 105.16,129.5
GND on TOP (solid shape): 72.92,111.09 77.5,111.09 77.55,111.04 77.55,110.68 77.52,110.66 72.54,110.66 72.47,110.73 72.47,111.11 72.49,111.14 72.87,111.14
GND on TOP (solid shape): 41.44,34.77 41.44,34.06 41.41,34.02 39.96,34.02 39.93,34.06 39.93,34.19 39.94,34.25 39.93,34.32 39.93,34.79 39.97,34.83 41.38,34.83
GND on TOP (solid shape): 76.96,121.94 76.96,121.58 76.86,121.48 69.34,121.48 69.29,121.43 68.4,121.43 68.35,121.48 68.35,121.88 68.43,121.96 76.94,121.96
GND on TOP (solid shape): 111.49,99.05 66.99,99.05 66.99,125.79 67.79,125.79 67.79,99.85 110.69,99.85 110.69,130.79 81.64,130.79 81.64,125.79 66.99,125.79 66.99,126.59 80.84,126.59 80.84,131.59 111.49,131.59
GND on TOP (solid shape): 36.46,108.64 36.46,107.94 36.58,107.82 36.58,106.95 35.86,106.95 35.86,106.94 35.76,106.94 35.76,106.95 35.04,106.95 34.97,107.01 34.97,107.26 34.98,107.26 34.98,107.97 35.1,108.1 35.1,108.67 36.43,108.67
GND on TOP (solid shape): 54.01,114.49 54.99,114.49 55.07,114.42 55.07,113.57 54.89,113.39 53.95,113.39 53.68,113.12 53.68,112.49 53.49,112.3 52.65,112.3 52.59,112.36 52.59,113.17 52.84,113.43 52.84,114.68 52.93,114.77 53.73,114.77
GND on TOP (solid shape): 72.29,125.11 72.29,122.77 72.16,122.65 68.4,122.65 68.35,122.7 68.35,123.1 68.38,123.13 69.14,123.13 69.54,123.54 69.54,124.88 69.85,125.19 72.21,125.19
GND on TOP (solid shape): 50.36,131.55 50.36,130.53 50.26,130.43 49.59,130.43 49.4,130.24 49.4,129.76 49.34,129.71 48.36,129.71 48.3,129.77 48.3,130.44 48.92,131.06 48.92,131.25 49.01,131.34 49.42,131.34 49.66,131.58 50.32,131.58
GND on TOP (solid shape): 36.54,37.55 36.6,37.5 36.68,37.48 36.75,37.45 36.78,37.38 36.78,36.82 36.69,36.73 36.69,34.85 35.75,34.85 35.75,36.42 36.46,37.13 36.46,37.44 36.45,37.45 36.45,37.57 36.52,37.57
GND on TOP (solid shape): 58.02,119.83 58.39,119.83 58.5,119.73 58.5,117.85 58.29,117.64 57.56,117.64 57.53,117.62 57.17,117.62 57.07,117.72 57.07,118.91 57,118.99 57,119.23 56.89,119.34 56.71,119.34 56.71,119.34 56.49,119.34 56.43,119.41 56.43,119.76 56.5,119.84 58.02,119.84
GND on TOP (solid shape): 38.37,46.72 38.28,46.56 38.32,46.38 37.74,45.8 37.74,45.06 37.52,44.83 37.13,44.83 36.91,44.62 36.47,44.62 36.47,47.01 36.35,47.14 36.35,47.21 36.28,47.21 36.25,47.24 35.73,47.24 35.68,47.29 35.68,48.11 38.37,48.11
GND on TOP (solid shape): 192.71,125.67 192.71,122.52 192.58,122.39 186.21,122.39 185.98,122.62 185.98,123.79 186.02,123.93 185.98,124.06 185.98,124.56 185.37,125.17 185.37,125.31 185.51,125.45 186.9,125.45 187.53,124.83 188.19,124.83 188.21,124.85 189.95,124.85 190.44,125.34 190.44,126.38 190.68,126.62 191.76,126.62
GND on TOP (solid shape): 219.81,90.05 215.68,90.05 215.12,90.29 214.88,90.85 214.88,91.55 214.83,91.9 214.68,92.22 214.68,93.98 219.81,93.98
GND on TOP (solid shape): 40.52,43.41 40.61,43.35 40.6,43.25 39.86,42.51 39.58,42.51 39.45,42.37 39.45,42.23 39.37,42.23 39.35,42.26 39.29,42.32 39.2,42.35 39.19,42.35 39.17,42.37 39.16,42.43 39.2,42.46 39.36,42.46 39.52,42.62 39.52,42.75 39.59,42.81 39.79,42.81 40.39,43.41
GND on TOP (solid shape): 219.81,148.93 209.03,148.93 208.23,149.76 207.43,148.93 204.66,148.93 204.66,152.9 219.81,152.9
GND on TOP (solid shape): 38.81,68.02 38.58,67.62 38.83,67.22 20.92,67.22 20.92,28.52 44.71,28.52 44.71,33.33 45.11,33.1 45.51,33.33 45.51,27.72 20.12,27.72 20.12,68.02
GND on TOP (solid shape): 38.46,89.97 38.22,89.57 38.46,89.17 24.16,89.17 24.16,69.32 44.65,69.32 44.65,69.03 44.99,68.59 45.51,68.8 45.51,68.52 23.36,68.52 23.36,89.97
GND on TOP (solid shape): 22.95,113.84 23.01,113.82 23.05,113.76 23.05,113.72 23.05,112.73 23.19,112.39 23.54,112.27 23.63,112.21 23.61,112.1 23.28,111.78 22.83,111.78 22.83,111.01 23.55,111.01 23.55,111.46 23.77,111.69 24.56,111.69 24.56,110.85 24.09,110.85 23.25,110.85 23.25,110.39 23.22,110.35 21.48,110.35 21.06,110.78 21.06,113.7 21.19,113.84
GND on TOP (solid shape): 34.01,47.39 34.59,47.39 34.7,47.28 34.7,46.47 35.26,46.47 35.59,46.15 35.59,43.52 35.61,43.49 35.62,43.44 35.57,43.41 35.5,43.41 35.35,43.25 35.16,43.44 34.52,43.44 34.2,43.76 34.19,43.87 34.28,43.92 34.93,43.92 34.93,45.09 33.81,45.09 33.81,44.39 33.75,44.3 33.65,44.31 32.95,44.31 32.79,44.47 32.79,45.09 33.08,45.38 33.08,47.29 33.41,47.62 33.78,47.62
GND on TOP (solid shape): 40.63,51.28 40.63,50.81 40.59,50.73 40.51,50.71 40.39,50.7 40.28,50.64 40.26,50.62 40.16,50.62 40.16,51.2 39.45,51.2 39.45,50.43 39.74,50.43 39.84,50.37 39.82,50.26 39.56,50.01 39.04,50.01 39.04,49.28 39.04,49.22 38.22,49.22 38.14,49.32 38.01,49.36 37.98,49.37 37.97,49.41 37.97,49.94 38.78,49.94 39.05,50.22 39.05,50.43 39.24,50.43 39.24,51.2 38.73,51.2 38.73,51.21 36.41,51.21 36.41,51.27 36.44,51.31 36.46,51.37 40.54,51.37
GND on TOP (solid shape): 76.35,120.08 76.35,119.78 76.3,119.73 73.99,119.73 73.84,119.57 73.84,119.14 74.02,118.96 74.5,118.96 74.57,118.89 74.57,118.51 74.5,118.43 74.04,118.43 73.96,118.35 73.96,117.82 74.07,117.72 76.58,117.72 76.66,117.64 76.66,117.34 76.58,117.26 74.04,117.26 73.94,117.16 73.94,116.73 74.09,116.58 74.52,116.58 74.57,116.53 74.57,116.09 74.52,116.04 74.19,116.04 74.09,115.94 74.09,115.43 74.22,115.31 76.63,115.31 76.68,115.26 76.68,115.05 76.56,114.92 74.24,114.92 74.12,114.8 74.12,114.26 74.22,114.16 76.56,114.16 76.61,114.11 76.61,113.76 76.53,113.68 74.12,113.68 73.96,113.53 73.96,113.1 74.12,112.94 76.86,112.94 77.19,113.27 77.19,113.93 77.2,113.95 77.2,114.05 77.27,114.11 80.44,114.11 80.9,113.65 83.31,113.65 83.44,113.53 83.44,112.82 83.29,112.66 80.74,112.66 80.61,112.53 77.06,112.53 76.9,112.37 73.39,112.37 73.25,112.51 73.25,119.55 73.1,119.7 71.5,119.7 71.4,119.8 71.4,120.06 71.48,120.13 76.3,120.13
GND on TOP (solid shape): 70.54,120.51 70.54,120.08 70.61,120 70.61,119.95 70.64,119.95 70.64,112.79 70.74,112.69 71.75,112.69 72.06,112.99 72.06,118.94 72.11,118.99 72.39,118.99 72.47,118.91 72.47,112.89 72.19,112.61 72.19,111.67 72.14,111.62 70.71,111.62 70.71,112.26 70.61,112.36 69.14,112.36 68.99,112.51 68.99,113.93 69.47,113.93 69.47,113.15 69.54,113.07 70.15,113.07 70.21,113.12 70.21,113.91 70.08,114.04 69.57,114.04 69.47,113.93 68.99,113.93 68.99,117.14 69.47,117.14 69.47,117.11 69.47,116.25 70.05,116.25 70.05,117.36 69.47,117.36 69.47,117.14 68.99,117.14 68.99,117.86 70.03,117.86 70.03,118.44 69.47,118.44 69.47,117.86 68.99,117.86 68.99,119.9 69.47,119.9 69.47,119.32 70.03,119.32 70.03,119.57 70.05,119.6 70.06,119.64 70.07,119.68 70.07,119.73 70.06,119.77 70.05,119.81 70.03,119.84 70.03,119.9 69.96,119.9 69.93,119.92 69.89,119.93 69.84,119.93 69.8,119.93 69.76,119.92 69.73,119.9 68.99,119.9 68.99,120.68 70.37,120.68
GND on TOP (solid shape): 35.75,113.78 36.14,113.78 36.14,112.94 36.04,112.84 35.89,112.84 35.35,112.84 35.14,112.7 35.19,112.45 35.22,112.38 35.19,112.31 35.1,112.22 35.1,111.99 35.15,111.94 35.15,111.72 35.15,111.71 35.12,111.61 35.15,111.51 35.15,111.5 35.15,111 35.15,111 35.15,110.02 35.08,109.95 34.19,109.95 34.08,110.06 34.07,111.05 33.56,111.05 33.48,111.07 33.39,111.05 33.2,111.05 33.12,111.07 33.03,111.05 32.82,111.05 32.82,111.58 33.04,111.8 33.8,111.8 33.93,111.94 33.93,112.22 33.85,112.31 33.82,112.38 33.85,112.45 33.92,112.62 33.84,112.78 33.8,112.86 33.84,112.94 33.91,113.17 33.73,113.33 33.73,113.65 34.63,113.65 34.79,113.81 34.79,114.5 35.75,114.5
GND on TOP (solid shape): 9.05,112.85 9.29,119.16 14.06,115.03 13.96,114.72 13.83,114.43 13.79,114.35 13.32,114.13 13.13,113.65 12.89,113.09 12.33,112.85 11.81,112.85
GND on TOP (solid shape): outline of 283 points within 35.41,38.52 39.34,41.82
GND on TOP (solid shape): outline of 6764 points within 0.2,0.2 222.87,166.7
GND on BOTTOM (solid shape): 35.27,61.76 27.27,61.76 27.27,69.76 35.27,69.76
GND on BOTTOM (solid shape): 41.36,50.65 33.36,50.65 33.36,58.65 41.36,58.65
GND on BOTTOM (solid shape): 42.77,36.82 27.77,36.82 27.77,46.82 42.77,46.82
GND on BOTTOM (solid shape): 94.08,119.37 94.08,118.67 91.91,118.67 91.85,118.73 91.85,119.34 91.92,119.42 94.03,119.42
GND on BOTTOM (solid shape): 26.11,110.53 26.11,109.53 26.03,109.45 25.17,109.45 25.03,109.59 25.03,110.53 25.08,110.58 26.06,110.58
GND on BOTTOM (solid shape): 70.21,119.73 70.21,116.63 70.16,116.58 69.86,116.58 69.82,116.62 69.82,119.74 69.86,119.78 70.16,119.78
GND on BOTTOM (solid shape): 70.21,115.81 70.21,112.71 70.16,112.66 69.86,112.66 69.82,112.7 69.82,115.82 69.86,115.86 70.16,115.86
GND on BOTTOM (solid shape): 71.2,119.72 71.2,116.62 71.15,116.57 70.85,116.57 70.81,116.61 70.81,119.73 70.85,119.77 71.15,119.77
GND on BOTTOM (solid shape): 71.2,115.81 71.2,112.71 71.15,112.66 70.85,112.66 70.81,112.7 70.81,115.82 70.85,115.86 71.15,115.86
GND on BOTTOM (solid shape): 72.19,119.72 72.19,116.62 72.14,116.57 71.84,116.57 71.8,116.61 71.8,119.74 71.84,119.77 72.14,119.77
GND on BOTTOM (solid shape): 72.19,115.81 72.19,112.78 72.07,112.66 71.84,112.66 71.8,112.7 71.8,115.82 71.84,115.86 72.14,115.86
GND on BOTTOM (solid shape): 76.1,116.4 76.1,116.09 76,115.99 72.85,115.99 72.79,116.05 72.79,116.36 72.89,116.45 76.05,116.45
GND on BOTTOM (solid shape): 76.1,114.19 76.1,113.85 76.02,113.77 72.88,113.77 72.8,113.85 72.8,114.17 72.87,114.24 76.05,114.24
GND on BOTTOM (solid shape): 76.11,115.32 76.11,115 76.01,114.9 72.85,114.9 72.79,114.96 72.79,115.33 72.82,115.37 76.06,115.37
GND on BOTTOM (solid shape): 76.12,117.54 76.12,117.24 76,117.12 72.89,117.12 72.8,117.22 72.8,117.54 72.85,117.6 76.05,117.6
GND on BOTTOM (solid shape): 76.15,119.7 76.15,119.49 76.02,119.36 72.86,119.36 72.8,119.43 72.8,119.77 72.85,119.81 76.04,119.81
GND on BOTTOM (solid shape): 76.21,118.56 76.21,118.28 76.17,118.23 72.86,118.23 72.8,118.3 72.8,118.65 72.84,118.69 76.07,118.69
GND on BOTTOM (solid shape): 76.28,128.24 76.28,127.09 75.31,127.09 75.26,127.14 75.26,128.44 75.34,128.52 76,128.52
GND on BOTTOM (solid shape): 102.1,112.3 102.1,109.5 102,109.4 99.31,109.4 99.22,109.48 99.22,112.4 99.3,112.48 101.92,112.48
GND on BOTTOM (solid shape): 104.5,131.42 104.5,130.61 104.27,130.39 100.83,130.39 100.67,130.56 100.67,131.44 100.8,131.57 104.34,131.57
GND on BOTTOM (solid shape): 155.29,114.99 155.29,114.1 155.24,114.05 150.44,114.05 150.27,114.21 150.27,114.98 150.41,115.11 155.17,115.11
GND on BOTTOM (solid shape): 155.3,126.43 155.3,125.54 155.22,125.47 148.51,125.47 148.39,125.59 148.39,126.43 148.44,126.48 155.24,126.48
GND on BOTTOM (solid shape): 171.98,126.66 171.98,121.91 171.96,121.88 171.2,121.88 171.12,121.96 171.12,126.74 171.14,126.76 171.88,126.76
GND on BOTTOM (solid shape): 206.05,97.74 206.05,95.78 205.96,95.69 204.46,95.69 204.2,95.95 204.2,97.74 204.3,97.85 205.94,97.85
GND on BOTTOM (solid shape): 116.87,112.87 116.87,110.71 116.59,110.43 115.24,110.43 114.99,110.68 114.99,111.29 115.8,112.11 115.8,112.97 116.76,112.97
GND on BOTTOM (solid shape): 109.38,105.95 109.38,105.03 109.25,104.91 99.32,104.91 99.28,104.95 99.28,105.88 99.51,106.11 99.52,106.12 109.21,106.12
GND on BOTTOM (solid shape): 209.38,97.8 209.38,95.7 209.34,95.65 208.64,95.65 208.58,95.72 208.33,95.72 208.26,95.78 208.26,97.55 208.57,97.86 209.32,97.86
GND on BOTTOM (solid shape): 40.79,122.22 42.4,122.22 42.51,122.1 42.51,121.35 42.26,121.1 39.98,121.1 39.86,121.22 39.86,122.2 39.89,122.23 40.78,122.23
GND on BOTTOM (solid shape): 111.53,121.22 111.53,117.72 111.38,117.57 110.39,117.57 110.26,117.69 110.26,121.17 110.43,121.34 111.42,121.34
GND on BOTTOM (solid shape): 141.6,119.12 142.11,119.12 142.2,119.03 142.2,118.42 142.11,118.33 136.32,118.33 136.3,118.35 136.3,119.14 136.4,119.24 141.48,119.24
GND on BOTTOM (solid shape): 144.17,123.76 144.17,122.52 144.07,122.42 142.39,122.42 142.04,122.77 134.72,122.77 134.57,122.93 134.57,123.79 134.59,123.79 134.67,123.87 144.07,123.87
GND on BOTTOM (solid shape): 28.04,117.08 28.04,116.12 28.47,115.69 28.47,115.05 28.42,115 28.02,115 27.79,115.23 27.79,117.06 27.84,117.11 28.02,117.11
GND on BOTTOM (solid shape): 43.61,123.4 43.61,122.43 43.54,122.36 40.73,122.36 40.59,122.5 40.59,123.24 40.7,123.35 42.72,123.35 42.87,123.5 43.51,123.5
GND on BOTTOM (solid shape): 57.48,112.94 57.69,112.74 58.98,112.74 59.02,112.69 59.02,112.21 58.94,112.14 56.69,112.14 56.54,112.28 56.54,112.92 56.56,112.94 57.41,112.94
GND on BOTTOM (solid shape): 84.31,117.76 84.31,116.78 84.15,116.63 81.25,116.63 81.15,116.72 81.15,117.89 81.23,117.97 84.1,117.97
GND on BOTTOM (solid shape): 108.41,125.88 108.41,116 107.91,115.51 107.91,115.18 107.92,115.17 107.92,114.98 107.86,114.91 107.38,114.91 107.28,115.01 107.28,125.81 107.38,125.91 108.38,125.91
GND on BOTTOM (solid shape): 192.3,112.57 192.9,112.57 192.99,112.48 192.99,111.9 192.89,111.8 192.43,111.8 191.73,112.5 190.42,112.5 190.35,112.57 190.35,112.7 190.41,112.75 192.12,112.75
GND on BOTTOM (solid shape): 28.96,125.36 28.96,124.55 29.15,124.36 29.15,123.75 29.09,123.7 28.61,123.7 28.57,123.73 28.57,124.57 28.68,124.68 28.68,125.36 28.75,125.44 28.88,125.44
GND on BOTTOM (solid shape): 78.64,129.89 79.3,129.89 79.37,129.81 79.37,129.33 79.35,129.3 78.56,129.3 78.55,129.31 78.22,129.31 77.9,129.63 77.34,129.63 77.32,129.66 77.32,130.27 78.26,130.27
GND on BOTTOM (solid shape): 125.08,119.32 125.08,118.76 125.21,118.63 125.55,118.63 125.67,118.52 125.67,117.24 125.51,117.08 124.73,117.08 124.57,117.24 124.57,119.29 124.73,119.45 124.96,119.45
GND on BOTTOM (solid shape): 194.18,125.9 194.18,123.87 194.56,123.48 194.56,121.15 194.46,121.05 193.67,121.05 193.43,121.29 193.43,123.37 192.89,123.92 192.89,125.82 193.07,126 194.08,126
GND on BOTTOM (solid shape): 62.89,101.31 62.89,100.9 62.84,100.85 62.74,100.85 62.15,101.44 61.19,101.44 61.01,101.62 60.88,101.62 60.76,101.74 60.76,102.02 60.83,102.1 62.1,102.1
GND on BOTTOM (solid shape): 122.12,121.48 122.12,119.6 121.82,119.29 121.82,118.76 122.12,118.46 122.12,116.88 122.05,116.8 121.4,116.8 121.34,116.86 121.34,119.11 120.98,119.47 120.98,121.45 121.16,121.63 121.97,121.63
GND on BOTTOM (solid shape): 132.03,99.15 132.03,97.81 131.57,97.35 120.99,97.35 120.81,97.53 120.81,99.19 120.9,99.28 131.9,99.28
GND on BOTTOM (solid shape): 220.64,121.19 220.64,120.64 220.5,120.51 220.29,120.51 220.28,120.52 220.07,120.52 220.07,120.52 218.78,120.52 218.72,120.58 218.21,120.58 218.13,120.67 218.13,121.23 218.2,121.3 220.52,121.3
GND on BOTTOM (solid shape): 220.67,107.89 220.67,107.35 220.54,107.21 220.33,107.21 220.32,107.22 220.11,107.22 220.11,107.23 218.82,107.23 218.76,107.29 218.25,107.29 218.16,107.37 218.16,107.93 218.24,108.01 220.56,108.01
GND on BOTTOM (solid shape): 26.52,119.85 26.52,119.42 26.82,119.12 27.84,119.12 27.94,119.01 27.94,118.68 27.81,118.56 27.46,118.56 27.18,118.28 24.36,118.28 24.26,118.38 24.26,120.49 24.36,120.59 25.78,120.59
GND on BOTTOM (solid shape): 84.25,112.92 85.77,112.92 85.93,112.51 86.15,112.12 86.15,111.53 86.02,111.39 82.17,111.39 81.11,112.45 81.11,113.13 81.17,113.19 83.98,113.19
GND on BOTTOM (solid shape): 127.81,116.6 127.81,115.28 127.66,115.13 126.85,115.13 126.47,114.75 126.01,114.75 125.93,114.82 125.93,115.28 126.03,115.38 126.54,115.38 126.87,115.71 126.87,116.68 126.9,116.7 127.71,116.7
GND on BOTTOM (solid shape): 56.24,124.16 56.24,122.72 56.53,122.43 57,122.43 57.15,122.28 57.15,121.95 57.11,121.91 56.12,121.91 56.08,121.95 56.08,122.25 55.61,122.72 55.61,124.12 55.69,124.2 56.2,124.2
GND on BOTTOM (solid shape): 27.72,127.82 28.67,127.82 28.84,127.64 28.84,127.31 28.75,127.22 28.29,127.22 27.97,126.89 27.83,126.89 27.83,126.89 26.56,126.89 26.56,126.89 24.69,126.89 24.51,127.07 24.51,128.06 24.74,128.29 27.25,128.29
GND on BOTTOM (solid shape): 158.36,122.81 158.36,121.34 159.11,120.6 160.7,120.6 160.81,120.49 160.81,119.68 160.61,119.48 155.76,119.48 155.65,119.59 155.65,121.08 155.78,121.21 157.05,121.21 157.09,121.26 157.09,122.73 157.23,122.87 158.3,122.87
GND on BOTTOM (solid shape): 175.21,117.55 175.21,116.31 175.26,116.26 176.89,116.26 176.96,116.33 176.96,117.47 177.05,117.56 180.22,117.56 180.39,117.39 180.39,115.86 180.14,115.61 178.36,115.61 178.35,115.62 175.01,115.62 174.95,115.68 174.95,117.52 174.99,117.56 175.2,117.56
GND on BOTTOM (solid shape): 188.95,112.5 188.95,110.99 188.7,110.74 188.7,106.4 188.51,106.21 187.06,106.21 186.8,106.47 186.8,107.18 186.82,107.2 186.82,108.43 186.64,108.6 185.23,108.6 185.04,108.79 185.04,110.81 185.24,111.01 186.84,111.01 186.98,111.14 188.01,111.14 188.33,111.47 188.33,112.51 188.44,112.63 188.82,112.63
GND on BOTTOM (solid shape): 65.26,119.85 65.26,119.29 65.31,119.24 66.2,119.24 66.25,119.19 66.25,118.29 66.21,118.25 65.92,118.25 65.86,118.31 65.86,118.76 65.83,118.79 64.82,118.79 64.76,118.73 64.76,116.62 64.72,116.57 64.44,116.57 64.37,116.64 64.37,119.11 64.5,119.23 64.83,119.23 64.87,119.27 64.87,119.58 64.87,119.58 64.87,119.84 64.91,119.88 65.24,119.88
GND on BOTTOM (solid shape): 84.22,121.9 84.22,121.88 85.12,120.99 85.12,119.85 84.42,119.15 81.9,119.15 81.81,119.24 81.81,119.65 81.69,119.78 81.25,119.78 81.22,119.81 81.22,120.16 81.25,120.19 81.6,120.19 81.84,119.95 84.25,119.95 84.37,120.07 84.37,120.78 83.94,121.21 83.28,121.21 82.8,121.69 82.8,121.98 82.93,122.11 84.01,122.11
GND on BOTTOM (solid shape): 130.96,103.67 97.9,103.67 97.9,109.13 98.3,108.9 98.7,109.13 98.7,104.47 130.16,104.47 130.16,127.77 104.79,127.77 105.03,128.17 104.79,128.57 130.96,128.57
GND on BOTTOM (solid shape): 45.26,107.05 23.11,107.05 23.11,112.51 23.3,112.32 23.56,112.27 23.76,112.35 23.91,112.5 23.91,107.85 44.46,107.85 44.46,130.67 29.98,130.67 30.23,131.07 30.01,131.47 45.26,131.47
GND on BOTTOM (solid shape): 73.83,136.87 97.41,136.87 97.41,93.52 48.7,93.52 48.93,93.92 48.7,94.32 96.61,94.32 96.61,136.07 73.03,136.07 73.03,144.07 57.53,144.07 57.53,130.67 46.56,130.67 46.56,125.36 46.16,125.61 45.76,125.38 45.76,131.47 56.73,131.47 56.73,144.87 73.83,144.87
GND on BOTTOM (solid shape): 172.21,115.01 172.21,114.01 172.53,113.69 174.31,113.69 174.43,113.57 174.43,112.4 174.59,112.25 175.83,112.25 176.31,112.73 177.71,112.73 177.86,112.58 177.86,110.12 177.94,110.05 178.9,110.05 178.96,110 178.96,109.43 178.83,109.3 177.58,109.3 177.32,109.03 177.32,107.72 177.46,107.58 179.08,107.58 179.27,107.39 179.27,106 179.13,105.86 178.74,105.86 178.59,106.01 178.59,106.75 178.43,106.9 177.51,106.9 177.21,106.6 172.94,106.6 172.68,106.86 172.68,110.15 171.22,111.61 170.6,111.61 169.8,112.41 169.8,112.97 169.95,113.12 171.25,113.12 171.36,113.24 171.36,114.02 171.11,114.28 171.11,115.13 171.18,115.2 172.02,115.2
GND on BOTTOM (solid shape): 67.15,119.19 67.23,119.16 67.25,119.07 67.25,118.97 67.28,118.88 67.29,118.87 67.29,118.61 67.28,118.6 67.25,118.46 67.28,118.32 67.29,118.31 67.29,118.05 67.28,118.04 67.25,117.9 67.28,117.76 67.29,117.75 67.29,117.49 67.28,117.48 67.25,117.36 67.27,117.24 67.27,117.12 67.22,117.07 67.11,117.07 66.85,117 66.75,116.76 66.75,116.62 66.7,116.56 66.31,116.56 66.25,116.5 66.25,115.51 66.16,115.42 63.97,115.42 63.91,115.48 63.91,115.87 63.94,115.91 65.8,115.91 65.86,115.97 65.86,116.89 65.95,116.99 66.29,116.99 66.36,117.06 66.36,117.51 66.43,117.58 66.81,117.58 66.85,117.62 66.85,119.14 66.89,119.18 66.94,119.19
GND on BOTTOM (solid shape): 7.92,161.84 11.36,161.91 13.1,158.94 12.83,157.62 12.07,156.5 7.34,156.5 6.69,157.36 6.35,158.37 6.31,158.68 6.3,158.96 6.31,159.1 6.84,160.16 7.24,161.28 7.49,161.52 7.62,161.62 7.73,161.71
GND on BOTTOM (solid shape): 11.54,47.71 12.74,46.44 13.18,44.74 13.07,43.88 12.75,43.08 11.1,43.08 10.63,42.61 10.63,41.93 10.51,41.96 10.38,41.97 8.38,41.97 8.1,41.92 7.87,41.75 7.81,41.79 7.66,41.89 7.49,42.02 7.48,42.02 6.18,44.95 7.82,47.71
GND on BOTTOM (solid shape): 12.9,119.28 14.44,117.31 14.52,114.81 14.34,114.35 13.83,114.35 13.33,114.15 12.89,113.09 12.33,112.85 8.15,112.85 8.04,112.94 7.75,113.24 7.57,113.44 7.42,113.64 6.75,116.68 8.46,119.28
GND on BOTTOM (solid shape): 68.27,120.21 68.27,119.72 68.27,119.7 68.24,119.58 68.27,119.45 68.27,119.44 68.27,119.16 68.27,119.15 68.24,119.02 68.27,118.89 68.27,118.88 68.27,118.6 68.27,118.59 68.24,118.46 68.27,118.33 68.27,118.32 68.27,118.04 68.27,118.03 68.24,117.9 68.27,117.77 68.27,117.76 68.27,117.48 68.27,117.47 68.24,117.34 68.27,117.21 68.27,117.2 68.27,117.15 68.23,117.07 68.14,117.06 68.07,117.07 68,117.07 67.97,117.07 67.94,117.06 67.85,117.07 67.8,117.15 67.8,117.21 67.81,117.22 67.83,117.34 67.81,117.46 67.8,117.47 67.8,117.77 67.81,117.78 67.83,117.9 67.81,118.02 67.8,118.03 67.8,118.33 67.81,118.34 67.83,118.46 67.81,118.58 67.8,118.59 67.8,118.89 67.81,118.9 67.83,119.02 67.81,119.14 67.8,119.15 67.8,119.45 67.81,119.46 67.83,119.54 67.83,119.63 67.86,119.66 67.86,120.22 67.94,120.31 68.17,120.31
GND on BOTTOM (solid shape): outline of 1079 points within 0.2,0.2 87.78,91.92
GND on BOTTOM (solid shape): outline of 1117 points within 0.2,39.95 21.46,144.57
GND on BOTTOM (solid shape): outline of 2831 points within 4.79,90.05 222.87,166.7
GND on IN1 (solid shape): 38.19,83.92 38.19,77.85 38.08,77.74 36.51,77.74 33.72,80.54 33.72,84.04 33.95,84.26 37.85,84.26
GND on IN1 (solid shape): 165.15,110.16 165.15,108.25 164.89,107.99 159.43,107.99 158.96,108.46 158.96,110.46 158.14,111.29 150.77,111.29 150.64,111.41 150.64,111.86 151.03,112.25 158.42,112.25 159.03,112.87 159.03,114.55 159.19,114.71 160.61,114.71
GND on IN1 (solid shape): 27.81,109.81 27.81,102.25 31.06,99.01 31.06,98.71 28.56,96.21 28.4,96.21 28.17,96.4 27.88,96.34 25.3,98.92 25.3,100.63 23.86,102.07 23.86,108.87 25.06,110.06 27.56,110.06
GND on IN1 (solid shape): 184.9,100.25 184.9,99.36 184.86,99.32 183.91,99.32 183.62,99.04 182.77,99.04 182.62,98.88 182.19,98.88 182.15,98.92 182.15,98.99 182.24,98.99 182.49,99.24 182.57,99.24 182.88,99.56 182.88,99.86 182.67,100.07 182.52,100.07 182.36,100.23 181.83,100.23 181.66,100.07 181.61,100.07 181.4,99.86 181.4,99.56 181.73,99.23 181.73,99.21 181.88,99.05 181.88,98.92 181.85,98.88 181.51,98.88 181.26,99.14 181.26,99.86 181.79,100.39 182.28,100.39 182.28,100.4 184.75,100.4
GND on IN1 (solid shape): 33.81,39.74 34.42,39.74 34.48,39.72 34.52,39.65 34.54,39.58 34.59,39.52 34.61,39.51 34.61,39.4 34.6,39.39 32.75,39.39 32.12,38.76 32.12,37.27 32.48,36.91 32.48,34.9 28.66,31.09 25.18,31.09 24.47,31.8 24.46,31.85 24.51,31.88 24.58,31.88 25.26,31.2 28.56,31.2 29.02,31.66 32.27,34.91 32.27,36.58 31.8,37.05 31.8,38.78 32.79,39.76 33.79,39.76
GND on IN1 (solid shape): 33.81,39.74 34.42,39.74 34.48,39.72 34.52,39.65 34.54,39.58 34.59,39.52 34.6,39.52 34.61,39.49 34.61,39.4 34.6,39.39 32.75,39.39 32.12,38.76 32.12,37.27 32.48,36.91 32.48,34.9 28.66,31.09 25.18,31.09 24.47,31.8 24.46,31.85 24.51,31.88 24.58,31.88 25.26,31.2 28.56,31.2 29.02,31.66 32.27,34.91 32.27,36.58 31.81,37.04 31.81,38.78 32.79,39.76 33.79,39.76
GND on IN1 (solid shape): 187.16,121.11 204.24,121.11 204.48,120.88 204.48,116.45 203.77,115.74 199.15,115.74 199.07,115.78 199.06,115.87 198.76,116.27 198.47,115.87 198.46,115.78 198.38,115.74 197.93,115.74 197.66,116.01 197.66,116.04 197.04,116.66 196.71,116.66 196.71,116.34 196.77,116.28 196.78,116.22 196.74,116.19 196.25,116.19 196,115.94 195.99,115.94 195.21,115.16 193.89,115.16 192.48,116.57 190.65,116.57 190.45,116.37 189.74,116.37 189.54,116.57 189.54,117.47 189.41,117.6 189.22,117.6 189.08,117.47 189.08,116.38 188.88,116.18 184.57,116.18 183.99,116.75 182.39,116.75 180.64,118.51 180.36,118.51 179.18,119.69 176.95,119.69 176.25,118.99 174.78,118.99 174.66,119.11 174.27,119.11 174.27,119.11 174.14,119.14 174.02,119.11 174.01,119.11 173.76,119.11 173.39,118.74 172.65,118.74 172.39,119.01 172.39,121.24 174.42,123.27 185,123.27
GND on IN1 (solid shape): 30.58,48.87 30.69,48.89 30.75,48.8 30.75,48.11 30.83,47.89 31.04,47.76 31.08,47.75 31.08,43.73 30.69,43.34 30.46,43.56 30.46,43.66 30.53,43.73 30.55,43.73 30.7,44.12 30.31,43.97 30.31,43.95 30.15,43.79 29.91,44.04 29.9,44.05 29.83,44.14 29.71,44.19 29.68,44.2 29.67,44.24 29.67,44.73 29.7,44.8 29.76,44.84 29.9,44.88 30.01,44.98 30.09,45.03 30.18,44.98 30.62,44.89 30.67,45.33 30.65,45.41 30.69,45.48 30.65,45.86 30.31,45.67 30.31,45.65 30.21,45.54 29.93,45.82 29.86,45.82 29.79,45.86 29.71,45.89 29.68,45.9 29.67,45.94 29.67,47.96
GND on IN1 (solid shape): outline of 312 points within 30.68,43.21 33.83,49.65
GND on IN1 (solid shape): outline of 748 points within 96.69,90.05 222.87,152.9
GND on IN1 (solid shape): outline of 966 points within 23.82,115.37 46.04,147.84
GND on IN1 (solid shape): outline of 1318 points within 4.79,119.43 179.44,166.7
GND on IN1 (solid shape): outline of 1476 points within 18.95,42.02 42.63,79.19
GND on IN1 (solid shape): outline of 5442 points within 0.2,0.2 87.78,142.65
GND on IN2 (solid shape): 147.65,104.94 147.65,104.82 147.57,104.74 142.77,104.74 140.79,106.72 140.79,106.97 145.62,106.97
GND on IN2 (solid shape): 105.78,131 105.79,130.99 108.55,130.99 108.59,130.96 108.59,130.74 108.46,130.61 105.87,130.61 105.07,131.42 100.31,131.42 99.66,130.77 97.26,130.77 97.06,130.96 94.46,130.96 93.5,130 86.49,130 85.89,130.6 79.11,130.6 76.96,128.45 70.96,128.45 70.55,128.86 66.39,128.86 63.57,126.04 61.47,126.04 60.32,124.89 59.82,124.89 59.91,124.98 59.91,124.99 59.94,125.02 60.18,125.02 61.42,126.26 63.54,126.26 66.34,129.05 70.6,129.05 71.03,128.63 76.94,128.63 79.11,130.8 85.96,130.8 86.56,130.2 93.4,130.2 94,130.8 94.01,130.8 94.37,131.16 97.16,131.16 97.35,130.97 99.58,130.97 100.23,131.62 105.16,131.62
GND on IN2 (solid shape): 105.82,129.85 105.82,129.81 105.73,129.72 105.65,129.72 104.44,130.93 100.53,130.93 99.84,130.24 99.61,130.24 97.8,128.43 97.37,128.43 96.44,129.36 88.42,129.36 86.77,127.71 84.54,127.71 83.23,129.01 79.54,129.01 77.04,126.52 65.55,126.52 64.57,125.54 61.71,125.54 59.95,123.78 58.96,123.78 58.86,123.85 58.89,123.96 59.07,124.15 60.05,124.15 61.65,125.75 62.35,125.75 62.36,125.74 64.49,125.74 65.46,126.72 76.98,126.72 79.46,129.2 83.33,129.2 84.62,127.91 86.67,127.91 88.32,129.57 94.57,129.57 95.4,130.39 95.4,130.58 95.49,130.67 95.81,130.67 96,130.47 99.79,130.47 100.44,131.12 104.56,131.12
GND on IN2 (solid shape): 68.36,124.82 68.36,124.72 66.32,122.68 63.71,122.68 63.14,122.1 61.1,122.1 61.02,122.18 61.02,122.45 61.03,122.45 61.03,122.74 61.28,122.99 61.66,122.99 61.67,122.94 61.68,122.89 61.69,122.84 61.72,122.8 61.75,122.76 61.79,122.73 61.83,122.7 61.88,122.68 61.93,122.67 61.98,122.66 62.03,122.67 62.07,122.68 62.12,122.7 62.16,122.73 62.2,122.76 62.23,122.8 62.26,122.84 62.28,122.89 62.29,122.94 62.29,122.99 62.28,123.04 62.27,123.09 62.25,123.13 62.22,123.17 62.18,123.21 62.14,123.24 62.1,123.26 62.05,123.28 62,123.29 61.95,123.29 61.9,123.28 61.85,123.26 61.81,123.24 61.77,123.21 61.73,123.17 61.71,123.13 61.68,123.09 61.67,123.04 61.66,122.99 61.28,122.99 61.97,123.67 65.09,123.67 66.29,124.87 68.3,124.87
GND on IN2 (solid shape): 136.18,108.32 136.19,108.32 136.25,108.27 137.74,108.27 141.68,104.33 141.68,103.95 138.18,103.95 134.67,107.46 136.68,107.46 136.68,107.41 136.69,107.36 136.71,107.32 136.74,107.27 136.77,107.24 136.81,107.21 136.85,107.18 136.9,107.16 136.95,107.15 136.99,107.15 137.04,107.16 137.09,107.17 137.13,107.19 137.18,107.22 137.21,107.25 137.24,107.29 137.26,107.34 137.28,107.38 137.29,107.43 137.29,107.48 137.28,107.53 137.26,107.58 137.24,107.62 137.21,107.66 137.18,107.69 137.13,107.72 137.09,107.74 137.04,107.76 136.99,107.76 136.95,107.76 136.9,107.75 136.85,107.73 136.81,107.71 136.77,107.68 136.74,107.64 136.71,107.6 136.69,107.55 136.68,107.51 136.68,107.46 134.67,107.46 133.81,108.32 133.81,110.35 133.81,110.4 133.88,110.48 134.02,110.48
GND on IN2 (solid shape): outline of 86 points within 102.02,99.29 114.19,103.34
GND on IN2 (solid shape): 41.92,123.52 42.12,123.33 42.12,123.11 42.44,122.78 42.45,122.77 42.48,122.67 42.54,122.59 42.56,122.55 42.54,122.52 42.44,122.29 42.54,122.03 42.52,121.99 42.55,121.48 43.05,121.6 43.06,121.63 43.14,121.63 43.14,121.41 42.96,121.24 42.96,119.99 42.93,119.91 42.86,119.88 42.56,119.58 42.86,119.27 42.93,119.24 42.96,119.17 42.96,116.51 43.67,115.8 43.67,113.74 45.65,111.76 45.65,111.7 45.55,111.6 45.36,111.6 43.47,113.49 43.47,115.21 41.72,116.97 41.72,123.77 41.92,123.77
GND on IN2 (solid shape): outline of 126 points within 77.31,113.2 94.12,124.83
GND on IN2 (solid shape): 111.24,123.65 114.34,123.65 114.41,123.57 114.41,123.44 114.33,123.35 111.11,123.35 109.54,124.92 99.65,124.92 97.82,123.08 97.82,122.22 94.33,118.74 93.6,118.74 91.41,116.54 91.41,115.94 95.44,111.91 95.44,111.07 95.39,111.02 94.82,111.02 93.8,112.04 91.51,112.04 90.48,111.01 84.2,111.01 83.41,111.81 83.41,114.63 83.85,115.07 83.85,115 83.86,114.92 83.86,114.85 83.8,114.8 83.78,114.18 84.21,114.63 84.21,114.67 84.24,114.7 84.26,114.7 84.3,114.69 84.32,114.65 84.66,114.34 84.99,114.66 85.02,114.73 85.32,114.85 85.42,115.08 85.44,115.15 85.73,115.28 85.86,115.57 85.93,115.6 86.13,116.18 85.59,115.9 85.57,115.86 85.53,115.84 85.51,115.84 85.44,115.87 85.42,115.94 85.3,116.19 85.05,116.27 85.18,116.4 90.82,116.4 90.94,116.51 90.98,116.51 91.17,116.7 91.3,116.7 91.4,116.7 93.57,118.87 94.29,118.87 97.58,122.16 97.58,123.02 99.77,125.2 109.69,125.2
GND on IN2 (solid shape): outline of 323 points within 22.86,100.8 41.87,112.84
GND on IN2 (solid shape): outline of 142 points within 117.19,94.45 132.77,108.73
GND on IN2 (solid shape): outline of 627 points within 52.21,111.29 57.75,126.97
GND on IN2 (solid shape): outline of 705 points within 172.14,102.66 217.69,133.42
GND on IN2 (solid shape): outline of 1318 points within 4.83,128.06 172.43,166.7
GND on IN2 (solid shape): outline of 1825 points within 23.77,110.8 62.31,148.5
GND on IN3 (solid shape): 214.36,129.52 214.36,125.21 213.55,124.4 213.55,118.49 213.36,118.3 212.44,118.3 212.44,126.34 212.32,126.46 212.32,129.45 212.72,129.86 214.02,129.86
GND on IN3 (solid shape): 87.54,89.04 87.42,88.88 87.25,88.76 65.38,88.76 65.38,89.23 87.54,89.23
GND on IN3 (solid shape): 140.53,100.3 139.93,99.69 139.93,98.63 140.92,97.64 140.94,97.64 141.59,96.99 141.59,96.49 141.45,96.36 139.65,96.36 136.47,99.54 135.05,99.54 135.04,99.55 135.04,99.78 135.07,99.81 139.32,99.81 139.99,100.47 140.53,100.47
GND on IN3 (solid shape): 43.68,93.28 43.79,93.3 43.85,93.2 43.85,92.95 44.87,91.94 44.89,91.87 44.87,91.84 44.84,91.82 44.43,91.82 43.46,92.79 43.46,93.06
GND on IN3 (solid shape): 41.2,110.49 41.31,110.51 41.37,110.41 41.37,107.52 41.33,107.47 41.33,107.23 41.26,107.13 41.15,107.16 40.92,107.39 40.92,109.39 40.94,109.42 40.95,109.42 41.11,109.59 41.05,109.81 41.04,109.82 41.03,109.84 41.03,110.32
GND on IN3 (solid shape): 100.85,136.03 101.47,136.03 101.72,135.78 103.17,135.78 103.66,135.29 103.66,128.9 103.15,128.39 102.79,128.39 102.79,128.5 103.14,128.86 103.14,134.27 101.92,135.49 100.94,135.49 100.73,135.29 100.73,135 100.76,134.98 100.76,134.69 100.76,134.69 100.76,134.57 100.92,134.4 100.92,134.37 100.74,134.19 100.74,133.41 100.97,133.17 101.5,132.65 101.5,131.01 101.12,130.63 101.12,128.65 101.12,128.23 101.8,127.55 101.8,127.26 101.75,127.22 101.33,127.22 101.08,127.47 101.08,127.68 100.87,127.89 98.92,127.89 98.7,128.11 98.7,131.67 99.53,132.5 99.53,132.93 99.17,133.29 98.46,133.29 98.3,133.45 98.3,136.25 98.47,136.42 100.47,136.42
