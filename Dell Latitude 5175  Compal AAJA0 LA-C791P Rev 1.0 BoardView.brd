# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.0V_PRIM on BOTTOM (solid shape): 74.4,99.38 74.4,97.25 73.86,96.71 73.86,96.1 73.74,95.98 73.15,95.98 73.05,96.08 73.05,96.92 72.87,97.09 72.87,97.63 72.75,97.75 71.72,97.75 71.59,97.88 71.59,99.43 71.67,99.51 74.27,99.51
+1.0V_PRIM on BOTTOM (solid shape): 177.76,127.04 177.76,125.45 177.6,125.29 176.5,125.29 176.5,125.82 175.95,125.82 175.95,125.29 175.7,125.29 175.7,125.82 175.15,125.82 175.15,125.29 174.47,125.29 174.27,125.49 174.27,126.99 174.47,127.19 177.61,127.19
+1.0V_PRIM on BOTTOM (solid shape): 64.11,97.7 64.11,97.07 64.16,97.02 64.26,97.02 64.29,97.04 64.29,97.73 64.31,97.75 64.49,97.75 64.52,97.73 64.52,95.93 64.46,95.87 63.86,95.87 63.62,96.11 63.62,96.78 63.88,97.04 63.88,97.7 63.93,97.75 64.06,97.75
+1.0V_PRIM on BOTTOM (solid shape): 66.12,97.7 66.12,97.02 66.14,96.99 66.27,96.99 66.29,97.02 66.29,97.73 66.32,97.75 66.45,97.75 66.52,97.68 66.52,97.02 66.9,96.64 66.9,95.9 66.85,95.85 66.22,95.85 66.17,95.9 66.17,96.46 65.89,96.74 65.89,97.7 65.94,97.75 66.07,97.75
+1.0V_PRIM on BOTTOM (solid shape): 68.3,104.08 68.3,103.29 68.2,103.19 67.88,103.19 67.8,103.11 67.8,102.32 67.51,102.02 64.34,102.02 64.24,102.12 64.24,102.45 64.13,102.56 63.58,102.56 63.5,102.63 63.5,103.36 63.59,103.45 64.59,103.45 64.62,103.42 64.62,103.03 64.84,102.81 65.55,102.81 65.77,102.81 66.18,103.22 67.08,103.22 67.26,103.39 67.26,104.1 67.29,104.13 68.25,104.13
+1.0V_PRIM on VCC (solid shape): outline of 192 points within 54.24,119.75 59.5,122.22
+1.0V_PRIM on GND1 (solid shape): 177.06,125.85 177.06,125.08 176.88,124.89 174.05,124.89 173.78,125.16 173.78,125.85 174.04,126.1 176.81,126.1
+1.0V_PRIM on GND1 (solid shape): 76.73,96.94 76.73,96.56 76.66,96.48 72.52,96.48 72.42,96.59 72.42,96.92 72.49,96.99 76.12,96.99 76.2,97.07 76.61,97.07
+1.0V_PRIM on IN1 (solid shape): 177.03,125.83 177.03,125.1 176.81,124.88 174.12,124.88 173.76,125.24 173.76,125.63 174.13,125.99 176.87,125.99
+1.0V_PRIM on IN1 (solid shape): 76.71,96.97 76.71,96.54 76.66,96.48 72.49,96.48 72.44,96.54 72.44,96.97 72.54,97.07 76.61,97.07
+1.0V_PRIM on IN1 (solid shape): 55.55,108.33 55.55,107.62 55.76,107.42 55.76,106.34 56.25,105.84 56.25,105.59 56.22,105.56 55.68,105.56 54.97,106.27 54.97,106.94 54.73,107.18 54.7,107.27 54.77,107.34 54.91,107.47 54.93,107.66 55.03,108.01 54.76,108.24 54.66,108.35 54.66,108.59 54.76,108.69 55.19,108.69
+1.0V_PRIM on IN2 (solid shape): 75.92,97.5 75.92,96.56 75.84,96.48 72.78,96.48 72.65,96.61 72.65,97.02 73.43,97.79 75.63,97.79
+1.0V_PRIM on IN3 (solid shape): 177.53,126.22 177.53,125.29 177.15,124.91 174.54,124.91 174.22,125.23 174.22,126.25 174.37,126.41 177.34,126.41
+1.0V_PRIM on IN3 (solid shape): 76.38,96.81 76.38,96.43 76.09,96.15 73.21,96.15 73.15,96.2 72.76,96.2 72.47,96.49 72.47,96.54 72.46,96.6 72.46,96.88 72.52,96.94 76.25,96.94
+1.0V_PRIM on GND3 (solid shape): 76.38,96.81 76.38,96.51 76.2,96.34 74.66,96.34 74.51,96.48 74.13,96.48 73.76,96.11 73.24,96.11 73.15,96.2 72.76,96.2 72.47,96.49 72.47,96.54 72.46,96.59 72.46,96.9 72.54,96.98 76.21,96.98
+1.0V_PRIM on IN4 (solid shape): outline of 701 points within 63.18,95.87 75.01,104.11
+1.0V_PRIM on VCC: 164.29,123.36 163.42,124.22 163.42,126.3 163.73,126.61 170.41,126.61 171.2,127.34 171.2,128.13 171.43,128.36 176.45,128.36 176.74,128.35 177.01,128.08 177.01,125.32 175.05,123.36
+1.0V_PRIMP on BOTTOM (solid shape): 174.07,126.94 174.07,125.47 174.38,125.15 175.28,125.15 175.28,125.69 175.57,125.69 175.57,125.15 176.08,125.15 176.08,125.69 176.37,125.69 176.37,125.15 177.42,125.15 177.76,124.82 177.76,122.09 177.55,121.88 172.36,121.88 172.21,122.04 172.21,126.89 172.39,127.07 173.94,127.07
+1.0V_VCCST on TOP (solid shape): 66.44,110.25 66.44,105.88 66.5,105.83 66.5,103.62 66.01,103.62 65.84,103.8 65.84,110 66.14,110.3 66.4,110.3
+1.0V_VCCST on TOP (solid shape): 189.91,137.33 189.91,136.29 189.66,136.04 188.1,136.04 187.54,135.48 187.54,131.31 187.46,131.23 187.14,131.23 187.01,131.36 187.01,135.74 187.75,136.48 189.1,136.48 189.38,136.76 189.38,137.3 189.48,137.4 189.84,137.4
+1.0V_VCCST on BOTTOM (solid shape): 67.51,101.77 67.51,99.71 67.46,99.66 66.83,99.66 66.73,99.76 66.73,100.28 66.88,100.43 66.88,101.82 66.93,101.87 67.41,101.87
+1.0V_VCCST on BOTTOM (solid shape): 68.78,106.54 68.78,106.01 68.72,105.95 66.95,105.95 66.89,106.02 66.89,106.43 66.95,106.49 67.36,106.49 67.36,106.5 67.41,106.5 67.51,106.6 68.73,106.6
+1.0V_VCCST on BOTTOM (solid shape): 80.38,104.6 80.38,103.87 80.35,103.84 79.96,103.84 79.96,104.06 79.62,104.4 78.67,104.4 78.61,104.34 78.55,104.34 78.52,104.31 78.47,104.31 78.36,104.2 77.99,104.2 77.94,104.25 77.94,104.58 78.01,104.65 78.01,104.76 78.09,104.85 80.14,104.85
+1.0V_VCCST on IN1 (solid shape): 66.65,111.83 66.65,109.84 66.52,109.7 66.1,109.7 65.89,109.91 65.89,111.8 65.99,111.9 66.57,111.9
+1.0V_VCCST on IN1 (solid shape): 187.51,131.74 187.51,131.07 186.88,130.44 186.72,130.44 186.57,130.59 186.57,130.91 186.85,131.18 186.85,131.51 187.16,131.82 187.43,131.82
+1.0V_VCCST on IN2 (solid shape): outline of 209 points within 65.43,111.42 68.05,115.05
+1.0V_VCCST on IN3 (solid shape): 86.31,106.23 86.31,105.96 86.24,105.89 84.95,105.89 84.66,106.17 84.66,106.35 84.81,106.5 86.04,106.5
+1.0V_VCCST on IN3 (solid shape): 67.19,100.03 68.7,100.03 69.03,99.71 69.03,99.53 68.78,99.28 67.08,99.28 66.37,99.99 66.37,100.24 66.45,100.32 66.9,100.32
+1.0V_VCCST on IN4 (solid shape): 80.69,104.34 80.69,103.37 80.57,103.24 80.21,103.24 80.18,103.28 80.18,103.3 80.15,103.33 80.15,103.69 79.97,103.87 79.97,104.65 80.01,104.69 80.34,104.69
+1.0V_XDP on BOTTOM (solid shape): 89.65,104.63 89.65,104.19 89.74,104.1 89.74,101.11 88.59,99.96 88.59,98.47 88.9,98.16 88.9,95.49 88.83,95.42 88.67,95.42 88.57,95.52 88.57,96.43 88.39,96.61 88.39,96.99 88.26,97.12 88.26,101.13 89.2,102.07 89.2,103.22 89.03,103.39 89.03,103.8 88.52,104.31 88.52,105.04 88.62,105.15 89.13,105.15
+1.0VA_GATE on TOP (solid shape): 57.68,102.45 57.68,100.74 57.52,100.57 56.49,100.57 56.4,100.66 56.4,102.42 56.54,102.56 57.58,102.56
+1.0VA_GATE on TOP (solid shape): 55.51,115.85 55.51,114.84 55.4,114.72 54.41,114.72 54.05,115.08 54.05,115.71 54.25,115.92 55.45,115.92
+1.0VA_GATE on IN1 (solid shape): outline of 768 points within 49.14,100.78 57.23,116.88
+1.0VA_GATE on IN3 (solid shape): 57.02,101.89 57.02,100.9 57.12,100.8 57.68,100.8 57.84,100.95 58.19,100.95 58.32,100.83 58.32,99.43 58.17,99.28 55.65,99.28 55.42,99.51 55.42,101.84 55.57,102 56.92,102
+1.0VA_GATE on IN4 (solid shape): 60.1,103.11 60.1,101.56 60.04,101.49 60.02,101.4 60.02,101.39 59.89,101.26 59.1,101.26 58.84,100.99 58.84,100.38 58.52,100.07 58.31,100.07 58.27,100.07 57.66,100.07 57.4,100.32 57.4,100.57 57.73,100.9 57.73,101.69 57.86,101.82 58.39,101.82 58.52,101.95 58.52,103.16 58.61,103.25 59.15,103.25 59.16,103.25 59.34,103.32 59.41,103.49 59.44,103.57 59.51,103.6 59.61,103.6
+1.0VA_GATE on BOTTOM: 62.62,101.73 62.15,102.2 59.72,102.2 59.54,102.38 59.54,103.4 59.66,103.53 61.05,103.53 61.33,103.25 62.29,103.25 62.42,103.38 63.27,103.38 63.3,103.35 63.3,102.68 63.55,102.43 63.91,102.43 63.98,102.35 63.98,101.79 63.93,101.73
+1.0VS_VCCSTG on BOTTOM (solid shape): 67.51,108.88 67.51,108.78 67.34,108.6 66.47,108.6 65.97,108.09 65.97,107.65 66.07,107.55 66.61,107.55 66.67,107.49 66.67,106.97 66.62,106.92 66.04,106.92 65.94,107.02 65.44,107.02 65.38,107.08 65.38,108.93 65.61,109.16 67.23,109.16
+1.2V_DDR on TOP (solid shape): 89.05,121.45 89.05,121.07 87.27,121.07 87.15,121.2 87.15,121.45 87.31,121.62 88.89,121.62
+1.2V_DDR on TOP (solid shape): 71.68,122.49 71.68,122.14 71.63,122.09 68.4,122.09 68.38,122.11 68.38,122.47 68.45,122.54 71.63,122.54
+1.2V_DDR on TOP (solid shape): 83.27,124.63 83.27,124.31 81.69,122.72 80.67,122.72 80.34,122.39 79.03,122.39 78.93,122.49 78.93,123.74 79.37,124.18 82.36,124.18 82.96,124.78 83.12,124.78
+1.2V_DDR on TOP (solid shape): 120.07,125.52 120.07,125.24 120.04,125.21 119.48,125.21 119.48,124.65 120.04,124.65 120.04,124.4 119.48,124.4 119.48,123.87 120.04,123.87 120.04,122.95 119.99,122.9 118.36,122.9 118.17,123.1 118.17,125.35 118.26,125.44 119.22,125.44 119.32,125.54 120.04,125.54
+1.2V_DDR on BOTTOM (solid shape): 80.62,93.31 80.62,92.89 80.58,92.85 78.69,92.85 78.49,93.05 78.49,93.3 78.54,93.36 80.57,93.36
+1.2V_DDR on BOTTOM (solid shape): 70.66,99.41 70.66,97.14 70.41,96.89 70.41,95.45 70.33,95.37 69.68,95.37 69.6,95.46 69.6,96.94 69.42,97.12 69.42,97.7 69.32,97.81 68.05,97.81 67.97,97.88 67.97,99.41 68.07,99.51 70.56,99.51
+1.2V_DDR on BOTTOM (solid shape): outline of 13677 points within 57.73,116.83 96.32,143.75
+1.2V_DDR on GND1 (solid shape): 65.28,141.7 65.28,141.24 64.49,140.45 64.03,140.45 63.93,140.55 63.93,141.14 64.67,141.87 65.1,141.87
+1.2V_DDR on GND1 (solid shape): 68.1,136.95 68.1,136.82 67.64,136.36 66.09,136.36 65.81,136.64 65.81,136.97 65.89,137.05 68,137.05
+1.2V_DDR on GND1 (solid shape): 101.61,126.26 101.61,125.79 101.17,125.35 100.04,125.35 99.27,126.12 99.27,126.24 99.37,126.34 101.53,126.34
+1.2V_DDR on GND1 (solid shape): 119.79,124.83 119.79,122.85 119.74,122.8 118.52,122.8 118.44,122.88 118.44,124.88 118.59,125.03 119.58,125.03
+1.2V_DDR on GND1 (solid shape): 74.02,132.42 74.02,131.53 73.85,131.36 73.18,131.36 72.52,132.02 72.52,132.32 72.69,132.5 73.94,132.5
+1.2V_DDR on GND1 (solid shape): 90.73,128.59 90.73,128.49 90.45,128.21 90.32,128.21 90.14,128.03 90.14,128.01 90.04,127.9 89.38,127.9 89.33,127.96 89.33,128.44 89.48,128.59 90.17,128.59 90.27,128.69 90.63,128.69
+1.2V_DDR on IN1 (solid shape): 68.09,137.04 68.09,136.49 67.97,136.36 65.97,136.36 65.85,136.48 65.85,137.05 65.9,137.1 68.03,137.1
+1.2V_DDR on IN1 (solid shape): 72.89,137.66 72.89,137.2 72.81,137.13 71.75,137.13 71.58,137.3 71.58,137.72 71.8,137.94 72.6,137.94
+1.2V_DDR on IN1 (solid shape): 65.35,141.78 65.35,141.29 64.51,140.46 64.04,140.46 63.93,140.57 63.93,141.25 64.61,141.93 65.2,141.93
+1.2V_DDR on IN1 (solid shape): 70.38,139.51 70.38,139.21 70.02,138.85 69.25,138.85 68.91,139.18 68.91,139.45 69.04,139.58 70.3,139.58
+1.2V_DDR on IN1 (solid shape): 67.95,137.95 67.95,137.49 67.88,137.42 66.17,137.42 66.04,137.55 66.04,137.95 66.09,138 67.91,138
+1.2V_DDR on IN1 (solid shape): 74.32,132.45 74.32,131.69 74,131.36 73.18,131.36 72.51,132.04 72.51,132.45 72.57,132.5 74.26,132.5
+1.2V_DDR on IN1 (solid shape): 90.77,128.91 90.77,128.58 90.7,128.52 90.64,128.52 90.23,128.1 90.19,128.1 90,127.91 89.4,127.91 89.34,127.96 89.34,128.55 89.35,128.55 89.35,129.13 89.47,129.25 90.43,129.25
+1.2V_DDR on IN1 (solid shape): 75.68,122.63 75.7,122.63 75.92,122.42 75.92,122.39 75.92,121.76 75.92,121.76 75.92,121.25 75.76,121.09 75.69,121.09 75.67,121.09 75.55,121.09 75.54,121.09 75.4,121.1 75.33,121.09 75.06,121.09 75.04,121.09 74.97,121.09 74.94,121.09 74.53,121.09 74.52,121.09 74.37,121.09 74.36,121.09 74.18,121.09 74.11,121.1 74.04,121.09 73.77,121.09 73.75,121.09 73.68,121.09 73.65,121.09 73.38,121.09 73.02,121.45 73.02,122.29 72.77,122.54 71.78,122.54 71.65,122.42 71.65,121.48 71.25,121.07 71.07,121.07 70.89,121.25 70.55,121.25 70.37,121.33 70.2,121.25 69.25,121.25 69.21,121.26 69.18,121.25 68.78,121.25 68.7,121.17 67.74,121.17 67.66,121.08 67.57,121.08 67.45,121.2 67.45,122.25 67.95,122.75 75.56,122.75
+1.2V_DDR on IN2 (solid shape): 75.27,122.43 75.27,121.16 75.19,121.08 74.23,121.08 74.22,121.08 74.11,121.1 74,121.08 73.99,121.08 72.93,121.08 72.92,121.08 72.81,121.1 72.7,121.08 72.7,121.08 72.56,121.08 72.48,121.12 72.46,121.21 72.17,121.59 71.87,121.21 71.85,121.12 71.77,121.08 71.65,121.08 71.64,121.08 71.53,121.1 71.42,121.08 71.42,121.08 70.36,121.08 70.35,121.08 70.24,121.1 70.13,121.08 70.13,121.08 69.07,121.08 69.06,121.08 68.96,121.1 68.85,121.08 68.84,121.08 67.55,121.08 67.45,121.18 67.45,122.45 67.57,122.57 75.13,122.57
+1.2V_DDR on IN3 (solid shape): 119.81,124.99 119.81,122.01 119.8,121.99 119.29,121.99 119.25,122.03 119.25,122.64 118.96,122.94 118.96,125.03 119.13,125.2 119.61,125.2
+1.2V_DDR on GND3 (solid shape): 65.27,141.86 65.27,141.39 64.29,140.41 63.97,140.41 63.77,140.61 63.77,141.36 64.58,142.17 64.97,142.17
+1.2V_DDR on GND3 (solid shape): 73.69,132.61 73.69,131.61 73.4,131.33 73.18,131.33 72.77,131.74 72.77,132.33 73.15,132.7 73.59,132.7
+1.2V_DDR on GND3 (solid shape): 89.55,129.35 89.55,129.27 89.99,128.83 89.99,128.83 90.12,128.83 90.18,128.77 90.2,128.72 90.2,128.5 90.22,128.47 90.22,128.28 89.89,127.94 89.64,127.94 89.13,128.45 89.13,128.57 89.27,128.71 89.27,129.3 89.26,129.31 89.26,129.35 89.34,129.42 89.47,129.42
+1.2V_DDR on GND3 (solid shape): 67.45,137.88 67.45,137.58 67.36,137.49 67.32,137.49 67.28,137.49 67.25,137.49 66.94,137.49 66.91,137.46 66.91,137.1 66.95,137.06 67.23,137.06 67.58,136.72 67.6,136.67 67.64,136.62 67.64,136.48 67.44,136.28 66.98,136.28 66.79,136.09 66.16,136.09 65.95,136.3 65.24,136.3 65.18,136.36 65.18,136.74 65.25,136.81 65.73,136.81 65.97,137.06 66.56,137.06 66.61,137.11 66.61,137.89 66.68,137.96 67.37,137.96
+1.2V_DDR on IN4 (solid shape): outline of 453 points within 89.22,128.56 92.03,132.04
+1.2V_DDR on TOP: 42.13,72.14 42.49,71.77 42.99,71.77 43.14,71.62 43.14,70.92 42.95,70.73 41,70.73 40.75,70.97 40.75,72.02 40.87,72.14
+1.2V_DDR on GND2: 76.99,116.68 76.81,116.86 76.81,120.14 75.87,121.07 66.3,121.07 65.38,121.99 65.38,122.88 61.45,126.81 61.19,126.81 60.38,127.63 60.38,129.25 59.66,129.97 59.66,134.38 60.3,135.01 60.3,135.8 62.61,138.11 62.61,139.66 65.05,142.1 71.4,142.1 77.39,136.11 89.35,136.11 91.36,134.1 91.36,133.46 92.66,132.17 93.72,132.17 99.31,126.58 117.95,126.58 119.96,124.57 119.96,117.32 119.33,116.68
+1.2V_DDRP on TOP (solid shape): 122.71,128.87 122.71,123.45 122.7,123.44 122.7,122.96 122.5,122.76 121.26,122.76 120.81,123.2 120.63,123.2 120.24,123.59 120.24,124.02 120.22,124.04 119.76,124.04 119.76,124.17 119.79,124.2 120.19,124.2 120.27,124.27 120.27,124.83 120.24,124.86 119.76,124.86 119.71,124.91 119.71,125.01 119.74,125.03 120.19,125.03 120.22,125.06 120.22,125.57 120.07,125.72 119.52,125.72 119.42,125.82 119.42,126.44 119.51,126.53 119.87,126.53 120.2,126.86 120.2,128.38 120.7,128.88 120.7,128.95 120.87,129.11 122.47,129.11
+1.2V_DDRP on BOTTOM (solid shape): 122.48,126.46 122.48,123.43 122.02,122.98 119.58,122.98 119.32,123.24 119.32,126.62 119.46,126.76 122.17,126.76
+1.2V_DDRP on BOTTOM (solid shape): 124.34,119.45 124.34,119.29 124.28,119.23 123.33,119.23 122.89,118.79 122.19,118.79 122.08,118.9 122.08,119.2 122.17,119.29 122.88,119.29 123.09,119.5 124.29,119.5
+1.2V_DDRP on IN4 (solid shape): 122.94,119.5 122.94,118.94 122.73,118.73 122.4,118.73 121.69,119.45 121.69,120.06 122.38,120.06
+1.2V_DDRP on IN4 (solid shape): 122.6,126.16 122.6,122.7 122.54,122.64 121.34,122.64 121.21,122.78 121.22,122.79 121.22,124.06 120.17,125.11 119.41,125.11 119.37,125.15 119.37,126.49 119.54,126.66 122.1,126.66
+1.2V_UF_DVDD on TOP (solid shape): 126.05,124.87 126.05,123.88 125.76,123.59 124.94,123.59 124.76,123.76 124.76,124.86 124.92,125.01 125.91,125.01
+1.2V_UF_DVDD on IN3 (solid shape): 115.96,131.23 115.96,130.82 115.89,130.75 115.86,130.75 115.83,130.72 115.44,130.72 115.36,130.81 115.36,130.96 115.05,131.27 114.88,131.27 114.82,131.32 114.82,131.72 114.86,131.77 115.43,131.77
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 69.47,102.28 69.47,100.85 69.37,100.75 68.94,100.75 68.88,100.8 68.88,101.21 68.78,101.31 68.25,101.31 68.2,101.36 68.2,102.02 68.25,102.07 68.71,102.07 68.96,102.33 69.42,102.33
+1.2V_VCCPLL_OC on IN1 (solid shape): outline of 248 points within 64.85,111.22 68.22,116.98
+1.2V_VCCPLL_OC on IN3 (solid shape): 68.73,101.89 68.73,101.34 68.63,101.23 65.07,101.23 64.87,101.44 64.87,101.92 65.07,102.12 68.5,102.12
+1.2VS on TOP (solid shape): 27.56,78.98 27.56,78.73 27.48,78.65 27.38,78.65 26.82,78.09 26.82,77.26 26.72,77.16 26.14,77.16 25.96,77.33 25.96,78.3 26.47,78.81 26.47,79.01 26.57,79.11 27.43,79.11
+1.2VS on TOP (solid shape): 29.51,78.93 29.51,78.48 29.62,78.37 29.62,78.17 29.61,78.17 29.61,77.21 29.55,77.15 29.45,77.15 29.39,77.21 29.39,78.1 29.32,78.17 29.06,78.17 28.93,78.3 28.93,78.92 28.98,78.97 29.48,78.97
+1.2VS on IN1 (solid shape): 26.71,70.81 30.1,70.81 30.71,71.41 31.52,71.41 31.57,71.36 31.57,70.7 31.11,70.25 26.16,70.25 25.6,70.81 25.6,70.81 25.49,70.92 25.49,71.35 25.57,71.42 26.09,71.42
+1.2VS on IN3 (solid shape): 30.81,71.49 31.79,71.49 31.9,71.38 31.9,70.4 31.76,70.26 30.72,70.26 30.64,70.34 30.64,71.39 30.75,71.49 30.8,71.49
+1.2VS on IN4 (solid shape): 31.89,78.59 31.89,70.64 31.55,70.3 30.89,70.3 30.54,70.64 30.54,71 30.56,71.01 30.56,76.87 29.93,77.49 26.74,77.49 26.54,77.7 26.54,79.52 26.75,79.72 30.76,79.72
+1.2VS on TOP: 30.05,71.44 30.48,71.44 30.6,71.56 31.32,71.56 31.65,71.24 34.06,71.24 34.45,71.63 34.45,72.27 35.74,73.55 37.85,73.55 37.99,73.41 37.99,72.61 37.72,72.34 37.02,72.34 36.25,71.57 36.25,70.6 36.41,70.44 36.41,69.99 36.04,69.62 32.28,69.62 31.8,70.1 31.8,70.63 31.7,70.73 29.34,70.73 29.21,70.86 29.21,71.19 29.35,71.33 29.93,71.33
+1.8V_IO_OUT on TOP (solid shape): 127.43,128.69 127.63,128.69 128.02,128.31 128.22,128.31 128.3,128.23 128.3,128.11 128.24,128.06 127.81,128.06 127.58,128.29 124.74,128.29 124.69,128.34 124.69,128.74 124.76,128.82 127.3,128.82
+1.8V_MEM on TOP (solid shape): 86.87,124.79 86.87,123.99 86.51,123.63 85.91,123.63 85.8,123.74 85.8,124.25 86.43,124.88 86.78,124.88
+1.8V_MEM on TOP (solid shape): 93.79,124.95 93.79,124.72 92.78,123.71 91.94,123.71 91.84,123.81 91.84,124.46 91.68,124.62 91.48,124.62 91.23,124.86 91.23,125.11 91.3,125.17 93.57,125.17
+1.8V_MEM on TOP (solid shape): 104.68,127.25 104.68,126.36 104.37,126.05 104.37,125.35 104.2,125.19 103.17,125.19 103.12,125.24 103.12,126.69 103.76,127.32 104.61,127.32
+1.8V_MEM on TOP (solid shape): 94.87,130.52 94.87,129.45 94.79,129.38 92.38,129.38 92.07,129.68 92.07,129.91 92.18,130.01 94.28,130.01 94.36,130.09 94.36,130.55 94.46,130.65 94.74,130.65
+1.8V_PCH_GPP on BOTTOM (solid shape): 61.05,118.96 61.05,118.83 60.97,118.76 60.81,118.76 60.74,118.83 60.16,118.83 60.15,118.83 59.08,118.83 58.84,119.07 57.68,119.07 57.58,118.96 57.58,118.76 57.51,118.68 56.95,118.68 56.77,118.86 56.77,119.73 56.87,119.83 60.18,119.83
+1.8V_PCH_GPP on GND1 (solid shape): 63.53,116.35 63.88,116.35 63.98,116.25 63.98,116.02 63.88,115.92 62.2,115.92 62.07,116.05 62.07,116.18 63.15,116.18 63.15,116.14 63.16,116.11 63.18,116.07 63.21,116.04 63.24,116.02 63.28,116 63.31,115.99 63.35,115.99 63.39,116 63.43,116.02 63.46,116.04 63.49,116.07 63.51,116.11 63.52,116.14 63.52,116.18 63.52,116.22 63.51,116.26 63.49,116.29 63.46,116.32 63.43,116.35 63.39,116.36 63.35,116.37 63.31,116.37 63.28,116.36 63.24,116.35 63.21,116.32 63.18,116.29 63.16,116.26 63.15,116.22 63.15,116.18 62.07,116.18 62.07,116.57 62.15,116.65 63.22,116.65
+1.8V_PRIM on TOP (solid shape): 62.69,138.85 62.69,137.2 61.82,136.34 61.39,136.34 61.29,136.44 61.29,138.34 61.9,138.95 62.59,138.95
+1.8V_PRIM on TOP (solid shape): 107.87,133.89 107.87,132.48 107.49,132.1 103.83,132.1 103.78,132.15 103.78,133.82 103.87,133.91 107.85,133.91
+1.8V_PRIM on TOP (solid shape): 107.29,130.16 107.29,128.67 107.16,128.54 106.35,128.54 106.27,128.62 106.27,129.53 106.4,129.66 106.81,129.66 106.86,129.71 106.86,130.16 106.91,130.22 107.24,130.22
+1.8V_PRIM on TOP (solid shape): 109.12,130.09 109.12,129.78 109.19,129.71 109.55,129.71 109.7,129.56 109.7,128.84 109.45,128.59 108.69,128.59 108.61,128.67 108.61,130.09 108.69,130.16 109.04,130.16
+1.8V_PRIM on TOP (solid shape): 38.96,104.36 38.96,103.46 37.64,102.15 36.4,102.15 36.19,102.35 36.19,103.34 36.25,103.39 36.98,103.39 37.06,103.47 37.06,103.83 37.16,103.93 38,103.93 38.34,104.26 38.34,104.36 38.35,104.4 38.39,104.41 38.91,104.41
+1.8V_PRIM on TOP (solid shape): 44.5,121.55 44.69,121.55 44.8,121.43 44.8,118.92 45.02,118.7 45.02,117.1 45.68,116.45 45.68,111.19 45.42,110.94 45.42,110.54 44.27,109.39 43.81,109.39 43.76,109.44 43.76,110.56 44.31,110.56 44.31,111.07 43.76,111.07 43.76,111.36 44.31,111.36 44.31,111.87 43.76,111.87 43.76,112.74 43.77,112.74 43.77,115.43 42.56,116.63 42.56,120.99 43.13,121.55 44.5,121.55
+1.8V_PRIM on BOTTOM (solid shape): 56.18,119.7 56.18,118.1 56.13,118.05 54.81,118.05 54.79,118.02 54.79,117.95 53.54,116.7 53.11,116.7 52.91,116.91 52.91,117.24 53.9,118.23 53.9,118.35 54.13,118.58 55.3,118.58 55.4,118.68 55.4,119.73 55.45,119.78 56.11,119.78
+1.8V_PRIM on GND1 (solid shape): 108.05,132.83 108.05,132.58 107.72,132.25 106.37,132.25 105.97,132.65 105.97,132.98 106.1,133.11 107.77,133.11
+1.8V_PRIM on GND1 (solid shape): 109.14,130.06 109.14,129.76 109.27,129.63 109.6,129.63 109.73,129.5 109.73,129.12 109.65,129.05 108.81,129.05 108.56,129.3 108.56,130.09 108.64,130.16 109.04,130.16
+1.8V_PRIM on GND1 (solid shape): 107.44,130.09 107.44,129.3 107.34,129.2 106.96,129.2 106.55,128.79 106.3,128.79 106.25,128.84 106.25,129.56 106.35,129.66 106.73,129.66 106.81,129.73 106.81,130.06 106.91,130.16 107.37,130.16
+1.8V_PRIM on IN1 (solid shape): 108.37,132.78 108.37,132.34 108.28,132.26 106.41,132.26 105.91,132.76 105.91,132.89 106.07,133.05 108.1,133.05
+1.8V_PRIM on IN1 (solid shape): 109.5,129.69 109.5,129.65 109.73,129.42 109.73,129.17 109.65,129.1 108.53,129.1 108.44,129.18 108.44,129.34 108.51,129.62 108.26,129.75 108.04,129.75 107.98,129.81 107.77,129.81 107.62,129.66 107.62,129.37 107.58,129.29 107.57,129.2 107.55,129.16 107.52,129.15 106.98,129.15 106.91,129.23 106.45,129.23 106.25,129.43 106.25,130.06 106.43,130.24 108.94,130.24
+1.8V_PRIM on IN3 (solid shape): 108.33,133.85 108.33,132.04 109.78,130.6 109.78,129.56 109.3,129.07 108.74,129.07 108.31,129.5 107.67,129.5 107.24,129.07 105.61,129.07 105.31,129.38 105.31,133.76 105.7,134.15 108.03,134.15
+1.8V_PRIM on IN4 (solid shape): 53.44,116.89 53.44,116.78 53.3,116.64 52.52,116.64 52.17,116.3 51.54,116.3 51.54,116.65 52,116.65 52.41,117.06 53.28,117.06
+1.8V_PRIM on VCC: 41.53,118.79 40.92,119.4 40.92,131.89 42.13,133.08 44.45,135.17 47.25,135.17 50.42,138.34 61.24,138.34 61.49,138.09 61.49,132.02 61.21,131.74 56.82,131.74 56.54,132.02 56.54,134.89 55.88,135.55 53.27,135.55 52.73,135.05 52.73,132.02 52.45,131.74 45.13,131.74 43.84,130.45 43.84,126.69 44.42,126.05 44.42,126.05 44.48,126 44.48,119.4 43.86,118.79
+1.8V_PRIMP on TOP (solid shape): 42.17,114.26 43.54,114.26 43.61,114.19 43.61,110.18 43.56,110.13 43.18,110.13 43.15,110.15 42.58,110.15 42.05,109.62 41.21,109.62 41.07,109.76 41.07,110.89 40.39,111.57 40.39,114.29 40.61,114.52 41.91,114.52
+1.8V_UF_VDD on IN1 (solid shape): 115.12,131.75 115.12,131.31 115.06,131.26 114.93,131.26 114.66,130.99 114.66,130.93 114.61,130.81 114.61,130.67 114.51,130.57 114.35,130.57 114.17,130.74 114.17,131.26 114.68,131.78 115.09,131.78
+1.8V_UF_VDD on IN3 (solid shape): 114.59,130.95 114.59,130.31 114.09,129.81 114.07,129.81 113.87,129.61 113.87,129.59 113.73,129.45 113.28,129.45 113.07,129.66 113.07,129.87 113.24,130.05 113.44,130.05 113.58,130.19 113.81,130.19 114.02,130.4 114.02,130.55 114.03,130.57 114.03,130.98 114.13,131.08 114.47,131.08
+1.8V_WF_DOVDD on TOP (solid shape): 125.4,128.11 125.4,127.22 125.04,126.86 124.06,126.86 124.06,127.74 124.46,128.13 125.37,128.13
+1.8VA_LDO_PD on TOP (solid shape): 33.81,44.01 33.81,43.92 33.89,43.92 34.48,43.33 35.12,43.33 35.27,43.18 35.25,43.15 35.25,42.48 35.05,42.48 35,42.53 35,42.76 34.82,42.94 33.96,42.94 33.25,43.65 32.97,43.65 32.92,43.7 32.92,44.14 32.99,44.21 33.6,44.21
+1.8VD_LDO_PD on TOP (solid shape): 41.63,43.32 41.63,42.76 41.58,42.71 41.12,42.71 40.33,41.93 39.67,41.93 39.55,42.05 39.55,42.33 39.62,42.41 39.9,42.41 40.84,43.35 41.6,43.35
+1.8VS on TOP (solid shape): 110.3,126.47 110.3,125 110.21,124.91 109.42,124.91 109.37,124.96 109.37,126.35 109.5,126.48 110.29,126.48
+1.8VS on TOP (solid shape): 48.67,133.3 48.67,132.74 49.1,132.31 49.81,132.31 50.06,132.06 50.06,131.74 49.66,131.74 49.63,131.77 49.63,131.92 49.56,131.99 48.94,131.99 48.84,132.1 48.82,132.1 48.29,132.63 48.29,132.64 48.04,132.89 47.15,132.89 47.08,132.96 47.08,133.48 47.15,133.56 47.31,133.56 47.31,133.56 48.41,133.56
+1.8VS on BOTTOM (solid shape): 54.74,122.25 54.74,121.86 54.92,121.68 54.92,121.16 54.74,120.98 54.74,119.22 54.81,119.22 54.86,119.17 55.19,119.17 55.24,119.12 55.24,118.76 55.19,118.71 54.53,118.71 54.2,119.04 54.2,119.47 54.24,120.13 54.15,120.79 54.15,122.21 54.25,122.3 54.68,122.3
+1.8VS on IN1 (solid shape): 61.77,140.15 61.77,139.97 61.39,139.59 60.22,139.59 60.05,139.77 60.05,140.1 60.25,140.3 61.62,140.3
+1.8VS on IN2 (solid shape): 54.97,122.6 54.97,121.64 54.84,121.52 54.15,121.52 54.02,121.65 54.02,121.9 54.34,122.22 54.34,122.66 54.46,122.77 54.8,122.77
+1.8VS on IN4 (solid shape): 112.25,126.14 112.25,125.77 112.19,125.71 111.11,125.71 110.3,126.52 110.3,126.53 110.21,126.62 110.21,127.9 110.26,127.96 110.44,127.96
+1.8VS_AUDIO on TOP (solid shape): 18.48,109.49 18.48,109.29 18.05,108.85 18.05,108.61 18.01,108.57 17.59,108.57 17.54,108.62 17.54,109.02 18.17,109.64 18.33,109.64
+1.8VS_AUDIO on TOP (solid shape): 37.92,109.41 37.92,107.38 37.88,107.34 36.72,107.34 36.7,107.36 36.7,107.84 36.56,107.98 36.56,109.65 36.63,109.72 37.62,109.72
+1.8VS_AUDIO on TOP (solid shape): 32.64,84.72 32.64,83.56 32.79,83.4 33.5,83.4 33.58,83.33 33.58,83.28 33.5,83.2 32.51,83.2 32.26,83.45 32.26,83.73 32.07,83.92 31.71,83.92 31.71,83.92 31.71,84.3 31.55,84.46 31.55,84.9 31.65,85 32.36,85
+1.8VS_AUDIO on TOP (solid shape): 30.13,84.45 30.13,83.5 30.42,83.2 31.26,83.2 32.21,82.25 32.21,82.05 32.44,81.83 33.5,81.83 33.58,81.75 33.58,81.68 33.5,81.6 32.03,81.6 31.5,82.13 31.05,82.13 31,82.18 31,82.55 30.89,82.67 30.41,82.67 30.03,83.05 29.6,83.05 29.51,83.14 29.51,84.46 29.61,84.56 30.01,84.56
+1.8VS_AUDIO on IN1 (solid shape): 37.19,109.58 37.19,109.29 37.08,109.18 36.3,109.18 35.67,109.81 35.67,110.05 35.76,110.13 36.64,110.13
+1.8VS_AUDIO on IN1 (solid shape): 29.5,91.26 29.5,90.51 29.21,90.21 28.71,90.21 28.63,90.3 28.63,91.32 28.74,91.42 29.34,91.42
+2.8V_UF_AVDD on TOP (solid shape): 144.4,132.35 144.4,131.74 144.54,131.59 144.54,130.95 144.48,130.88 144.41,130.88 143.66,130.88 143.51,131.03 143.51,131.92 143.43,131.99 142.57,131.99 142.52,131.94 142.52,130.47 142.39,130.34 141.93,130.34 141.86,130.42 141.86,131.9 141.95,131.99 142.07,131.99 142.2,132.12 142.2,132.53 142.31,132.64 144.11,132.64
+2.8V_UF_AVDD on IN1 (solid shape): 142.81,132.69 143.6,132.69 144.23,132.06 144.23,131.68 144.17,131.61 142.39,131.61 142.2,131.42 142.07,131.42 141.88,131.61 141.88,131.99 141.53,132.34 141.53,132.86 141.63,132.96 142.54,132.96
+2.8V_UF_AVDD on IN1 (solid shape): 114.01,133.4 114.01,132.72 113.99,132.7 113.99,132.37 113.84,132.22 113.84,131.05 114.05,130.85 114.05,130.62 113.9,130.47 113.27,130.47 113.11,130.64 113.11,131.05 113.28,131.23 113.28,133.24 113.49,133.44 113.97,133.44
+2.8V_VCM_OUT on TOP (solid shape): 131.62,132.44 131.62,130.41 131.56,130.36 130.96,130.36 130.93,130.39 130.93,131.74 130.96,131.78 130.96,132.49 131.01,132.54 131.52,132.54
+2.8V_WF_AVDD on TOP: 126.39,124.91 127.28,124.91 127.33,124.86 127.33,123.69 127.2,123.56 126.64,123.56 126.6,123.6 126.6,123.94 126.31,124.23 126.31,124.83
+3.3V_BBAT_LDO on BOTTOM (solid shape): 142.39,99.18 142.39,98.39 141.91,98.39 141.91,98.82 141.48,99.25 141.48,99.39 141.59,99.5 142.07,99.5
+3.3V_BBAT_LDO on BOTTOM (solid shape): 141.58,96.23 141.58,96.01 141.02,95.46 141.02,95 140.92,94.9 140.66,94.9 140.61,94.95 140.61,95.79 141.2,96.37 141.44,96.37
+3.3V_LDO_PD on TOP (solid shape): 44.09,57.1 44.09,55.52 44.01,55.44 42.42,55.44 42.19,55.67 42.19,56.1 42.67,56.58 43.04,56.58 43.2,56.74 43.2,57.13 43.25,57.17 44.02,57.17
+3.3V_LDO_PD on TOP (solid shape): 37.79,44.67 37.79,44.19 36.88,43.27 36.88,42.69 36.78,42.59 36.63,42.59 36.55,42.66 36.55,44.52 36.96,44.52 37.17,44.73 37.73,44.73
+3.3V_LDO_PD on TOP (solid shape): 35.67,57.71 35.9,57.71 36.34,57.27 36.34,56.54 36.13,56.32 36.13,54.47 36.42,54.17 36.42,53.89 36.32,53.79 35.99,53.79 35.89,53.89 35.89,53.99 35.86,54.02 35.48,54.02 35.41,54.09 35.41,54.49 35.5,54.59 35.5,54.71 35.54,54.75 35.54,55.87 35.5,55.91 35.5,57.06 35.32,57.25 35.09,57.25 34.99,57.35 34.99,57.65 35.05,57.71 35.67,57.71
+3.3V_LDO_PD on IN1 (solid shape): 38.73,53.94 38.73,51.62 38.5,51.38 38.29,51.38 37.31,52.36 36.22,52.36 36.08,52.22 35.76,52.22 35.76,53.99 35.89,54.12 38.56,54.12
+3.3V_LDO_PD on TOP: 41.85,46.49 41.86,46.5 41.86,50.97 42.26,51.37 43.25,51.37 43.43,51.2 43.43,48.74 43.52,48.64 43.52,44.89 43.33,44.69 41.99,44.69 41.93,44.76 41.93,46.03 41.85,46.11
+3.3V_LDO_PD on VCC: 37.6,43.73 36.66,44.66 36.66,51.4 35.84,52.22 35.84,55.94 36.13,56.24 45.01,56.24 45.01,43.91 44.83,43.73
+3.3V_PCH_GPP on BOTTOM (solid shape): 61.05,117.69 61.05,117.54 60.99,117.48 60.97,117.46 60.87,117.36 60.87,117.19 61.05,117.01 61.05,116.93 60.66,116.54 59.75,116.54 59.31,116.98 58.29,116.98 58.22,117.06 58.22,117.44 58.27,117.49 59.66,117.49 59.73,117.41 60.41,117.41 60.74,117.74 60.99,117.74
+3.3V_PCH_GPP on BOTTOM (solid shape): 58.84,115.68 59.63,115.68 59.77,115.53 60.63,115.53 60.89,115.26 60.94,115.19 61.02,115.14 61.05,115.12 61.05,115.02 60.92,114.89 60.8,114.89 60.62,114.97 60.44,114.91 60.42,114.89 60.41,114.89 60.21,114.7 58.35,114.7 58.35,115.63 58.39,115.68 58.84,115.68
+3.3V_PCH_GPP on BOTTOM (solid shape): 58.54,121.21 59.8,121.21 60.03,120.99 60.42,120.99 60.61,120.91 60.8,120.99 60.92,120.99 61.05,120.86 61.05,120.73 61.02,120.72 60.9,120.52 61.02,120.31 61.05,120.3 61.05,120.1 60.97,120.04 60.93,119.98 60.66,119.72 60.54,119.72 60.28,119.98 56.91,119.98 56.83,120.06 56.83,120.99 56.75,121.06 56.35,121.06 56.08,121.33 56.08,121.71 56.16,121.78 57.97,121.78
+3.3V_SPI on TOP (solid shape): 48.87,114.21 48.87,113.86 48.26,113.25 48.26,112.31 48.08,112.13 47.65,112.13 47.52,112.26 47.52,113.77 48.02,114.26 48.82,114.26
+3.3V_SPI on BOTTOM (solid shape): 52.2,116.04 52.2,113.48 52.02,113.3 51.56,113.3 51.46,113.4 51.46,115.26 51.18,115.53 51.18,116.12 51.21,116.14 52.1,116.14
+3.3V_SPI on IN4 (solid shape): 51.43,115.99 51.43,115.59 51.23,115.38 51.16,115.38 49.95,114.18 49.19,114.18 48.54,113.53 48.13,113.53 47.95,113.71 47.95,113.91 48.79,114.75 48.83,114.79 49.49,114.79 50.75,116.04 51.38,116.04
+3.3V_SPI on TOP: 56.6,148 56.73,148 56.92,147.81 56.92,146.85 57.37,146.41 57.37,146.03 57.18,145.84 56.67,145.84 56.54,145.96 56.54,147.93
+3.3V_VCCSPI on BOTTOM (solid shape): 55.4,123.21 55.4,122.6 55.36,122.56 54.48,122.56 54.41,122.49 53.97,122.49 53.8,122.67 53.8,123.09 53.86,123.15 54.25,123.15 54.36,123.26 55.35,123.26
+3.3V_VCCSPI on VCC (solid shape): 55.61,122.42 55.61,121.95 55.53,121.87 54.51,121.87 54.32,121.68 53.9,121.68 53.62,121.96 53.62,122.36 53.76,122.5 55.52,122.5
+3.3V_VCCSPI on GND1 (solid shape): 64.28,120.59 64.28,120.48 64.63,120.13 64.63,119.98 64.5,119.85 64.34,119.85 63.91,120.28 63.78,120.28 63.58,120.49 63.58,120.67 63.8,120.89 63.98,120.89
+3.3V_VCCSPI on IN1 (solid shape): 64.2,120.65 64.2,120.57 64.63,120.14 64.63,119.94 64.53,119.84 64.26,119.84 63.82,120.28 63.78,120.28 63.58,120.49 63.58,120.67 63.8,120.89 63.95,120.89
+3.3V_VOUT_PD on IN1 (solid shape): 33.76,43.06 33.76,42.76 33.72,42.73 33.2,42.73 32.83,42.36 32.62,42.36 32.52,42.46 32.52,43.09 32.66,43.22 33.6,43.22
+3.3V_VOUT_PD on IN1 (solid shape): 35.1,42.1 35.31,42.1 35.48,41.93 35.76,41.93 35.86,41.82 35.86,41.65 35.74,41.52 35.2,41.52 35.2,41.52 34.97,41.52 34.65,41.84 34.64,41.84 34.55,41.94 34.55,42.22 34.67,42.35 34.85,42.35
+3.3VDX_SSD on TOP (solid shape): 42.7,101.13 42.7,100.5 42.54,100.35 40.82,100.35 40.74,100.42 40.74,101.11 40.84,101.21 42.62,101.21
+3.3VDX_SSD on TOP (solid shape): 34.42,108.91 34.87,108.91 35,108.78 35,108.14 34.87,108.02 34.87,107.41 34.77,107.31 34.68,107.31 34.67,107.3 33.51,107.3 33.51,107.3 33.41,107.4 33.41,108.82 33.55,108.96 33.81,108.96 33.96,109.11 34.21,109.11
+3.3VDX_SSD on BOTTOM (solid shape): 34.08,109.46 34.08,108.6 34.32,108.35 34.32,108.03 34.29,107.99 33.4,107.99 33.25,108.14 33.25,109.45 33.33,109.53 34.01,109.53
+3.3VDX_SSD on BOTTOM (solid shape): 26.24,109.11 26.24,108.52 26.16,108.45 24.57,108.45 24.51,108.51 24.51,109.03 24.56,109.08 24.99,109.08 25.09,109.18 26.16,109.18
+3.3VDX_SSD on BOTTOM (solid shape): 26.09,99.23 26.09,98.19 25.93,98.03 25.93,96.51 25.83,96.41 24.74,96.41 24.59,96.56 24.59,98.67 25.2,99.28 26.03,99.28
+3.3VDX_SSD on BOTTOM (solid shape): 42.93,97.98 42.93,94.73 42.54,94.35 38.94,94.35 38.61,94.68 38.61,98.01 38.68,98.08 40.33,98.08 40.44,97.98 40.44,96.31 40.72,96.03 41.96,96.03 42.14,96.21 42.14,97.98 42.27,98.11 42.8,98.11
+3.3VDX_SSD on GND1 (solid shape): 41.63,100.52 41.63,100.19 41.02,99.58 40.67,99.58 40.54,99.71 40.54,100.32 40.87,100.65 41.5,100.65
+3.3VDX_SSD on GND1 (solid shape): 34.42,108.96 34.42,107.81 34.16,107.56 33.17,107.56 32.99,107.74 32.99,108.83 33.24,109.08 34.29,109.08
+3.3VDX_SSD on IN1 (solid shape): 42.27,101.06 42.27,100.7 41.16,99.59 40.57,99.59 40.44,99.72 40.44,100.69 41.04,101.28 42.04,101.28
+3.3VDX_SSD on IN1 (solid shape): 34.39,108.98 34.39,106.9 34.27,106.78 33.1,106.78 32.97,106.91 32.97,108.73 33.38,109.13 34.24,109.13
+3.3VDX_SSD on IN3 (solid shape): 34.49,109.16 34.49,107.84 34.14,107.48 33.17,107.48 32.97,107.69 32.97,108.78 33.17,108.98 33.17,109.38 33.3,109.51 34.14,109.51
+3.3VDX_SSD on IN3 (solid shape): outline of 95 points within 25.03,95.75 41.33,100.52
+3.3VDX_SSD on GND3 (solid shape): 34.49,109.16 34.49,107.84 34.14,107.48 33.17,107.48 32.97,107.69 32.97,108.78 33.13,108.94 33.13,109.43 33.28,109.57 34.08,109.57
+3.3VDX_SSD on IN4 (solid shape): outline of 265 points within 24.49,97.7 34.47,111.04
+3V_1.8V_HDA on TOP (solid shape): 56.95,122.51 56.95,122.36 56.99,122.32 57.63,122.32 58,121.95 58,121.25 57.92,121.17 57.62,121.17 57.61,121.18 57.53,121.18 56.97,121.73 56.26,121.73 56.2,121.8 56.2,122.52 56.26,122.58 56.89,122.58
+3V_LDO on TOP (solid shape): 198.26,142.01 198.26,141.44 197.98,141.17 197.98,139.97 197.58,139.57 197.58,139.29 196.98,138.7 195.68,138.7 195.66,138.67 194.82,138.67 194.79,138.7 194.79,139.16 194.82,139.18 196.7,139.18 197.38,139.86 197.38,141.62 197.83,142.07 198.19,142.07
+3V_LDO on BOTTOM (solid shape): 130.52,102.36 130.52,102.17 129.67,101.32 129.52,101.32 129.3,101.54 129.3,101.69 130.2,102.59 130.29,102.59
+3V_LDO on BOTTOM (solid shape): 134.09,105.04 134.09,104.92 133.93,104.76 133.58,104.76 132.66,105.68 132.66,105.83 132.82,105.98 133.15,105.98
+3V_LDO on BOTTOM (solid shape): 118.61,94.04 118.61,93.68 117.94,93 117.58,93 117.46,93.12 117.46,93.47 117.6,93.61 117.6,93.62 118.07,94.09 118.56,94.09
+3V_LDO on BOTTOM (solid shape): 198.03,118.16 198.75,118.16 199.61,117.31 201.8,117.31 201.96,117.16 201.96,116.32 200.76,115.13 197.99,115.13 196.95,116.18 196.95,117.54 197.3,117.89 197.3,118.48 197.41,118.59 197.6,118.59
+3V_LDO on BOTTOM (solid shape): 135.22,102.49 135.22,98.03 135.17,97.98 135.05,97.98 135.01,98.02 135.01,98.87 134.96,98.93 134.96,99.65 134.4,100.21 134.4,102.52 134.52,102.63 135.08,102.63
+3V_LDO on IN1 (solid shape): 199.55,139.16 199.55,138.83 199.47,138.75 194.94,138.75 194.77,138.92 194.77,139.25 195,139.48 199.23,139.48
+3V_LDO on IN3 (solid shape): 197.41,130.17 197.41,129.65 198.08,128.98 198.08,127.79 198.2,127.68 198.2,118.3 198.19,118.3 198.19,117.68 196.89,116.37 196.31,116.37 196.3,116.38 195.65,116.38 195.49,116.55 195.49,116.88 196.93,118.33 196.93,118.33 196.93,128.36 196.36,128.92 196.36,130.25 196.56,130.45 197.14,130.45
+3V_LDO on IN4 (solid shape): 134.37,104.84 134.37,103.49 134.84,103.02 134.84,102 134.66,101.82 133.43,101.82 133.3,101.95 133.3,104.84 133.53,105.07 134.14,105.07
+3V_LDOP on BOTTOM (solid shape): 204.34,115.79 204.34,113.99 203.01,112.65 203.01,112.31 202.68,111.98 202.15,111.98 202.13,112 202.13,113.53 202.51,113.91 202.51,115.79 202.79,116.07 204.06,116.07
+3V_PRIM on TOP (solid shape): 123.7,137.02 123.7,135.6 122.86,134.76 119.02,134.76 118.64,135.14 118.64,136.77 119.18,137.3 123.42,137.3
+3V_PRIM on TOP (solid shape): 47.07,136.57 48.08,136.57 48.23,136.41 48.23,135.4 48.08,135.24 46.3,135.24 46.13,135.42 46.13,136.36 46.38,136.62 47.02,136.62
+3V_PRIM on TOP (solid shape): 34.85,103.34 34.85,101.89 34.7,101.74 33.25,101.74 33.16,101.83 33.16,103.1 33.25,103.19 34.06,103.19 34.24,103.37 34.82,103.37
+3V_PRIM on TOP (solid shape): 75.49,102.81 75.92,102.38 75.92,102.15 75.72,102.15 75.64,102.07 74.52,102.07 74.45,102.15 74.45,102.3 75.11,102.96 75.11,103.11 75.49,103.11
+3V_PRIM on TOP (solid shape): 48.62,124.37 48.62,123.84 48.36,123.59 48.06,123.59 47.78,123.87 46.89,123.87 46.89,124.37 47.22,124.7 48.29,124.7
+3V_PRIM on TOP (solid shape): 59.94,134.18 59.94,133.64 59.56,133.26 59.56,133.09 59.38,132.91 59.13,132.91 59.08,132.95 59.08,134.7 59.12,134.74 59.38,134.74
+3V_PRIM on TOP (solid shape): 63.8,142.81 63.8,142.53 63.78,142.51 63.78,140.5 60.15,140.5 60.02,140.63 60.02,142.64 60.38,142.99 63.63,142.99
+3V_PRIM on TOP (solid shape): 67.31,129.88 67.31,129.08 67.24,129.01 67.07,129.01 66.87,129.21 66.05,129.21 65.94,129.32 65.94,129.72 65.99,129.77 66.88,129.77 67.04,129.93 67.26,129.93
+3V_PRIM on TOP (solid shape): 71.18,103.58 71.18,102.52 70.72,102.05 70.27,102.05 70.16,102.16 70.16,102.59 70.66,103.1 70.66,103.55 70.8,103.69 70.85,103.69 70.87,103.7 71.07,103.7
+3V_PRIM on TOP (solid shape): 147.47,123.94 147.47,123.68 147.37,123.57 147.37,122.63 147.26,122.52 146.55,122.52 146.47,122.6 146.47,123.93 146.58,124.05 147.37,124.05
+3V_PRIM on TOP (solid shape): 52.4,100.96 52.4,99.87 52.31,99.77 46.78,99.77 46.72,99.83 46.72,100.24 46.87,100.4 49.01,100.4 49.12,100.28 51.39,100.28 51.52,100.42 51.52,100.95 51.57,101 52.36,101
+3V_PRIM on TOP (solid shape): 29.69,110.81 29.69,110.35 30.12,109.92 33.38,109.92 33.86,109.44 33.86,109.36 33.6,109.11 33.27,109.11 33.02,109.36 29.87,109.36 29.87,109.36 29.55,109.36 28.66,110.25 28.07,110.25 27.97,110.35 27.97,110.84 28.07,110.94 29.57,110.94
+3V_PRIM on BOTTOM (solid shape): 55.96,121.71 55.96,121.1 56.13,120.92 56.13,120.06 56.1,120.03 55.45,120.03 55.45,121.71 55.5,121.76 55.91,121.76
+3V_PRIM on BOTTOM (solid shape): 88.16,108.85 88.16,108.24 88.11,108.19 88.11,106.64 87.96,106.49 86.99,106.49 86.88,106.61 86.88,107.36 86.75,107.48 86.75,107.62 86.88,107.75 87.39,107.75 87.58,107.94 87.58,107.94 87.67,108.04 87.67,108.81 87.81,108.95 88.07,108.95
+3V_PRIM on BOTTOM (solid shape): 44.17,130.19 44.17,126.45 44.09,126.38 42.59,126.38 41.95,127.02 41.95,127.35 41.95,127.36 42.5,127.36 42.5,127.9 42.49,127.9 41.95,127.9 41.95,127.91 41.95,128.15 41.95,128.16 42.47,128.16 42.49,128.18 42.49,128.68 42.47,128.7 41.95,128.7 41.94,128.71 41.94,129.15 41.72,129.37 40.32,129.37 39.7,128.74 36.88,128.74 36.47,129.15 36.47,130.09 36.8,130.42 43.94,130.42
+3V_PRIM on IN1 (solid shape): 48.79,125.24 48.79,123.23 48.67,123.1 48.41,123.1 48.16,123.36 48.16,125.29 48.36,125.49 48.55,125.49
+3V_PRIM on IN1 (solid shape): 63.8,103.95 65.13,103.95 65.51,103.57 65.51,103.24 65.33,103.06 64.64,103.06 64.35,103.35 64.1,103.35 64.05,103.4 63.49,103.4 62.71,104.18 62.71,104.54 62.76,104.59 63.17,104.59
+3V_PRIM on IN1 (solid shape): 47.01,100.22 47.01,99.83 46.9,99.71 46.74,99.71 46.19,99.16 45.82,99.16 45.81,99.18 45.81,99.65 45.87,99.71 46.32,99.71 46.62,100.02 46.63,100.02 46.63,100.2 46.68,100.26 46.98,100.26
+3V_PRIM on IN1 (solid shape): 56.93,117.05 56.96,116.96 56.9,116.88 56.62,116.56 56.93,116.27 56.95,116.27 57.02,116.24 57.05,116.17 57.05,114.47 56.97,114.39 56.71,114.39 56.6,114.49 56.6,115.57 56.35,115.83 56.35,116.23 55.6,116.98 55.6,117.39 55.8,117.59 56.39,117.59
+3V_PRIM on IN4 (solid shape): 43.36,133.14 43.36,127.98 42.76,127.37 36.7,127.37 36.45,127.62 36.45,128.84 41.12,128.84 41.13,128.8 41.14,128.76 41.16,128.72 41.18,128.69 41.21,128.66 41.25,128.64 41.29,128.62 41.33,128.62 41.37,128.62 41.41,128.62 41.45,128.64 41.49,128.66 41.52,128.69 41.55,128.72 41.57,128.76 41.58,128.8 41.58,128.84 41.58,128.89 41.57,128.93 41.55,128.97 41.52,129 41.49,129.03 41.45,129.05 41.41,129.07 41.37,129.07 41.33,129.07 41.29,129.07 41.25,129.05 41.21,129.03 41.18,129 41.16,128.97 41.14,128.93 41.13,128.89 41.12,128.84 36.45,128.84 36.45,130.85 36.46,130.86 36.46,131.42 36.46,131.42 36.46,132.93 37.42,133.89 42.61,133.89
+3V_PRIM on TOP: 57.11,147.93 57.3,147.93 57.43,147.81 57.43,147.23 58.38,146.28 58.38,144.95 58.25,144.82 57.75,144.82 57.49,145.07 57.49,146.47 57.05,146.92 57.05,147.87
+3V_PRIM on TOP: 151.06,130.69 151.28,130.91 151.28,131.49 151.41,131.61 151.83,131.61 151.94,131.5 151.94,129.63 151.25,128.95 150.34,128.95 150.23,128.84 150.23,127.79 150.19,127.76 147.76,127.76 147.48,128.03 147.48,129.26 147.64,129.42 148.76,129.42 150.03,130.69
+3V_PRIM on BOTTOM: 50.98,125.36 49.73,125.36 49.5,125.14 49.5,125.03 49.28,124.81 48.62,124.81 48.36,124.55 48.36,123.84 48.29,123.76 47.93,123.76 47.83,123.66 47.83,122.24 47.88,122.19 48.23,122.19 49.48,123.43 49.48,123.74 49.45,123.76 49.12,123.76 49.05,123.84 49.05,124.4 49.1,124.45 49.35,124.45 49.81,124.91 50.98,124.91 51.08,125.01 51.08,125.26
+3V_PRIM on BOTTOM: 58.39,104.28 58.34,104.33 58.34,105.35 58.42,105.43 59.64,105.43 59.87,105.65 59.87,105.96 59.89,105.98 60.27,105.98 60.3,105.96 60.3,105.62 60.05,105.36 60.05,105.02 59.97,104.94 58.93,104.94 58.85,104.87 58.85,104.33 58.8,104.28
+3V_PRIM on BOTTOM: 54.05,125.86 53.98,125.85 53.9,125.94 53.9,126 53.84,126 53.83,126.01 53.8,126.01 53.35,126.01 53.25,126.12 53.25,126.63 53.35,126.74 53.73,126.74 53.93,126.54 53.93,126.19 54.08,126.05 54.53,126.05 54.7,125.88 54.7,125.52 54.67,125.49 54.33,125.49 54.3,125.52 54.3,125.75 54.21,125.84 54.14,125.84 54.12,125.86
+3V_PRIM on BOTTOM: 55.16,113.4 55.06,113.5 53.03,113.5 52.93,113.6 52.93,113.75 52.96,113.83 52.95,113.93 52.98,113.96 54.32,113.96 54.57,114.21 54.57,116.56 54.64,116.63 54.64,117.01 55,117.38 55.96,117.38 55.99,117.41 55.99,117.82 56.03,117.86 56.68,117.86 56.71,117.83 56.71,117.41 56.49,117.2 56.16,117.2 56,117.04 56,116.14 55.98,116.12 55.4,116.12 55.14,115.86 55.14,114.85 55.09,114.8 55.09,114.01 55.26,113.84 56.19,113.84 56.24,113.8 56.24,113.43 56.21,113.4
+3V_PRIM on VCC: 31.37,102.15 30.63,102.89 30.63,106.72 33.51,109.62 34.14,109.62 36.6,112.08 36.6,139.13 40.39,142.92 49.99,142.92 51.08,144.03 51.08,145.02 51.39,145.33 58.09,145.33 61.49,141.92 61.49,139.16 61.18,138.85 50.21,138.85 47.04,135.68 44.25,135.68 41.79,133.45 40.41,132.1 40.41,119.19 41.32,118.28 44.07,118.28 44.98,119.19 44.98,125.59 45.29,125.9 48.94,125.9 49.25,125.59 49.25,123.56 46.81,121.13 46.81,111.14 47.99,109.96 53.15,109.96 55.02,111.82 55.02,114.81 55.5,115.29 56.65,115.29 56.71,115.36 56.88,115.19 56.88,111.14 54.41,108.67 54.41,107.25 54.91,106.74 54.91,106.04 55.1,105.86 55.14,105.86 55.18,105.82 55.52,105.82 55.55,105.79 55.63,105.79 55.88,106.04 55.88,106.64 55.87,106.64 56.06,106.83 56.7,106.83 56.78,106.75 56.78,105.67 56.95,105.5 62.41,105.5 63.39,104.53 63.39,104.08 63.36,104.05 62.68,104.05 62.04,104.69 54.99,104.69 52.58,107.1 38.4,107.1 33.45,102.15
+3V_PRIM on VCC: 160.3,133.92 164.44,129.78 170.02,129.78 170.69,129.12 170.69,127.56 170.21,127.12 163.38,127.12 161.55,128.95 150.67,128.95 149.38,127.65 149.38,124.99 148.64,124.25 148.19,124.25 147.68,123.74 146.94,123.74 146.84,123.84 146.84,123.95 147.41,124.52 147.41,126.38 147.03,126.76 140.66,126.76 139.15,125.25 139.15,128.16 136.91,130.41 133.59,130.41 131.36,128.18 129.9,128.18 129.5,127.79 129.5,126.29 129.53,126.29 129.53,126.28 129.83,125.97 130.07,125.97 130.15,125.9 132.16,125.9 132.97,126.71 134.17,126.71 134.45,126.43 134.45,123.99 126.95,123.99 122.73,128.21 122.73,131.26 122.38,131.61 120.93,131.61 120.93,134.08 120.04,134.97 120.04,137.17 120.3,137.43 121.83,137.43 121.84,137.44 124.8,137.44 124.8,137.34 125.09,135.88 125.92,134.64 126.28,134.28 127.41,133.53 128.74,133.26 130.12,133.26 130.48,133.28 130.84,133.34 131.08,133.4 131.32,133.49 131.59,133.62 131.85,133.77 132.2,134.03 132.5,134.35 132.89,133.96 136.33,133.96 136.34,133.95
+3V_PRIM on IN1: 57.26,134.81 57.87,134.2 59.64,134.2 59.74,134.1 59.74,133.77 59.64,133.67 57.66,133.67 56.96,134.37 56.63,134.37 56.63,134.72 56.72,134.81
+3V_PRIMP on TOP (solid shape): 42.88,124.86 42.88,123.9 42.74,123.76 40.35,123.76 40.11,123.52 39.87,123.52 39.65,123.74 39.65,124.84 39.78,124.98 42.76,124.98
+3V_PRIMP on BOTTOM (solid shape): 41.76,126.94 43,125.69 43,124.02 42.47,123.48 38,123.48 37.62,123.87 37.59,123.87 37.36,124.09 37.36,128.31 39.67,128.31 40.41,129.05 41.76,129.05
+3V_SKYCAM on TOP (solid shape): 131.27,122.62 131.27,121.33 131.14,121.2 129.84,121.2 129.64,121.4 129.64,122.82 129.74,122.93 130.96,122.93
+3V_SKYCAM on TOP (solid shape): 136.14,121.96 136.14,121.5 135.66,121.02 133.27,121.02 133.1,121.2 133.1,121.73 133.4,122.04 136.07,122.04
+3V_SKYCAM on TOP (solid shape): 128.36,125.96 128.36,125.68 128.45,125.59 128.45,124.48 128.37,124.4 127.79,124.4 127.74,124.45 127.74,125.01 127.94,125.21 127.94,125.97 128.01,126.05 128.27,126.05
+3V_SKYCAM on TOP (solid shape): 140.97,127.02 140.97,123.31 139.67,122.01 138.66,122.01 138.56,122.11 138.56,122.52 138.66,122.62 139.14,122.62 140,123.48 140,127.07 140.03,127.09 140.89,127.09
+3V_SKYCAM on TOP (solid shape): 144.81,124.69 144.81,123.94 144.95,123.8 145.66,123.8 145.79,123.67 145.79,122.28 145.74,122.23 144.06,122.23 143.94,122.35 143.94,123.74 143.94,123.74 143.94,124.72 144.06,124.83 144.67,124.83
+3V_SKYCAM on TOP (solid shape): 128.73,131.54 129.26,131.54 129.36,131.43 129.36,131.13 129.03,130.8 129.03,129.61 129.11,129.53 129.11,129.3 129.06,129.25 128.9,129.25 128.83,129.33 128.83,129.76 128.7,129.89 128.7,130.19 128.04,130.85 128.04,131.49 128.04,131.54 128.17,131.66 128.6,131.66
+3V_SKYCAM on IN1 (solid shape): 145.92,122.96 145.92,122.33 145.8,122.2 144.74,122.2 144.66,122.28 144.66,122.94 144.75,123.03 145.85,123.03
+3V_SKYCAM on IN1 (solid shape): 130.2,122.85 130.45,122.85 130.45,122.84 131.05,122.84 131.15,122.75 131.15,122.21 131.07,122.14 129.75,122.14 129.3,122.59 129.3,122.7 129.5,122.9 130.15,122.9
+3V_SKYCAM on IN1 (solid shape): 132.63,131.43 132.63,131.32 131.86,130.54 130.21,130.54 130.18,130.57 129.94,130.57 129.77,130.74 128.18,130.74 128.14,130.78 128.14,131.08 128.17,131.1 130.07,131.1 130.33,130.85 131.6,130.85 132.17,131.42 132.19,131.42 132.26,131.49 132.58,131.49
+3V_SKYCAM on IN3 (solid shape): 145.94,123.47 145.94,122.65 145.84,122.55 145.1,122.55 145.03,122.62 145.03,122.96 144.99,123.01 144.99,123.01 144.88,123.12 144,123.12 142.53,121.64 138.9,121.64 138.71,121.83 138.71,122.7 138.84,122.82 142.23,122.82 143.56,124.15 145.26,124.15
+3V_SKYCAM on TOP: 130.68,127.65 130.48,127.65 130.43,127.7 130.43,127.85 130.5,127.92 130.78,127.92 130.89,128.03 130.89,128.87 131.09,129.07 131.09,129.13 132.07,130.11 132.07,131.34 132.14,131.4 132.35,131.4 132.36,131.39 132.5,131.39 132.6,131.29 132.6,129.9 131.39,128.69 131.39,128.13 131.47,128.06 131.84,128.06 131.96,127.94 131.96,127.4 131.85,127.29 131.04,127.29
+3V_SKYCAM on IN1: 127.89,126.47 127.89,125.85 127.96,125.77 130.3,125.77 131.66,127.13 132,127.13 132.05,127.18 132.05,127.46 131.94,127.57 130.97,127.57 129.73,126.33 128.9,126.33 128.68,126.56 128.68,126.97 128.57,127.08 128.5,127.08
+3V_SKYCAM on IN4: 133.23,121 132.35,121.87 132.35,123.04 132,123.39 131.65,123.39 131.17,122.91 128.13,122.91 127.48,123.56 127.48,124.37 127.61,124.5 128.73,124.5 128.96,124.27 129.18,124.5 129.3,124.49 129.38,124.5 129.45,124.5 129.5,124.19 129.82,124.23 130.74,124.23 131.02,124.5 132.25,124.5 133.38,123.37 133.38,122.04 133.63,121.79 133.98,121.79 134.13,121.94 134.28,121.94 134.33,121.89 134.33,121.85 134.31,121.76 134.33,121.68 134.33,121.67 134.33,121.26 134.06,121
+3V_TPM_S0 on TOP (solid shape): 57.66,142.55 57.66,139.84 57.53,139.72 57.02,139.72 56.62,140.12 55.68,140.12 55.6,140.2 55.6,140.55 56.79,141.75 56.79,142.61 56.92,142.74 57.47,142.74
+3VALW on TOP (solid shape): 200.24,133.33 200.24,132.18 200.18,132.12 199.29,132.12 199.22,132.18 199.22,133.33 199.35,133.45 200.11,133.45
+3VALW on TOP (solid shape): 51.54,105.24 51.54,104.21 51.46,104.13 49.5,104.13 49.48,104.16 49.48,105.23 49.55,105.3 51.48,105.3
+3VALW on TOP (solid shape): 206.17,129.36 206.17,126.56 206.12,126.51 205.16,126.51 204.9,126.76 204.52,126.76 204.47,126.81 204.47,129.49 204.62,129.64 205.89,129.64
+3VALW on TOP (solid shape): 181.39,106.15 181.8,106.15 181.97,105.98 181.97,102.43 181.17,101.64 179.56,101.64 179.51,101.69 179.51,102.43 180.31,103.24 180.31,106.1 180.37,106.16 181.38,106.16
+3VALW on TOP (solid shape): 50.48,102.61 51,102.61 51,102.61 52.22,102.61 52.3,102.53 52.3,102.29 52.3,102.29 52.3,102.08 52.78,101.6 52.78,101.29 52.78,101.28 51.67,101.28 51.61,101.34 51.61,101.87 51.38,102.1 49.56,102.1 49.48,102.17 49.48,102.66 49.56,102.73 50.36,102.73
+3VALW on TOP (solid shape): 206.22,125.04 206.22,122.75 206.88,122.09 216.41,122.09 218.24,120.25 218.24,106.17 217.35,105.27 217.35,104.97 217.24,104.86 216.77,104.86 216.71,104.92 216.71,106.24 217.02,106.54 217.37,106.54 217.5,106.67 217.5,107.23 217.35,107.38 217.35,119.09 215.65,120.79 206.02,120.79 204.44,122.37 204.44,124.07 204.56,124.18 205,124.18 205.23,124.41 205.23,125.04 205.3,125.11 206.15,125.11
+3VALW on TOP (solid shape): 201.24,106.06 201.24,101.38 201.88,100.75 202.87,100.75 202.97,100.65 202.97,100.29 202.79,100.12 200.86,100.12 199.59,101.39 198.7,101.39 198.7,101.38 198.38,101.38 198.15,101.15 198.15,98.81 198.04,98.71 197.09,98.71 196.95,98.85 196.95,101.84 196.24,102.56 195.76,102.56 195.68,102.63 195.68,103.6 196.14,103.6 196.6,103.14 197.21,103.14 197.36,102.99 197.36,102.43 197.47,102.31 198.2,102.31 199.06,103.18 199.06,106.03 198.99,106.1 198.99,106.14 198.73,106.4 198.7,106.4 198.68,106.42 193.15,106.42 192.98,106.59 192.98,108.03 193.14,108.19 199.11,108.19
+3VALW on BOTTOM (solid shape): 172.31,120.69 172.31,119.19 172.26,119.14 171.78,119.14 171.64,119.28 171.64,120.7 171.7,120.77 172.24,120.77
+3VALW on BOTTOM (solid shape): 118.57,109.51 118.57,108.96 118.49,108.88 117.22,108.88 117.07,109.03 117.07,109.36 117.14,109.44 117.98,109.44 118.14,109.59 118.49,109.59
