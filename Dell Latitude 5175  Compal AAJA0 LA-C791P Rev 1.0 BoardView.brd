# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBC_EN: length 22.6
  TOP w0.119: U30.1 30.19,59.94 29.68,59.43 29.68,58.71 30.63,57.76 31.25,57.76 v1(31.44,57.57) ; R278.1 31.66,41.75 v1(31.52,41.89)
  IN1 w0.084: v1(31.52,41.89) 31.35,41.89 v2(31.12,41.66) ; v2(31.44,54.97) v1(31.44,57.57)
  IN2 w0.079: v2(31.12,41.66) 31.52,42.06 31.52,43.16 31.65,43.28 31.65,45.95 30.63,46.97 30.63,48.94 31.44,49.75 v2(31.44,54.97)
USBC_EN_R: length 24.4
  TOP w0.119: v1(32.36,57.57) 31.78,58.16 31.78,58.52 31.89,58.64 U30.4 33.31,58.64 R231.1 ; v1(32.99,48.26) 32.14,47.41 30.63,47.41 29.79,46.57 29.67,46.57 29.16,46.07 29.16,40.99 R264.2
  IN1 w0.084: v2(32.41,48.55) 32.7,48.26 v1(32.99,48.26) ; v2(32.03,55.1) 32.36,55.43 v1(32.36,57.57)
  IN2 w0.079: v2(32.03,55.1) 32.03,54.46 31.71,54.14 31.71,49.87 32.41,49.17 v2(32.41,48.55)
USBC_HPD: length 33.5
  TOP w0.119: RV20.1 22.6,49.54 v1(24.01,49.54) ; v1(39.39,33.34) 39.39,33.19 39.69,32.89 40.78,32.89 40.89,32.99 R302.2
  IN1 w0.084: v2(24.28,48.05) 24.47,48.24 24.47,49.25 24.18,49.54 v1(24.01,49.54) ; v1(39.39,33.34) 39.37,33.34 39.07,33.64 39.07,35.42 v2(38.79,35.7)
  IN2 w0.079: v2(24.28,48.05) 24.28,44.17 23.46,43.35 23.46,40.62 27.14,36.93 29.43,36.93 30.95,35.41 38.49,35.41 v2(38.79,35.7)
USBC_MUX_EN: length 7.1
  TOP w0.119: U31.17 v1(26.51,41.89) ; v1(29.62,42.34) R262.2 30.06,41.9 30.06,41.06 30.25,40.87 30.25,40.74 30.44,40.55 R264.1
  IN1 w0.084: v1(29.62,42.34) 28.93,42.34 28.85,42.27 27.58,42.27 27.2,41.89 v1(26.51,41.89)
USBC_POL: length 35.5
  TOP w0.119: R296.1 R286.2 22.8,34.37 23.24,34.81 23.24,35.88 22.47,36.65 22.35,36.65 v1(22.12,36.87) ; R255.2 40.79,50.13 40.79,51.35 40.61,51.53 36.36,51.53 v1(36.23,51.4) ; U31.3 24.01,36.96 v1(24.09,36.87)
  IN1 w0.084: v2(30.51,40.55) 27.71,37.76 27.71,37.51 26.82,36.62 25.3,36.62 25.04,36.87 v1(24.09,36.87) 24.09,36.87 v1(22.12,36.87) ; v1(36.23,51.4) 36.23,50.99 v2(36.35,50.87)
  IN2 w0.079: v2(30.51,40.55) 33.55,43.6 33.55,47.69 35.25,49.39 36.04,49.39 36.35,49.7 v2(36.35,50.87)
USBC_RX1N: length 39.9
  TOP w0.119: v1(24.51,35.28) 24.42,35.28 24.23,35.48 24.23,35.97 23.39,36.81 23.39,37.06 23.51,37.17 U31.2
  IN1 w0.109: v1(24.51,35.28) 24.33,35.46 v2(24.33,35.74)
  IN3 w0.084: JUSBC1.B10 6.39,17.96 7.16,17.96 7.91,17.21 17.01,17.21 26.66,26.86 26.66,30.32 27.04,30.7 27.04,34.26 26.49,34.8 24.4,34.8 24.13,35.07 24.13,35.54 v2(24.33,35.74)
USBC_RX1P: length 40
  TOP w0.119: v1(23.65,35.28) 23.96,35.6 23.96,35.87 23.13,36.7 23.13,37.06 23.01,37.19 U31.1
  IN1 w0.109: v1(23.65,35.28) 23.9,35.28 24.03,35.41 24.03,35.51 v2(23.8,35.74)
  IN3 w0.084: v2(23.8,35.74) 23.96,35.58 23.96,35 24.33,34.64 26.43,34.64 26.87,34.19 26.87,30.77 26.49,30.39 26.49,26.93 16.94,17.37 7.98,17.37 7.23,18.12 6.41,18.12 JUSBC1.B11
USBC_RX2N: length 41
  TOP w0.119: U31.10 27.51,37.13 27.95,36.68 28.84,36.68 29.69,35.84 29.69,35.54 v1(29.97,35.26)
  IN1 w0.109: v1(8.09,14.3) 8.19,14.2 8.39,14.2 8.74,13.86 8.74,13.46 v2(8.84,13.36) ; v2(29.82,35.58) 29.82,35.41 v1(29.97,35.26)
  IN3 w0.084: v2(29.82,35.58) 29.73,35.49 29.73,34.07 30.25,33.54 30.25,28.86 17.4,16.01 12.2,16.01 10.27,14.08 8.77,14.08 8.64,13.95 8.64,13.56 v2(8.84,13.36)
USBC_RX2P: length 41
  TOP w0.119: v1(29.18,35.26) 29.43,35.5 29.43,35.73 28.73,36.42 v17(28.47,36.42) 27.85,36.42 27.01,37.26 U31.9
  IN1 w0.109: v2(29.29,35.6) 29.18,35.5 v1(29.18,35.26) ; v1(8.09,13.8) 8.09,13.88 8.18,13.97 8.3,13.97 8.51,13.76 8.51,13.52 8.35,13.36 v2(8.31,13.36)
  IN3 w0.084: v2(29.29,35.6) 29.57,35.32 29.57,34 30.09,33.48 30.09,28.92 17.34,16.17 12.13,16.17 10.2,14.24 8.7,14.24 8.47,14.01 8.47,13.45 8.38,13.36 v2(8.31,13.36)
USBC_SBU1: length 50.8
  TOP w0.119: R284.2 31.39,37.87 v1(30.52,37)
  IN1 w0.109: v1(30.52,37) 30.17,37.34 29.23,37.34 29.04,37.15 28.75,37.15 27.48,35.88 24.89,35.88 24.67,36.1 19.01,36.1 16.66,33.75 16.66,26.74 v2(16.81,26.58) ; v1(8.09,15.3) v2(7.49,15.3)
  IN3 w0.084: v2(7.49,15.3) v3(8.08,15.3) ; v2(16.81,26.58) 16.66,26.43 16.66,23.15 16.41,22.9 16.41,22.3 16.54,22.18 v7(16.71,22.18)
  IN4 w0.089: v7(16.71,22.18) 16.62,22.27 16.41,22.27 16.28,22.14 16.28,20.47 15.01,19.2 9.37,19.2 9.25,19.08 9.25,18.79 9.12,18.66 8.94,18.66 8.81,18.79 8.81,19.08 8.69,19.2 8.47,19.2 8.34,19.08 8.34,18.57 8.22,18.44 7.99,18.44 7.86,18.57 7.86,18.75 7.73,18.87 7.39,18.87 7.21,18.7 7.21,17.71 7.42,17.5 7.42,17.23 7.51,17.15 8.03,17.15 8.12,17.06 8.12,16.79 8.03,16.7 7.51,16.7 7.42,16.61 7.42,16.35 7.51,16.26 8.03,16.26 8.12,16.17 8.12,15.9 8.03,15.81 7.51,15.81 7.42,15.72 7.42,15.44 7.56,15.3 v3(8.08,15.3)
USBC_SBU1_R: length 2.7
  TOP w0.119: U31.11 28.45,38.61 28.6,38.46 28.6,37.63 29.23,37 R283.2
USBC_SBU2: length 51.4
  TOP w0.119: R281.2 30.95,40.77 30.95,38.39 30.52,37.96 v1(30.52,37.89)
  IN1 w0.109: v1(30.52,37.89) 30.2,37.57 29.14,37.57 28.94,37.38 28.65,37.38 27.38,36.11 24.99,36.11 24.77,36.33 18.92,36.33 16.43,33.85 16.43,26.74 16.28,26.59 v2(16.28,26.58)
  IN3 w0.084: v2(16.28,26.58) 16.48,26.39 16.48,23.23 16.22,22.98 16.22,22.42 v7(15.98,22.18)
  IN4 w0.089: v7(15.98,22.18) 16.07,22.09 16.07,20.56 14.92,19.42 9.04,19.42 6.73,21.73 5.17,21.73 4.52,21.08 4.52,18.41 JUSBC1.B8
USBC_SBU2_R: length 2.5
  TOP w0.119: R279.2 29.17,37.89 29.02,38.03 29.02,38.76 28.68,39.11 U31.12
USBC_TOP_N: length 20.3
  IN1 w0.109: v1(21.89,30.99) 22.06,30.99 22.17,31.1 22.17,31.4 22.44,31.66 22.67,31.89 23.11,31.89 23.48,32.27 24.74,32.27 25.42,31.59 28.4,31.59 28.63,31.82 31.89,35.07 31.89,36.42 31.39,36.91 31.39,38.92 32.63,40.15 34.67,40.15 v1(34.69,40.17)
USBC_TOP_N_R: length 23.4
  TOP w0.119: JUSBC1.A7 8.61,15.8 8.73,15.92 9.03,15.92 9.28,16.17 9.28,16.51 v1(9.35,16.58) ; R304.2 22.04,30.26 22.04,29.99 v1(21.82,29.77)
  IN1 w0.109: v1(9.35,16.58) 9.26,16.49 9.26,16.21 9.35,16.11 10.17,16.11 18.89,24.83 19.66,24.83 22.15,27.32 22.15,29.76 22.08,29.83 21.88,29.83 v1(21.82,29.77)
USBC_TOP_P: length 20.3
  IN1 w0.109: v1(35.19,40.17) 34.92,39.9 33.88,39.9 33.86,39.92 32.72,39.92 31.65,38.84 31.65,36.98 32.12,36.52 32.12,34.98 28.86,31.72 28.86,31.72 28.5,31.36 25.33,31.36 24.64,32.04 23.58,32.04 23.2,31.66 22.77,31.66 22.7,31.6 22.41,31.3 22.41,31.04 v1(22.45,30.99)
USBC_TOP_P_R: length 23.4
  TOP w0.119: R305.2 22.3,30.25 22.3,30 v1(22.53,29.77) ; JUSBC1.A6 8.62,16.3 8.74,16.18 8.92,16.18 9.02,16.28 9.02,16.52 v1(8.97,16.58)
  IN1 w0.109: v1(22.53,29.77) 22.38,29.62 22.38,27.22 19.76,24.6 18.99,24.6 10.27,15.88 9.26,15.88 9.03,16.11 9.03,16.51 v1(8.97,16.58)
USBC_TX1N: length 33.4
  TOP w0.119: U31.5 25.01,37.09 24.89,36.97 24.89,36.84 26,35.73 26,35.6 v1(26.34,35.26)
  IN1 w0.109: v2(8.85,17.76) 8.66,17.95 8.24,17.95 v1(8.09,17.8) ; v2(26.29,34.28) 26.29,34.28 26.04,34.53 26.04,34.98 26.31,35.26 v1(26.34,35.26)
  IN3 w0.084: v2(8.85,17.76) 8.93,17.83 16.83,17.83 26.1,27.11 26.1,34.09 v2(26.29,34.28)
USBC_TX1P: length 33.3
  TOP w0.119: U31.4 24.51,37.12 24.62,37 24.62,36.73 v17(25.11,36.24) 25.74,35.62 25.74,35.52 v1(25.48,35.26)
  IN1 w0.109: v2(8.85,18.29) 8.74,18.18 8.21,18.18 v1(8.09,18.3) ; v2(25.76,34.28) 25.81,34.33 25.81,35.22 25.72,35.31 25.53,35.31 v1(25.48,35.26)
  IN3 w0.084: v2(8.85,18.29) 8.85,18.27 9.12,18 16.76,18 25.94,27.18 25.94,34.09 v2(25.76,34.28)
USBC_TX2N: length 40.6
  TOP w0.119: U31.7 26.01,37.56 26.01,37.2 25.87,37.06 25.87,36.92 26.37,36.43 27.14,36.43 27.84,35.73 27.84,35.38 27.97,35.26 v1(28.19,35.26)
  IN1 w0.109: v1(28.19,35.26) 28,35.26 27.89,35.15 27.89,34.52 28.14,34.27 28.35,34.27 28.48,34.4 v2(28.48,34.42)
  IN3 w0.084: JUSBC1.B3 6.08,14.18 6.14,14.11 6.24,14.11 6.31,14.03 7.55,14.03 8.42,14.9 9.97,14.9 11.86,16.79 17.14,16.79 27.71,27.35 27.71,33.7 28.17,34.16 28.27,34.16 28.48,34.37 v2(28.48,34.42)
USBC_TX2P: length 40.6
  TOP w0.119: U31.6 25.51,37.16 25.61,37.06 25.61,36.81 26.26,36.16 v17(26.57,36.16) 27.03,36.16 27.58,35.62 27.58,35.5 v1(27.33,35.26)
  IN1 w0.109: v2(28.48,33.71) 28.16,34.04 28.05,34.04 27.66,34.42 27.66,34.97 27.37,35.26 v1(27.33,35.26)
  IN3 w0.084: v2(28.48,33.71) 28.48,33.85 28.33,34 28.23,34 27.87,33.64 27.87,27.29 17.21,16.63 11.93,16.63 10.04,14.74 8.49,14.74 7.62,13.87 6.3,13.87 JUSBC1.B2
USH_DET#: length 211.4
  IN1 w0.084: v1(45.49,117.46) 45.87,117.46 v2(46,117.59) 47.19,118.78 47.19,121.37 47.51,121.69 48.43,121.69 49.71,122.96 49.71,124.53 51.76,126.59 52.74,126.59 53.05,126.28 53.69,126.28 55.33,127.91 56.78,127.91 56.93,128.06 58.07,128.06 59.82,129.82 60.73,129.82 62.94,132.03 64.83,132.03 64.92,131.95 71.64,131.95 71.83,131.76 72.58,131.76 73.35,130.99 74.72,130.99 75.66,131.93 76.81,131.93 77.38,132.5 85.71,132.5 87.25,134.04 99.06,134.04 99.36,134.34 99.57,134.34 99.65,134.42 106.26,134.42 106.33,134.34 119.22,134.34 120.92,132.64 120.92,131.17 121.11,130.98 121.11,130.11 122.56,128.67 122.93,128.67 123.04,128.56 125.17,128.56 125.6,128.13 126.98,128.13 127.06,128.21 128.39,128.21 128.87,128.68 129.47,128.68 129.55,128.76 130.11,128.76 130.24,128.88 132.52,128.88 134.07,130.43 136.21,130.43 140.15,134.38 167.82,134.38 172.36,129.83 176.78,129.83 176.95,129.67 178.09,129.67 179.48,131.06 v2(179.53,131.06)
  IN3 w0.06: 56.58,118.95 57.33,118.21 59.96,118.21 60.15,118.02 60.19,118.02 60.19,118.02 60.29,118.02 62.1,118.02 62.14,118.06 62.51,118.06 62.71,118.26 v10(62.85,118.26)
  IN3 w0.084: v2(179.53,131.06) 179.56,131.03 v3(179.91,131.03) ; v2(46,117.59) 46.76,118.35 47.91,118.35 48.68,117.58 52.12,117.58 53.17,118.63 53.2,118.63 53.58,119.01 53.9,119.01 54.03,118.88 54.4,118.88 54.65,118.63 55.47,118.63 55.59,118.74 55.83,118.74 56.04,118.95 56.58,118.95
  IN4 w0.089: v4(190.83,102.96) 190.83,101.59 v4(190.93,101.49) ; v3(179.91,131.03) 179.91,130.52 179.27,129.88 179.27,127.84 184.05,123.05 184.05,111.8 v4(184.72,111.13)
  BOTTOM w0.119: v4(184.72,111.13) 184.72,105.28 186.51,103.48 190.31,103.48 v4(190.83,102.96) ; JUSH1.26 v4(190.93,101.49)
USH_I2C_ALERT#: length 49.6
  IN4 w0.089: v10(193.32,135.74) 193.58,135.47 193.92,135.47 194.08,135.63 194.08,135.82 194.24,135.98 194.46,135.98 194.59,135.85 194.59,135.6 194.71,135.48 195.35,135.48 197.32,133.51 197.32,131.72 197.96,131.08 197.96,130.07 v4(198.35,129.68) 198.37,129.68 199.05,130.36 201.28,130.36 204.88,126.77 204.88,119.45 202.74,117.31 202.74,114.03 200.46,111.75 200.46,107.77 199.22,106.53 198.58,106.53 196.88,104.82 196.88,104.64 196.11,103.87 v4(196.11,101.64)
  BOTTOM w0.119: JUSH1.13 197.43,100.32 v4(196.11,101.64)
USH_PS_SMBCLK: length 350.4
  TOP w0.119: v1(25.97,93.41) 27.1,92.29 29.47,92.29 30.12,91.63 37.19,91.63 39.26,93.7 v1(41.23,93.7)
  IN1 w0.109: v1(41.23,93.7) 41.89,94.36 42.33,94.36 42.98,95.01 45.06,95.01 46.71,93.36 53.96,93.36 54.17,93.15 59.36,93.15 59.74,93.54 60.21,93.54 v2(60.58,93.17) ; v1(25.97,93.41) 24.94,93.41 20.84,97.51 20.84,114.32 20.15,115.02 20.15,116.57 9.57,127.14 9.57,132.6 10.79,133.82 10.79,134.92 11.99,136.13 11.99,138.04 12.23,138.27 v2(12.23,138.38)
  IN2 w0.079: v2(115.96,96.95) 115.24,96.23 103.69,96.23 98.78,101.15 97.2,101.15 95.72,102.63 95.1,102.63 94.45,103.28 89.65,103.28 89.22,102.85 87.29,102.85 86.78,102.34 85.18,102.34 80.16,97.32 80.16,94.72 78.33,92.89 60.83,92.89 60.58,93.14 v2(60.58,93.17) ; v2(198.6,99.25) 198.73,99.25 199.69,98.29 213.49,98.29 213.94,98.75 215.92,98.75 221.1,103.92 221.1,109.72 220.97,109.84 220.97,116.91 v2(220.55,117.34)
  IN3 w0.084: v3(116.98,96.95) 116.82,96.79 116.12,96.79 v2(115.96,96.95) ; v7(198.43,99.9) 198.6,99.73 v2(198.6,99.25) ; v7(221.53,117.72) 221.42,117.72 221.03,117.34 v2(220.55,117.34) 219.75,118.13 219.75,123.16 219.75,123.17 219.75,123.31 217.68,125.38 217.68,138.39 215.02,141.05 212.56,141.05 204.51,149.1 201.76,149.1 198.59,145.94 197.17,145.94 195.64,144.41 193.46,144.41 193.23,144.19 193.23,143.74 191.34,141.85 191.34,141.29 191.12,141.07 191.12,140.58 v7(191.01,140.46) ; v7(12.23,138.87) v2(12.23,138.38)
  IN4 w0.066: v7(191.01,140.46) 191.42,140.05 191.42,138.06 191.82,137.66 v4(191.82,137.24)
  IN4 w0.089: v3(116.98,96.95) 117.11,96.95 117.42,96.64 118.42,96.64 118.81,96.26 120.22,96.26 121.34,95.14 131.87,95.14 132.46,94.56 136.03,94.56 136.28,94.81 141.44,94.81 144.61,97.98 146.07,97.98 146.81,97.23 146.81,94.64 147.9,93.55 166.17,93.55 166.84,94.22 176.49,94.22 179.21,96.94 184.12,96.94 185.17,97.98 185.84,98.66 190.72,98.66 191.22,99.16 193.13,99.16 193.35,98.94 195.13,98.94 195.63,99.44 198.12,99.44 198.43,99.75 v7(198.43,99.9)
  BOTTOM w0.119: JIO1.13 221.48,117.68 v7(221.53,117.72)
USH_PS_SMBDAT: length 354
  TOP w0.119: v1(41.83,93.79) 41.54,94.07 39.1,94.07 37.03,92 30.28,92 28.99,93.29 v1(28.99,94.4)
  IN1 w0.109: v2(60.02,93.14) 60.02,92.96 59.85,92.79 46.69,92.79 45.05,94.43 42.91,94.43 42.48,94 42.04,94 v1(41.83,93.79) ; v2(13.7,140.57) 13.7,138.68 12.75,137.72 12.75,135.81 11.55,134.61 11.55,133.51 10.33,132.29 10.33,127.46 19.76,118.03 21.15,118.03 22.6,116.58 22.6,113.33 21.6,112.34 21.6,97.82 24.89,94.53 28.87,94.53 v1(28.99,94.4)
  IN2 w0.079: v2(116.51,97.14) 116.51,96.8 115.57,95.86 103.57,95.86 98.62,100.81 97.06,100.81 96.1,101.78 95.39,101.78 94.7,102.47 87.37,102.47 86.89,101.98 85.29,101.98 80.5,97.19 80.5,94.58 78.43,92.5 60.67,92.5 v2(60.02,93.14) ; v2(197.97,99.53) 198.15,99.71 198.92,99.71 199.91,98.72 205.51,98.72 205.78,98.99 213.54,98.99 213.76,99.21 215.73,99.21 215.8,99.28 215.8,99.28 220.64,104.11 220.64,116.54 v2(220.32,116.86)
  IN3 w0.084: v7(191.77,140.46) 191.77,140.8 192.32,141.35 192.32,141.52 193.8,143 195.84,143 197.35,144.5 197.64,144.5 201.75,148.62 204.33,148.62 212.26,140.69 214.7,140.69 217.22,138.17 217.22,125.19 219.29,123.12 219.29,117.89 v2(220.32,116.86) 221.04,116.86 v7(221.48,117.29) ; v7(13.23,140.57) v2(13.7,140.57) ; v2(197.97,99.53) 197.97,99.86 v7(197.93,99.9) ; v2(116.51,97.14) 116.61,97.25 117.09,97.25 117.36,96.98 v3(117.47,96.98)
  IN4 w0.066: v4(194.32,136.24) 194.17,136.24 193.92,135.99 193.9,135.99 193.89,135.98 193.72,135.98 193.22,135.98 192.23,135.98 192.07,136.14 192.07,137.77 191.55,138.29 191.55,140.24 v7(191.77,140.46)
  IN4 w0.089: v7(197.93,99.9) 195.61,99.9 194.98,99.28 193.5,99.28 193.27,99.51 191.08,99.51 190.57,99 185.7,99 185.02,98.33 185.02,98.33 183.97,97.28 179.07,97.28 176.35,94.56 166.7,94.56 166.03,93.9 148.04,93.9 147.15,94.78 147.15,97.38 146.21,98.32 144.47,98.32 141.3,95.15 136.14,95.15 135.89,94.9 132.6,94.9 132.02,95.48 121.48,95.48 120.36,96.6 118.95,96.6 118.57,96.98 v3(117.47,96.98)
  BOTTOM w0.119: JIO1.15 221.47,117.28 v7(221.48,117.29)
USH_PWR_STATE#: length 96.4
  TOP w0.119: v1(192.94,99.89) 191.45,99.89 v14(190.91,100.43)
  IN1 w0.084: v2(192.79,99.51) 192.94,99.66 v1(192.94,99.89)
  IN2 w0.079: v2(196.53,137.08) 196.6,137.08 197.2,137.68 199.36,137.68 199.79,138.11 201.66,138.11 202.59,139.05 207.43,139.05 209,140.62 213.98,140.62 217.68,136.92 217.68,136.07 220.2,133.54 220.2,119.48 219.79,119.06 219.79,116.63 219.79,116.59 220.25,116.13 220.25,104.28 215.56,99.59 213.59,99.59 213.38,99.38 213.33,99.38 213.32,99.39 205.1,99.39 204.93,99.56 204.2,99.56 203.87,99.23 199.96,99.23 199.24,99.95 196.29,99.95 195.98,100.26 194.68,100.26 193.93,99.51 v2(192.79,99.51)
  IN3 w0.084: v10(193.82,136.74) 193.87,136.69 195.85,136.69 195.85,136.69 196.28,136.69 196.53,136.94 v2(196.53,137.08) ; v7(192.43,98.85) 192.79,99.2 v2(192.79,99.51)
  BOTTOM w0.119: v7(192.43,98.85) 192.93,99.35 JUSH1.22
USH_RST#: length 4.1
  BOTTOM w0.119: R326.1 186.69,139.44 188.14,139.44 188.77,138.8 188.77,138.56 188.89,138.45 189.28,138.45 189.82,137.91 U34.A11
USH_RST#_R: length 74.9
  TOP w0.119: RZ2.2 197.87,103.67 RZ1.2 197.86,103.69 R166.2 196.62,104.06 194.82,104.06 194.58,103.82 U19.4 194.58,102.46 194.45,102.33 192.94,102.33 v1(192.01,103.25) 190.69,104.57 v14(190.69,105.02) 190.69,106.85 191.47,107.63 v13(191.47,109.45)
  IN1 w0.084: v2(179.25,129.57) 180.16,129.57 182.22,131.63 182.22,132.46 183.27,133.51 183.27,134.66 184.58,135.97 185.37,135.97 187.38,137.97 187.38,138.84 v2(187.25,138.97)
  IN1 w0.109: v1(192.01,103.25) v2(191.58,103.25)
  IN3 w0.084: v3(191.26,102.96) 191.29,102.96 v2(191.58,103.25) ; v3(186.07,128.74) 185.36,128.74 184.03,130.07 181.97,130.07 181.55,129.66 179.34,129.66 v2(179.25,129.57) ; v7(186.87,140.96) 187.25,140.58 v2(187.25,138.97)
  IN4 w0.089: v13(191.47,109.45) 191.55,109.45 192,109.9 193.49,109.9 194.97,111.38 194.97,113.6 196,114.63 196,123.34 194.28,125.06 193.15,125.06 191.86,126.35 186.66,126.35 186.07,126.94 186.07,128.74 v3(186.07,128.74) ; v3(191.26,102.96) 191.46,102.76 191.57,102.76 v4(193.07,101.26)
  BOTTOM w0.119: JUSH1.21 193.43,100.89 v4(193.07,101.26) ; v7(186.87,140.96) 186.66,140.76 R326.2
VCORE_PG: length 53.1
  TOP w0.119: v14(117.41,122.62) 117.41,123.62 117.17,123.87 115.96,123.87 115.72,124.11 v9(115.72,124.17)
  GND1 w0.254: v9(115.72,124.17) 115.77,124.12 v2(115.77,123.84)
  IN3 w0.06: 114.33,121.01 114.1,120.78 114.1,120.51 113.83,120.24 v7(113.83,120.2)
  IN3 w0.084: v7(95,108.5) 95.39,108.1 99.37,108.1 99.46,108.01 102.95,108.01 103.92,108.97 106.67,108.97 107.11,108.52 110.59,108.52 110.9,108.83 111.56,108.83 112.07,109.35 114.13,109.35 118.09,113.31 118.09,116.62 118.61,117.14 118.61,117.19 118.61,117.19 118.61,118.04 116.95,119.7 116.95,121 117.47,121.52 117.47,122.23 117.99,122.76 117.99,123.44 117.83,123.61 117.32,123.61 117.22,123.51 116.1,123.51 v2(115.77,123.84)
  IN3 w0.254: 114.33,121.01 114.61,121.01 114.78,121.19 114.78,121.5 115.11,121.83 115.11,123.18 v2(115.77,123.84)
  BOTTOM w0.119: v7(95,108.5) 95,108.96 94.39,109.57 91.88,109.57 91.4,109.08 UH5.2
VDOCKPOGOPIN: length 89.2
  IN4 w0.089: v4(163.71,97.53) 163.79,97.61 174.13,97.61 174.49,97.25 175.62,97.25 177.71,99.35 182.31,99.35 186.41,103.46 189.94,103.46 190.52,104.04 194.93,104.04 195.92,105.03 195.92,105.22 198.15,107.44 198.15,111.33 201.41,114.59 201.41,124.12 198.53,127 197.34,127 195.82,128.52 195.53,128.52 194.92,129.13 194.92,129.57 v4(194.64,129.85) ; v4(163.64,102.56) 163.46,102.38 155.8,102.38 155.37,102.81 153.88,102.81 153.63,103.06 153.4,103.29 151.04,103.29 150.56,103.77 150.56,104.63 v4(150.48,104.71)
  BOTTOM w0.119: v4(163.71,97.53) 163.64,97.6 163.64,102.55 v4(163.64,102.56) ; U34.N2 194.28,131.69 194.28,130.61 194.64,130.24 v4(194.64,129.85) ; PR540.2 149.9,105.5 150.48,104.91 v4(150.48,104.71)
VOLUME_DOWN#: length 7.1
  TOP w0.119: R124.2 6.96,123.48 D8.1 v14(6.91,125.53) 6.91,127.02 6.35,127.57 4.33,127.57 SW2.2
VOLUME_UP#: length 5.4
  TOP w0.119: D2.1 7.49,138.5 7.8,138.19 v14(7.8,137.53) ; D2.1 6.1,138.5 5.67,138.92 4.33,138.92 SW1.2 ; D2.1 6.73,138.47 R21.2
VR_ON: length 150.5
  TOP w0.119: R498.1 200.7,134.06 UH1.4 200.7,132.05 201.32,131.43 201.32,129.24 200.89,128.81 v14(199.72,128.81) 191.96,128.81 v1(191.31,128.16)
  IN1 w0.084: v1(191.31,128.16) 190.88,128.16 188.58,130.46 188.58,131.01 187.58,132.01 185.75,132.01 184.39,130.65 183.74,130.65 180.86,127.77 172.08,127.77 v2(171.89,127.59)
  IN3 w0.084: v7(92.61,106.09) 92.64,106.11 105.08,106.11 105.63,106.66 111.36,106.66 111.67,106.97 112.33,106.97 112.84,107.49 114.9,107.49 119.96,112.55 119.96,113.27 120.68,113.99 120.68,114.37 121.16,114.85 122.42,114.85 123.44,115.88 123.44,121.25 123.47,121.27 ; 123.47,121.27 125.45,121.27 127.1,122.92 127.1,124.48 128.42,125.8 128.42,126.84 129.08,127.5 v3(129.08,127.51) ; 123.47,121.27 120.85,121.27 v7(120.65,121.48) ; v3(171.89,128.08) v2(171.89,127.59)
  IN4 w0.089: v3(171.89,128.08) 171.89,130.57 168.55,133.91 155.02,133.91 153.69,132.58 151.18,132.58 150.42,131.82 149.81,131.82 149.13,132.5 147.47,132.5 147.04,132.06 145.6,132.06 145.09,131.55 145.09,130.23 144.89,130.03 143.6,130.03 142.34,128.77 141.41,128.77 141.06,128.42 141.04,128.42 140.41,127.8 131.24,127.8 131.21,127.78 129.46,127.78 129.2,127.51 v3(129.08,127.51)
  BOTTOM w0.119: v7(120.65,121.48) 120.22,121.48 119.94,121.76 PR1107.1 ; R412.1 89.66,108.29 89.75,108.2 UH5.1 90.75,107.36 90.8,107.3 91.35,107.3 91.64,107.02 91.64,105.86 91.86,105.64 92.23,105.64 92.61,106.02 v7(92.61,106.09)
VSET_1641: length 4.5
  IN4 w0.089: v5(189.32,136.24) 189.22,136.13 v4(187.2,136.13)
  BOTTOM w0.119: v4(187.2,136.13) 187.2,136.51 187.07,136.64 185.55,136.64 R335.1
WAKE#: length 6.1
  BOTTOM w0.076: UC1.BP9 62.51,124.66 61.73,125.45 59.15,125.45 58.54,126.05 58.03,126.05 57.38,125.39 RH74.2
WC_I2C_ALERT#: length 109.9
  IN4 w0.089: v4(133.04,97.74) 133.18,97.74 134.15,98.7 138.85,98.7 140.03,99.88 142.14,99.88 142.73,99.3 147.91,99.3 151.28,95.93 165.29,95.93 166.36,97 175.8,97 177.96,99.16 182.42,99.16 186.53,103.27 190.02,103.27 190.6,103.85 195.01,103.85 196.11,104.95 196.11,105.14 198.27,107.3 198.85,107.3 199.7,108.14 199.7,112.07 201.98,114.35 201.98,125.32 199.98,127.32 v4(199.19,127.32) 198.92,127.59 198.44,127.59 195.95,130.08 195.95,130.1 194.62,131.42 194.62,132.26 194.42,132.47 194.09,132.47 v4(193.82,132.74)
  BOTTOM w0.119: v4(199.19,127.32) 199.1,127.41 196.84,127.41 196.57,127.13 R369.1 ; JIO4.42 132.72,95.92 132.76,95.95 132.76,97.45 v4(133.04,97.74)
WF_HCLK: length 11.8
  TOP w0.119: v13(151.37,132.13) 151.12,131.88 C43.1 150.72,131.88 150.27,131.43 L25.1
  IN2 w0.079: v2(142.52,131.23) 145.38,131.23 145.54,131.07 147.97,131.07 148.7,131.8 151.04,131.8 v13(151.37,132.13)
  IN3 w0.084: v7(142.4,130.55) 142.4,131.11 v2(142.52,131.23)
WF_HCLK_R: length 33.4
  VCC w0.089: v21(126.88,129.54) 126.96,129.54 127.22,129.27 127.22,128.85 128.04,128.04 128.71,128.04 v9(128.96,127.78)
  IN1 w0.084: v1(124.03,129.48) 124.71,129.48 125.18,129.94 125.5,129.94 125.53,129.91 126.06,129.91 v2(126.39,129.58) 126.43,129.54 v21(126.88,129.54) ; v2(150.49,132.15) 150.03,132.15 v1(150,132.18)
  IN3 w0.084: v2(126.39,129.58) 126.61,129.36 126.68,129.36 126.85,129.2 v3(127.91,129.2) ; v2(150.49,132.15) v3(149.96,132.15)
  IN4 w0.089: v3(149.96,132.15) 149.03,133.07 145.96,133.07 145.7,133.33 139.4,133.33 137.81,131.74 137.44,131.74 136.85,131.14 134.5,131.14 134.28,130.92 133.76,130.92 133.18,130.34 133.18,130.13 132.67,129.62 130.52,129.62 130.47,129.57 128.28,129.57 v3(127.91,129.2)
WF_I2C_CLK: length 26.8
  VCC w0.089: v9(128.56,128.58) 128.13,129.02 v20(128.05,129.02)
  GND1 w0.084: v9(126.03,129.16) 126.03,129.35 125.88,129.51 v2(125.88,129.53)
  IN1 w0.084: v2(125.88,129.53) 125.88,129.51 126.15,129.23 126.74,129.23 126.95,129.02 v20(128.05,129.02)
  IN3 w0.084: v2(125.88,129.53) 125.88,129.53 126.69,128.72 128.32,128.72 v3(129.16,127.88)
  IN4 w0.089: v7(143.41,132.86) 143.26,132.71 143.26,130.11 142.1,128.96 141.33,128.96 140.98,128.61 140.96,128.61 140.36,128.02 131.19,128.02 131.14,127.97 129.25,127.97 v3(129.16,127.88)
  BOTTOM w0.119: v7(143.41,132.86) 143.41,133.16 143.3,133.26 JWFC.33
WF_I2C_DATA: length 23.9
  VCC w0.089: v20(126.66,128.95) 126.79,128.81 126.85,128.81 127.88,127.78 v9(128.56,127.78)
  GND1 w0.084: v9(125.48,129.16) 125.32,129.31 125.32,129.54 v2(125.37,129.59)
  IN1 w0.084: v2(125.37,129.59) 125.51,129.46 125.51,129.41 126.05,128.87 126.58,128.87 v20(126.66,128.95)
  IN3 w0.084: v3(125.6,129.2) 125.55,129.25 125.55,129.41 v2(125.37,129.59)
  IN4 w0.089: v4(140.77,129.96) 140.11,129.96 139.81,129.66 133.9,129.66 133.05,128.82 130.86,128.82 130.8,128.77 128.74,128.77 128.26,128.29 127.52,128.29 126.85,128.95 125.85,128.95 v3(125.6,129.2)
  BOTTOM w0.119: v4(140.77,129.96) 142.72,129.96 143,130.24 143,130.55 JWFC.32
WF_SENSOR_RST#: length 12.2
  TOP w0.119: v14(148.23,129.97) 147.85,130.36 147.85,131.48 v13(147.85,131.48) 147.85,131.48 147.84,131.49 R44.1 147.87,132.22 148.49,132.22 R42.2 R49.2
  BOTTOM w0.119: JWFC.27 141.5,133.52 141.88,133.14 142.58,133.14 143.15,132.57 143.92,132.57 144.41,133.06 146.27,133.06 v13(147.85,131.48)
WF_SENSOR_RST#_R: length 20.6
  TOP w0.119: v1(145.28,131.87) 146.58,131.87 146.91,132.2 R44.2
  IN1 w0.084: v1(129.36,128.18) 129.43,128.11 130.38,128.11 130.5,128.23 132.99,128.23 134.73,129.97 136.4,129.97 139.84,133.41 143.48,133.41 144.66,132.23 144.66,132.14 144.93,131.87 v1(145.28,131.87)
WIN7_DEBUG#: length 106.8
  TOP w0.119: v1(23.71,61.86) 22.82,62.75 22.82,63.48 22.64,63.65 U29.9
  IN1 w0.084: v1(23.71,61.86) 23.22,61.37 23.22,60.35 23.76,59.81 28.62,59.81 29.17,60.37 32.92,60.37 34.94,58.35 35.8,58.35 v2(35.81,58.36)
  IN3 w0.06: v3(56.31,118.3) 56.77,117.85 59.53,117.85 59.75,117.63 59.75,117.39 59.83,117.31 60.37,117.31 60.5,117.18 60.55,117.13 62.24,117.13 62.3,117.07 62.7,117.07 62.93,117.3 v10(63.1,117.3)
  IN3 w0.084: v2(35.81,58.36) 42.94,58.36 44.25,59.67 44.25,69.99 44.69,70.43 44.69,80.66 42.63,82.71 42.63,89.64 42.68,89.69 42.68,93.59 42.89,93.79 42.89,95.24 41.89,96.23 41.89,96.69 41.89,110.36 v3(42.1,110.58)
  IN4 w0.06: v3(56.31,118.3) 56.11,118.51 55.98,118.51 55.73,118.25 54.53,118.25 54.52,118.24 54.21,118.24 53.93,117.96 53.63,117.96 53.57,117.9 53.16,117.9
  IN4 w0.089: 53.16,117.9 52.06,117.9 51.8,117.64 48.34,117.64 47.7,116.99 46.66,116.99 46.42,116.75 45.36,116.75 43.55,114.94 43.55,111.46 42.67,110.58 v3(42.1,110.58)
WL_OFF#_R: length 27.3
  TOP w0.119: R101.1 44.31,126.41 D5.1 42.66,127.09 42.2,127.55 41.47,127.55 v1(41.35,127.66)
  IN1 w0.084: v2(46.86,147.64) 46.86,145.89 43.98,143.01 43.98,142.24 43.83,142.09 43.48,142.09 41.75,140.36 41.75,134.54 42.05,134.24 42.05,134.01 41.96,133.92 41.96,132.24 41.96,132.24 41.96,130.48 41.96,130.29 41.96,130.29 41.96,129.05 41.45,128.54 41.45,127.76 v1(41.35,127.66)
  IN3 w0.084: v2(46.86,147.64) v7(47.21,147.64)
WLAN_EN: length 4.1
  TOP w0.119: U3.3 48.55,135.1 R34.2 48.83,134.85 49.2,134.48 51.13,134.48 D4.1
WLAN_ON: length 33.4
  TOP w0.119: D5.3 41.61,125.76 42,125.36 43.37,125.36 43.51,125.22 v1(43.51,123.15)
  IN1 w0.084: v2(42.87,119.58) 42.9,119.61 42.9,121.27 43.15,121.53 43.15,122.3 43.51,122.66 v1(43.51,123.15)
  IN3 w0.084: v3(42.9,119.98) 42.9,119.61 v2(42.87,119.58)
  IN4 w0.06: v5(60.25,121.18) 60.18,121.18 59.96,120.96 55.88,120.96 55.85,120.99 54.55,120.99 54.49,121.05
  IN4 w0.089: v3(42.9,119.98) 42.9,120.13 44.4,121.63 46.4,121.63 47.04,122.28 47.99,122.28 48.26,122.54 48.26,123.99 47.99,124.26 47.99,124.64 48.3,124.95 49.69,124.95 50.04,124.6 50.04,123.59 50.64,122.98 52.04,122.98 53.23,121.8 53.74,121.8 54.49,121.05
  BOTTOM w0.06: UC1.BB2 60.7,121.48 60.64,121.43 60.5,121.43 v5(60.25,121.18)
WLAN_PWR_EN: length 6.1
  IN3 w0.06: v7(57.61,122.95) 57.96,122.6 59.28,122.6 59.95,121.93 60.17,121.93 60.17,121.93 60.52,121.93 60.95,121.49 61.85,121.49 62.43,120.92 62.64,120.92 62.72,120.84 v10(62.85,120.84)
WLAN_RST#: length 36.7
  TOP w0.119: U8.2 48.55,127.55 48.35,127.35 48.35,126.51 48.96,125.9 v14(48.96,125.86) 50.08,124.74 51.21,124.74 51.37,124.58 51.37,124.06 v1(51.51,123.92)
  IN1 w0.084: v2(62.2,110.61) 62.01,110.61 61.62,111 60.77,111 58.17,113.6 57.29,113.6 56.46,114.43 56.46,115.45 56.21,115.7 56.21,116.08 54.39,117.9 53.21,117.9 53,118.11 53,118.42 53.59,119.01 54.33,119.01 54.46,119.14 54.46,120.16 53.74,120.88 53.74,121.94 52.84,122.83 52.52,122.83 51.51,123.84 v1(51.51,123.92)
  IN3 w0.06: v2(62.2,110.61) 62.09,110.72 v10(61.9,110.72)
  IN4 w0.06: v10(61.9,110.72) 61.8,110.72 61.59,110.51 61.48,110.51 61.45,110.49 61.39,110.49 61.27,110.38 61.27,110.31 61.21,110.24 61.21,109.94 59.88,108.62 59.88,107.03 60.19,106.72 60.19,105.46 60.09,105.37 60.09,104.16 v4(60.19,104.06)
  BOTTOM w0.119: RC87.2 59.82,104.43 v4(60.19,104.06)
WLAN_RST#_Q: length 31.9
  TOP w0.119: v1(48.89,128.72) 49.12,128.95 R67.1 49.3,129.34 49.81,128.83 49.81,128.7 50.19,128.32 50.19,127.99 50.53,127.64 50.74,127.64 51.03,127.35 U8.4 ; v1(46.4,147.02) v14(47.02,147.02)
  IN1 w0.084: v2(45.54,145.27) 45.58,145.27 46.4,146.08 v1(46.4,147.02) ; v1(48.89,128.72) 48.89,128.54 48.51,128.16 v2(48.16,128.16)
  IN3 w0.084: v7(45.54,146.17) v2(45.54,145.27) 45.54,143.27 44.71,142.43 44.71,140.48 44.16,139.94 44.16,137.8 43.92,137.55 43.92,133.77 43.27,133.13 43.27,131.35 45.44,129.18 45.44,129.18 46.46,128.16 v2(48.16,128.16)
  BOTTOM w0.119: v7(45.54,146.17) 45.54,146.29 45.89,146.64 JNGFF3.52
WLAN_WIGIG60GHZ_DIS#: length 249
  TOP w0.119: v1(199.54,109.77) 199.55,109.77 202.67,106.65 202.67,104.29 204.41,102.56 204.41,100.95 205,100.36 205,99.99 v1(204.79,99.78) ; v1(40.64,128.08) 40.81,127.91 D5.2
  IN1 w0.084: v1(40.64,128.08) 40.51,127.95 40.51,117.03 42.16,115.39 42.16,109.77 41.66,109.27 41.66,102.68 42.9,101.44 42.9,100.34 42.17,99.61 42.17,98.93 43.58,97.52 46.76,97.52 47.82,98.58 50.47,98.58 51.41,97.64 53.96,97.64 55.77,95.82 58.24,95.82 59.36,94.7 60.6,94.7 60.76,94.54 60.99,94.54 61.69,93.84 78.12,93.84 78.66,94.37 81.49,94.37 82.14,95.02 82.14,95.24 84,97.1 85.74,97.1 86.12,97.48 102.07,97.48 103.41,96.14 117.3,96.14 118.42,97.26 118.74,97.26 118.94,97.06 118.94,97.02 119.34,96.62 119.63,96.62 120.22,97.22 122.47,97.22 122.47,97.22 122.93,97.22 122.93,97.22 132.13,97.22 132.49,97.58 134.79,97.58 135.34,97.02 137.32,97.02 138.83,95.51 174.38,95.51 175.52,96.66 178.95,96.66 180.62,98.33 198.2,98.33 198.89,99.02 203.82,99.02 204.57,99.78 v1(204.79,99.78) ; v1(199.54,109.77) 198.12,109.77 195.93,111.96 195.93,112.38 195.92,112.38 v2(195.92,112.41)
  IN3 w0.084: v2(195.92,112.41) 195.92,112.2 v3(195.72,111.99)
  IN4 w0.089: v3(195.72,111.99) 195.8,112.07 195.8,113.46 197.66,115.32 197.66,117.75 197.39,118.02 197.39,122.92 194.36,125.95 193.42,125.95 192.31,127.06 190.69,127.06 189.65,128.09 189.53,128.09 187.88,129.73 187.88,130.14 188.18,130.43 188.41,130.43 188.57,130.59 188.57,130.99 189.66,132.07 v4(189.82,132.24)
WWAN_EN: length 4.2
  TOP w0.119: U12.3 205.17,126.22 204.98,126.41 R105.2 204.62,126.34 204.62,126.18 204.14,125.69 203.78,125.69 202.83,124.74 D6.1
WWAN_OFF#: length 219
  TOP w0.119: v1(208.99,137.07) 209.05,137.07 209.98,136.14 209.98,134.79 209.82,134.62 Q4.1
  IN1 w0.084: v1(48.21,116.49) 48.03,116.66 v2(48.03,117.34) 48.03,117.8 47.37,118.45 47.37,121.29 47.59,121.5 48.51,121.5 49.89,122.89 49.89,124.46 51.84,126.4 52.59,126.4 52.9,126.09 53.77,126.09 55.4,127.73 56.86,127.73 57.01,127.88 58.14,127.88 59.9,129.64 60.83,129.64 62.93,131.74 63.9,131.74 63.95,131.79 64.33,131.79 64.56,131.56 65.21,131.56 65.41,131.76 71.57,131.76 71.75,131.58 72.5,131.58 73.27,130.81 74.8,130.81 75.73,131.74 76.89,131.74 77.46,132.31 85.78,132.31 87.33,133.86 99.35,133.86 99.72,134.23 106.18,134.23 106.32,134.09 109.58,134.09 112.73,130.94 112.73,130.68 113.14,130.27 116.31,130.27 117.32,129.25 117.32,128.48 117.65,128.15 118.48,128.15 119.46,127.18 122.32,127.18 123.01,126.49 127.04,126.49 127.9,125.63 130.39,125.63 131.77,127.01 132.72,127.01 135.04,129.32 136.67,129.32 137.85,130.5 139.89,130.5 140.15,130.76 142.87,130.76 143.47,131.36 145.17,131.36 145.81,132 148.01,134.19 167.63,134.19 172.38,129.45 178.13,129.45 179.38,130.7 180.12,130.7 180.59,131.17 180.59,132.61 181.94,133.96 181.94,135.11 184.11,137.28 184.9,137.28 185.36,137.74 185.36,138.79 186.96,140.39 188.15,140.39 191.23,143.46 194.44,143.46 196.85,145.87 202.58,145.87 203.11,145.33 204.18,145.33 207.42,142.09 208.61,142.09 209.08,141.63 209.08,140.34 208.99,140.25 v1(208.99,137.07)
  IN3 w0.084: v2(48.03,117.34) 48.03,116.94 v3(48.01,116.92)
  IN4 w0.06: v5(62.36,116.97) 62.22,116.97 62.07,117.13 62.07,117.7 61.71,118.06 61.13,118.06 61.09,118.1 57.81,118.1 57.66,118.25 57.19,118.25 56.67,117.74 56.04,117.74 55.74,117.44
  IN4 w0.089: 55.74,117.44 53.6,117.44 53.32,117.71 52.14,117.71 51.88,117.45 48.55,117.45 48.16,117.06 48.15,117.06 v3(48.01,116.92)
WWAN_OFF#_R: length 15.1
  TOP w0.119: Q4.6 211.41,134.93 211.06,135.28 R27.2 211.06,136.07 209.81,137.33 209.81,140.05 v1(210.38,140.62)
  IN1 w0.084: v1(210.38,140.62) 209.84,141.15 209.84,142.66 208.99,143.51 v2(208.99,146.15)
  IN3 w0.084: v2(208.99,146.15) 208.89,146.26 v7(208.89,146.52)
  BOTTOM w0.119: JNGFF1.8 208.95,146.46 v7(208.89,146.52)
WWAN_PWR_OFF#: length 199.1
  TOP w0.119: R7.2 209.45,140.94 209.45,136.99 210.71,135.73 210.71,134.7 v1(210.76,134.65)
  IN1 w0.084: v1(210.76,134.65) 210.95,134.46 210.95,130.29 212.21,129.03 212.21,126.03 212,125.83 207.79,125.83 207.09,126.54 206.7,126.54 206.12,127.12 206.12,127.19 205.27,128.05 199.36,128.05 198.8,127.49 184.99,127.49 181.05,123.55 173.81,123.55 171.61,121.35 167.55,121.35 163.34,125.56 153.96,125.56 152.52,127 152.52,128.17 151.87,128.82 150.85,128.82 149.82,127.8 149.04,127.8 148.23,127 148.23,125.19 146.9,123.85 143.79,123.85 141.09,121.16 136.23,121.16 135.5,120.43 135.5,119.48 134.25,118.23 130.16,118.23 129.73,118.65 126.79,118.65 126.14,119.3 124.17,119.3 123.63,118.76 121.86,118.76 119.35,116.26 117.65,116.26 117.28,115.88 116.23,115.88 115.51,116.6 115.51,117.21 115.06,117.66 113.94,117.66 111.55,120.05 111.55,124.4 110.4,125.55 110.06,125.55 109.19,126.42 103.12,126.42 103.01,126.53 99.69,126.53 98.95,125.79 98.95,125.79 97.91,124.75 96.42,124.75 95.62,123.95 95.62,123.25 94.67,122.3 92.7,122.3 92.57,122.43 85.96,122.43 85.61,122.79 81.86,122.79 81.48,122.41 79.89,122.41 79.58,122.71 77.38,122.71 76.41,123.68 66.13,123.68 63.25,120.8 63.25,120.13 v2(60.83,117.72)
  IN3 w0.06: v2(60.83,117.72) 61.1,117.72 61.15,117.77 61.49,117.77 61.49,117.77 61.57,117.77 61.58,117.77 62.02,117.77 62.19,117.94 62.56,117.94 62.67,118.06 63.03,118.06 63.1,118.13 v10(63.1,118.58)
WWAN_PWR_OFF#_R: length 8.3
  TOP w0.119: C8.1 209.96,141.59 R7.1 209.37,142.31 v1(209.49,142.42)
  IN1 w0.084: v2(208.43,146.17) 208.43,143.56 209.49,142.51 v1(209.49,142.42)
  IN3 w0.084: v7(208.43,146.52) v2(208.43,146.17)
  BOTTOM w0.119: v7(208.43,146.52) 208.87,146.96 JNGFF1.6
WWAN_RST#: length 259.9
  TOP w0.119: v1(209.19,136.23) 207.33,136.23 206.35,135.24 R29.1
  IN1 w0.084: v2(48.42,103.49) 48.74,103.17 48.74,102.57 49.47,101.84 50.67,101.84 53.07,99.43 54.7,99.43 56.16,97.97 61.1,97.97 62.3,96.78 63.48,96.78 64.45,95.81 76.93,95.81 77.82,96.7 81.07,96.7 83.27,98.9 84.71,98.9 85.78,99.97 86.97,99.97 87.67,99.27 93.02,99.27 93.73,99.99 96.99,99.99 97.21,99.77 98.31,99.77 98.6,99.48 102.69,99.48 103.75,98.41 104.46,98.41 105.44,97.44 114.51,97.44 115.68,98.61 135.08,98.61 135.73,97.95 137.7,97.95 139.22,96.44 159.1,96.44 159.65,96.99 160.71,96.99 161.26,96.44 169.83,96.44 170.72,97.34 174.49,97.34 174.83,97.67 178.18,97.67 179.2,98.7 179.2,99.07 181.52,101.39 187.12,101.39 188.47,100.04 190.13,100.04 190.9,100.81 192.87,100.81 193.57,101.51 196.21,101.51 197.18,100.54 202.88,100.54 203.48,101.14 205.98,101.14 206.07,101.05 206.45,101.05 206.73,101.33 211.61,101.33 v2(212.42,102.13)
  IN1 w0.109: v2(209.52,139.74) 209.47,139.68 209.47,136.5 v1(209.19,136.23)
  IN2 w0.079: v2(209.52,139.74) 213.03,139.74 219.5,133.27 219.5,120.18 219.14,119.82 219.14,116.9 219.14,116.3 219.58,115.85 219.58,105.43 218.9,104.75 218.9,104.2 216.94,102.24 212.52,102.24 v2(212.42,102.13)
  IN3 w0.06: 56.18,114.68 56.36,114.68 56.53,114.85 58.03,114.85 58.82,115.64 60.47,115.64 60.76,115.92 61.86,115.92 62.09,115.69 v10(62.36,115.69)
  IN3 w0.084: 56.18,114.68 55.91,114.68 55.71,114.89 54.55,114.89 54.21,115.22 53.17,115.22 52.36,114.41 51.85,114.41 51.35,113.9 50.93,113.9 50.82,113.79 50.28,113.79 49.63,113.15 49.63,113.01 48.91,112.29 48.91,111.91 47.79,110.79 47.79,110.39 48.34,109.84 48.34,106.96 47.78,106.4 47.78,105.7 48.79,104.68 48.79,103.96 v7(48.63,103.8) 48.63,103.7 v2(48.42,103.49)
WWAN_RST#_Q: length 3.6
  TOP w0.119: Q5.1 206.13,131.71 206.07,131.78 R52.2 203.85,131.78 v1(203.68,131.61)
  IN1 w0.109: v2(203.3,131.61) v1(203.68,131.61)
  IN3 w0.084: v2(203.3,131.61) 203.3,131.62 203.05,131.62 v7(202.96,131.71)
WWAN_WAKE#: length 0.8
  IN1 w0.084: v1(203.58,143.14) 203.51,143.14 203.32,142.95 v2(203.32,142.92)
  IN3 w0.084: v2(203.32,142.92) 203.11,142.71 v7(202.96,142.71)
XCLK_BIASREF: length 4.3
  BOTTOM w0.119: UC1.P1 60.26,112.79 58.9,111.42 58.55,111.42 58.23,111.74 57.36,111.74 RH103.1
XDP_BPM#0: length 25.3
  IN3 w0.06: v10(75.72,111.18) 75.7,111.16 75.7,110.94 75.65,110.89 75.63,110.89 75.52,110.77 75.52,110.76 75.52,110.76 75.52,109.57 76.4,108.69 76.4,107.94 76.52,107.83 76.92,107.83 76.99,107.75 78.39,107.75 79.1,107.04 80.44,107.04 80.73,107.33 81.18,107.33 81.28,107.43
  IN3 w0.084: 81.28,107.43 81.51,107.66 85.17,107.66 85.29,107.54 85.29,107.37 85.17,107.25 81.53,107.25 81.45,107.17 v3(81.45,107.18)
  IN4 w0.089: v4(82.76,102.72) 82.75,102.73 82.75,103.14 82.91,103.3 82.91,103.49 82.75,103.65 82.75,104.31 82.76,104.33 82.88,104.33 82.98,104.43 82.98,104.58 82.88,104.68 82.76,104.68 82.67,104.77 82.67,104.95 82.76,105.04 82.88,105.04 82.98,105.14 82.98,105.29 82.88,105.39 82.76,105.39 82.67,105.48 82.67,105.93 81.8,106.81 81.45,107.15 v3(81.45,107.18)
  BOTTOM w0.119: v4(82.76,102.72) 82.25,102.72 82.16,102.63 82.16,101.79 81.89,101.51 RC126.1
XDP_BPM#1: length 25.6
  IN3 w0.06: 81.52,106.65 79.15,106.65 78.29,107.51 76.89,107.51 76.88,107.52 76.82,107.59 76.42,107.59 76.15,107.85 76.15,108.6 75.2,109.55 75.2,111.02 75.4,111.22 v10(75.4,111.43)
  IN3 w0.084: 81.52,106.65 83.75,106.65 83.85,106.75 83.85,106.91 83.76,107 81.69,107 81.61,106.92 81.2,106.92 v3(81.08,107.05)
  IN4 w0.06: 81.33,106.77 81.08,107.03 v3(81.08,107.05)
  IN4 w0.089: 81.33,106.77 81.46,106.64 81.46,106.62 82.33,105.75 82.33,104.5 82.4,104.42 82.4,102.58 82.65,102.33 v4(82.75,102.33)
  BOTTOM w0.119: v4(82.75,102.33) 83.38,102.33 83.69,102.02 83.69,100.43 83.53,100.27 83.23,100.27 83.16,100.35 83.16,101.06 82.91,101.31 82.49,101.31 RC125.1
XDP_BPM#2: length 13.2
  IN3 w0.06: v7(85.67,107.96) 85.36,108.27 81.52,108.27 81.48,108.22 81.38,108.22 80.92,107.77 80.57,107.77 80.32,107.52 79.46,107.52 78.84,108.14 77.12,108.14 76.66,108.6 76.66,108.76 76.47,108.96 76.47,109.25 75.8,109.92 75.8,110.61 v10(75.72,110.69)
  BOTTOM w0.119: TC50.1 86.03,108.42 85.67,108.06 v7(85.67,107.96)
XDP_BPM#3: length 9.5
  IN3 w0.06: v10(75.4,110.94) 75.4,109.52 76.28,108.64 76.28,107.9 76.47,107.71 76.87,107.71 76.94,107.63 78.34,107.63 79.05,106.92 80.63,106.92 v7(80.66,106.88)
  BOTTOM w0.119: TC64.1 81.14,106.88 v7(80.66,106.88)
XDP_DBRESET#: length 6.3
  TOP w0.119: RC34.2 CC90.1 89.99,100.66 90.36,100.3 v1(90.36,100.3)
  IN1 w0.084: v2(90.03,100.08) 90.24,100.3 v1(90.36,100.3)
  IN3 w0.084: v3(90.3,99.9) 90.16,99.9 90.03,100.03 v2(90.03,100.08)
  IN4 w0.089: v4(89.94,98.34) 89.94,99.54 v3(90.3,99.9)
  BOTTOM w0.119: JXDP1.48 v4(89.94,98.34)
XDP_HOOK3: length 64.3
  IN1 w0.084: v2(89.18,100.09) 89.07,99.99 87.67,99.99 87.21,100.45 85.6,100.45 84.52,99.36 83.07,99.36 80.88,97.17 77.63,97.17 76.75,96.28 64.67,96.28 63.61,97.34 62.51,97.34 61.3,98.54 56.25,98.54 54.89,99.9 53.27,99.9 50.86,102.3 49.66,102.3 49.2,102.76 49.2,105.34 48.98,105.57 48.98,106.12 47.48,107.62 47.48,110.19 47.42,110.25 47.42,112.46 v2(47.07,112.82)
  IN3 w0.084: v2(89.18,100.09) 89.31,99.97 v7(89.52,99.97) ; v2(47.07,112.82) v7(47.07,113.15)
  BOTTOM w0.119: v7(47.07,113.15) 46.72,113.49 46.72,116.59 47.13,116.99 RC49.2 ; JXDP1.47 89.64,99.85 v7(89.52,99.97) 89.52,99.97 89.52,100.31 90.22,101.01 RC114.2
XDP_OBS0: length 1.6
  BOTTOM w0.119: RC126.2 81.84,100.67 JXDP1.21
XDP_OBS1: length 1.6
  BOTTOM w0.119: JXDP1.23 82.44,100.68 RC125.2
XDP_PIN1: length 21.3
  IN3 w0.06: v7(86.57,107.23) 86.57,107.31 86.26,107.62 85.48,107.62 85.17,107.93 81.47,107.93 81.02,107.49 80.72,107.49 80.39,107.16 79.17,107.16 78.46,107.87 77.04,107.87 76.87,108.04 v3(76.62,108.04)
  IN4 w0.06: v3(76.62,108.04) 76.62,107.78 76.86,107.54 76.86,105.89 77.46,105.29 77.46,104.77 77.44,104.76
  IN4 w0.089: 77.44,104.76 77.44,103.65 76.94,103.14 76.94,102.91 76.31,102.28 76.31,100.5 v4(75.95,100.14)
  BOTTOM w0.119: RC63.2 86.53,107.27 v7(86.57,107.23) ; JXDP1.1 75.84,100.04 v4(75.95,100.14)
XDP_PRDY#: length 12.8
  IN4 w0.06: v5(75.72,110.2) 75.79,110.12 75.79,109.92 75.96,109.75 76.03,109.75 76.24,109.54 76.24,109.19 77.48,107.95 77.48,106.39 77.82,106.06 77.82,104.94 78.18,104.58 78.18,103.58 77.97,103.37 77.97,103.04
  IN4 w0.089: 77.97,103.04 77.97,100.95 v4(77.88,100.85)
  BOTTOM w0.119: JXDP1.5 77.04,100.35 T36.1 77.55,100.85 v4(77.88,100.85)
XDP_PREQ#: length 15.2
  IN4 w0.06: 79.23,103.04 79.23,103.54 79.32,103.63 79.32,103.91 78.99,104.24 78.99,107.16 78.25,107.91 78.25,108.99 77.61,109.63 77.07,109.63 v5(77,109.7)
  IN4 w0.089: v4(79.22,101.06) 79.23,101.06 79.23,103.04
  BOTTOM w0.119: JXDP1.3 76.44,100.51 T37.1 ; T37.1 76.38,100.85 RC123.2 ; T37.1 77.07,101.14 78.45,101.14 78.54,101.06 v4(79.22,101.06)
XDP_PRSENT: length 35.3
  TOP w0.119: v1(74.22,102.61) 74.05,102.44 74.05,101.79 73.95,101.69 U24.2 ; v1(95.66,101.67) 95.44,101.89 83.44,101.89 81.53,103.8 v14(79.51,103.8) 78.69,103.8 78.4,103.51 v1(78.4,103.42) 78.47,103.34 78.54,103.34 78.97,102.91 U23.2
  IN1 w0.084: v1(74.22,102.61) 74.59,102.61 74.99,102.2 76.18,102.2 77.35,103.37 78.37,103.37 78.4,103.39 v1(78.4,103.42) ; v2(95.53,102.12) 95.66,101.99 v1(95.66,101.67)
  IN3 w0.084: v2(95.53,102.12) 95.55,102.1 v7(96.19,102.1)
  BOTTOM w0.119: U44.4 93.2,107.42 93.45,107.18 95.33,107.18 95.55,106.95 95.55,105.26 96.19,104.63 v7(96.19,102.1)
XDP_PRSENT#: length 110
  TOP w0.119: RC13.2 44.65,122.1 44.49,121.94 43.03,121.94 42.25,121.16 42.25,119.29 40.72,117.76 v14(40.72,117.17) v1(40.72,116.14)
  IN1 w0.084: v2(40.97,97.88) 40.97,98.94 42.56,100.53 42.56,101.3 40.75,103.11 40.75,108.84 41.82,109.91 41.82,115.25 40.92,116.14 v1(40.72,116.14)
  IN2 w0.079: v2(41.53,90.21) 41.97,90.21 42.86,91.1 44.91,91.1 45.05,90.96 80.05,90.96 82.82,93.73 82.82,96.53 85.45,99.16 88.15,99.16 88.26,99.28 94.8,99.28 v2(94.96,99.44)
  IN3 w0.084: v2(40.97,97.88) 41.12,97.73 41.12,95.21 41.97,94.36 41.97,91.2 41.53,90.75 v2(41.53,90.21) ; v2(94.96,99.44) v7(95.59,99.44)
  BOTTOM w0.119: U44.2 93.85,105.97 95.68,104.14 RC107.2 95.68,102.47 95.47,102.25 95.47,100.45 95.59,100.32 v7(95.59,99.44) 95.59,97.36 94.1,95.87 JXDP1.60
XDP_PWRBTN#: length 2.9
  BOTTOM w0.119: RC121.2 CC123.1 87.69,99.98 87.84,99.83 JXDP1.41
XDP_RST#: length 17.2
  IN4 w0.089: v4(88.72,105.48) 88.99,105.21 88.99,103.53 88.52,103.06 88.52,101.55 88.99,101.08 88.99,98.72 v4(89.34,98.36)
  BOTTOM w0.119: v4(88.72,105.48) 88.71,105.47 83.8,105.47 83.1,106.16 RC77.2 82.77,106.16 RC75.2 ; JXDP1.46 v4(89.34,98.36)
XDP_TCK0: length 28.1
  IN4 w0.089: v4(77.34,102.26) 77.58,102.03 77.58,99.55 77.37,99.34 77.37,98.27 78.57,97.07 80.05,97.07 80.35,97.37 85.32,97.37 85.83,97.88 91.73,97.88 91.85,98.01 v4(92.12,98.01)
  BOTTOM w0.119: RC92.2 74.47,104.73 RC86.2 73.38,104.45 73.38,103.67 73.76,103.29 74.46,103.29 75.15,102.61 77,102.61 v4(77.34,102.26) ; JXDP1.57 92.64,98.53 v4(92.12,98.01)
XDP_TCK1: length 3.3
  BOTTOM w0.119: JXDP1.55 92.04,99.79 92.71,100.45 RC111.2
XDP_TDI: length 9.9
  BOTTOM w0.119: RC110.2 RC109.2 94.27,102.14 94.79,101.62 94.79,100.44 95.2,100.03 95.2,97.61 94.41,96.81 92.57,96.81 92.34,96.59 JXDP1.56
XDP_TDO: length 7.3
  IN4 w0.089: v4(91.72,98.34) 90.93,99.13 v4(90.93,100.45)
  BOTTOM w0.119: RC115.2 RC116.2 v4(90.93,100.45) ; v4(91.72,98.34) 91.52,98.34 91.14,97.96 91.14,97.5 JXDP1.52
XDP_TMS: length 27.7
  IN4 w0.06: 78.21,103.05 78.21,103.09 v4(78.26,103.14)
  IN4 w0.089: 78.21,103.05 78.21,99.28 77.83,98.9 77.83,98.23 v4(77.86,98.19)
  BOTTOM w0.119: RC105.2 RC106.2 ; v4(77.86,98.19) 77.41,98.19 75.67,96.45 75.67,95.39 75.86,95.2 92.75,95.2 92.94,95.4 JXDP1.58
XDP_TRST#: length 29.9
  IN4 w0.089: v4(94.64,99.99) 91.62,99.99 91.27,100.33 91.27,100.59 91.07,100.79 91.07,100.79 89.43,102.43 89.43,105.56 89.17,105.82 88.58,105.82 88.39,105.63 88.39,104.01 87.91,103.53 v4(87.91,103.33)
  BOTTOM w0.119: v4(94.64,99.99) 94.83,99.8 94.83,97.77 94.31,97.25 92.45,97.25 91.74,96.54 JXDP1.54 ; RC101.2 78.32,103.86 78.55,104.1 78.6,104.1 78.64,104.13 79.22,104.13 79.57,103.79 RC100.2 79.81,103.53 80.48,103.53 80.52,103.56 82.45,103.56 82.58,103.44 87.76,103.44 87.87,103.33 v4(87.91,103.33)
XTAL24_IN: length 7.6
  BOTTOM w0.112: UC1.M1 60.31,112.14 58.47,110.3 57.71,110.3 57.4,110.61 RH104.2 57.38,110.58 CH14.1
  BOTTOM w0.119: YH2.3 55.26,109.07 55.5,108.82 55.8,108.82 56.03,109.05 56.03,109.23 CH14.1
XTAL24_OUT: length 9.2
  BOTTOM w0.112: UC1.L2 60.29,111.82 58.52,110.05 57.73,110.05 RH104.1 57.09,109.4 57.06,109.4 CH15.1
  BOTTOM w0.119: YH2.1 53.56,107.33 54.39,108.16 55.82,108.16 CH15.1
N1728290: length 25.6
  TOP w0.254: v13(103.05,108.65) 103.62,109.22 PL1102.1
  IN4 w0.254: v13(103.05,108.65) 103.23,108.47 106.4,108.47 106.78,108.09 111.75,108.09 114.9,111.24 114.9,112.44 114.93,112.47 115.92,113.46 116.34,113.46 117.97,115.09 117.97,118.48 v4(117.7,118.75)
  BOTTOM w0.254: v4(117.7,118.75) 118.23,118.75 118.93,119.45 PR1154.1
N1728978:
  vias: v1(108.55,108.49) v1(108.55,108.14) v1(109.52,110.89) v1(109.52,110.54)
N1925285: length 3.9
  TOP w0.254: v1(114.68,116.34) 114.75,116.27 115.54,116.27 PR1131.1 116.43,116.29 PR1132.1
  IN1 w0.254: v2(114.83,116.84) 114.68,116.69 v1(114.68,116.34)
  IN3 w0.254: v7(114.33,118.2) 114.83,117.69 v2(114.83,116.84)
N16335894: length 1.8
  BOTTOM w0.203: PU500.17 138.51,112.34 138.04,111.87 PC540.1
  vias: v1(138.38,111.83) v1(138.63,112.03) v2(138.02,111.52) v7(137.76,111.74) v7(138,111.85)
N16335926: length 4.5
  BOTTOM w0.203: PC523.1 144.36,113.54 PU500.2
  BOTTOM w0.305: PC523.1 144.97,112.91 145.91,111.97 PC525.2 146.81,112.8 PR501.2
N16335934: length 3.2
  BOTTOM w0.203: PC523.2 144.87,113.94 PU500.1
  BOTTOM w0.305: PC523.2 145.88,113.85 PC524.1 146.75,113.88 PR502.2
N16336052:
  vias: v1(144.6,112.35) v1(144.75,112.59) v2(145.08,112.05) v7(144.17,112.49) v7(144.45,112.49)
N16336068: length 4.7
  TOP w0.119: PC534.1 142.38,109.51 143,108.89 v1(143,108.8) 143.05,108.8 143.45,108.41 PR517.2
  IN1 w0.084: v1(143,108.8) v2(142.65,108.8)
  IN3 w0.084: v2(142.65,108.8) 142.65,109.06 142.76,109.17 142.76,109.18 v7(142.87,109.29)
  BOTTOM w0.119: PU500.8 142.75,110.22 142.87,110.1 v7(142.87,109.29)
N16336072: length 5.7
  TOP w0.119: v1(142.72,110.96) 142.44,110.96 142.32,110.84 PC533.1 143.48,109.29 PR513.2
  IN1 w0.084: v2(143.08,110.96) v1(142.72,110.96)
  IN3 w0.084: v7(143.46,110.96) v2(143.08,110.96)
  BOTTOM w0.119: v7(143.46,110.96) 144.04,110.96 144.22,111.14 144.22,111.45 144.13,111.54 PU500.7
N16336110: length 5.4
  TOP w0.119: v1(141.86,109.08) 141.86,109.06 PR525.1 142.67,108.6 143.74,107.53 PR522.2
  IN1 w0.084: v1(141.86,109.08) v2(142.11,108.83)
  IN3 w0.084: v7(142.49,109.29) 142.11,108.91 v2(142.11,108.83)
  BOTTOM w0.119: PU500.9 142.35,110.01 142.49,109.87 v7(142.49,109.29)
N16336166: length 1.3
  BOTTOM w0.119: PR521.2 141.95,109.39 PU500.10
N16336190: length 2.8
  BOTTOM w0.119: PU500.15 139.06,111.54 138.91,111.39 138.91,110.81 139.19,110.53 PR531.2
N16336228: length 1.4
  BOTTOM w0.203: PR526.1 138.18,112.74 PU500.18
N16336338: length 8.6
  BOTTOM w0.203: PR506.2 145.47,109.54 145.47,111.25 PC528.2 144.77,111.94 PU500.6
  BOTTOM w0.254: PR506.2 PR505.2 145.64,108.14 145.64,106.9 145.44,106.7 PR541.2 144.23,106.7 PQ512.1
N16336480: length 2.5
  BOTTOM w0.203: PR523.1 138.89,114.82 138.89,114.04 138.98,113.94 PU500.21
N16337658:
  vias: v4(161.42,112.16) v4(161.62,112.38) v4(163.23,112.13) v4(163.49,112.33)
N16337829: length 9.3
  IN4 w0.508: 160.01,106.97 160.03,106.95 163.98,106.95 164.49,107.46 164.49,112.11
  vias: v4(159.41,106.95) v4(159.69,106.95) v4(164.07,112.13) v4(164.35,112.36)
N16338400: length 9.2
  BOTTOM w0.508: PR519.2 162.42,111.83 162.79,111.47 165.79,111.47 PQ504.2 166.86,110.4 PR528.1 167.79,110.56 PR527.1 169.01,111.29 PQ505.1
N16338670:
  vias: v7(160.3,110.23) v7(160.55,110.23) v7(161.39,113.32) v7(161.59,113.1)
N16339095: length 2.7
  BOTTOM w0.508: PQ506.3 168.89,107.46 170.33,106.03 PD502.2
N16339107: length 1.4
  BOTTOM w0.508: PR528.2 168.58,110.4 PQ506.1
N16355483:
  vias: v4(151.94,109.62) v4(152.22,109.62) v4(153.01,111.88) v4(153.29,111.88)
N16355542: length 3.5
  BOTTOM w0.508: PC544.1 154.97,111.98 PR537.1 154.05,111.62 153.77,111.34 152.65,111.34 152.17,110.86
N16355618: length 3.2
  BOTTOM w0.508: PQ511.1 151.25,112.92 PR538.1 PR534.2 154.03,112.92 PR537.2
N16355677: length 4.9
  BOTTOM w0.508: PQ511.3 149.04,113.24 148.03,112.23 148.03,111.33 147.78,111.08 147.08,111.08 146.68,110.68 PD503.2
N16355838:
  vias: v4(150.67,108.47) v4(150.93,108.47) v4(152.07,111.88) v4(152.35,111.88)
N16369124: length 2.5
  TOP w0.119: PQ202.2 189.72,125.53 189.39,125.2 v14(189.19,125.2) 189.14,125.25 PU200.4
N16777906: length 1.3
  TOP w0.254: U21.11 138.72,103.55 C156.1
N16777910: length 1.2
  TOP w0.254: U21.9 138.51,104.55 C156.2
N16784816: length 2
  TOP w0.119: Q5.6 206.13,134.19 R29.2 R30.2
N16784922: length 2.3
  BOTTOM w0.119: CA67.1 13.74,121.97 CA68.1 R389.1 RA59.2 16.05,121.97 RA57.2
N17205976: length 10.7
  TOP w0.119: v14(189.93,141.61) 189.5,141.61 189.03,142.08 189.03,142.19 v1(188.72,142.5)
  IN1 w0.084: v2(187.73,142.81) 188.05,142.5 v1(188.72,142.5)
  IN3 w0.084: v7(192.81,147.48) 188.78,143.45 188.59,143.45 188.16,143.02 v7(188.11,143.02) 187.93,143.02 v2(187.73,142.81)
  BOTTOM w0.119: v7(192.81,147.48) 192.63,147.3 JDEG1.1
N17240183: length 1.7
  TOP w0.203: C146.1 36.25,106.21 35.92,105.89 U20.10
N17242618: length 2.1
  TOP w0.203: U7.10 107.5,126.44 107.24,126.18 106.81,126.18 106.5,125.87 C104.1
N17243850: length 1.5
  TOP w0.203: U12.12 209.28,126.22 C97.1
N17302212: length 1.6
  TOP w0.203: C163.1 46.46,103.02 U22.12
N17303797: length 1.5
  TOP w0.203: U12.10 209.27,125.42 C106.1
N17544228: length 2
  TOP w0.119: CA28.1 31.58,80.66 31.81,80.89 UA2.19
N17544867: length 2.4
  TOP w0.203: UA2.2 37.99,84.72 38.28,85 39.09,85 CA16.1
N17545095: length 2.5
  TOP w0.119: CA32.1 35.19,77.66 UA2.28
N17545649: length 1.8
  TOP w0.119: RA39.2 36.3,76.9 35.99,77.2 UA2.30
N17587387: length 3.1
  TOP w0.203: UA2.39 39.75,79.69 41.48,77.97 LA9.1
N17587465: length 2.1
  TOP w0.203: UA2.45 39.99,82.09 40.83,82.93 40.83,83.14
N18800960: length 5.1
  TOP w0.254: RA18.1 20.43,128.23 v1(20.18,128.49)
  IN1 w0.254: v1(20.18,128.49) v2(19.44,128.49)
  IN3 w0.254: v7(16.99,129.2) 17.71,129.2 18.55,128.35 19.31,128.35 v2(19.44,128.49)
  BOTTOM w0.254: v7(16.99,129.2) 16.98,129.22 UA3.10
N18930710: length 0.9
  TOP w0.254: PC1120.2 114.68,114.54 PR1127.1
N18930749: length 0.9
  TOP w0.305: PC1119.2 113.82,123.48 PR1126.1
N18963961: length 1.3
  TOP w0.508: PR1137.1 105.41,121.63 PC1125.2
N18964596: length 0.8
  TOP w0.254: PC1122.1 PR1132.2
N18975678: length 6.9
  BOTTOM w0.254: PR1141.2 109.56,126.94 104.88,126.94 104.47,126.53 103.25,126.53 PH1101.1
N19013762: length 1
  BOTTOM w0.254: PR1149.2 115.85,124.17 PC1149.1
