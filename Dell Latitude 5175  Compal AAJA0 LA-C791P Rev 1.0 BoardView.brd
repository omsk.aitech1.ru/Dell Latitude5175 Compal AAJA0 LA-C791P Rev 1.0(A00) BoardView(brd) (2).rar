# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SKYCAM_CSI2_D#: length 99.8
  IN2 w0.079: v2(141.05,128.65) 141.22,128.82 141.22,129.1 141.17,129.14 139.35,129.14 137.88,127.67 134.04,127.67 132.74,126.37 130.43,126.37 129.83,125.77 129.18,125.77 127.49,127.45 126.26,127.45 125.94,127.13 125.67,127.13 125.34,127.45 124.43,127.45 124.06,127.83 121.56,127.83 121.21,128.17 119.87,128.17 119.84,128.21 115.41,128.21 115.22,128.39 115.22,128.73 115.14,128.81 114.91,128.81 114.83,128.73 114.83,128.39 114.64,128.21 114.05,128.21 113.52,128.73 112.05,128.73 111.87,128.92 111.87,129.18 111.79,129.26 111.55,129.26 111.47,129.18 111.47,128.92 111.29,128.73 110.9,128.73 109.92,127.76 109.43,127.76 109.2,127.99 108.81,127.99 108.58,127.76 108.19,127.76 107.97,127.98 107.45,127.98 107.23,127.76 106.9,127.76 106.82,127.68 106.82,127.66 106.63,127.47 106.24,127.47 106.05,127.66 106.05,127.68 105.97,127.76 105.69,127.76 104.58,128.87 103.38,128.87 103.17,129.08 103.17,129.52 103.08,129.61 102.9,129.61 102.76,129.47 102.29,129.47 102.15,129.61 101.92,129.61 101.76,129.45 101.35,129.45 101.19,129.61 101.05,129.61 96.57,125.13 95.91,125.13 95.34,124.56 95.34,124.07 90.8,119.53 84.89,119.53 81.21,115.85 81.21,112.54 79.46,110.79 71.92,110.79 71.5,111.22 69.6,111.22 69.23,110.85 68.65,110.85 68.49,110.69 68.49,109.84 68.58,109.75 68.68,109.75 68.83,109.9 v2(68.83,109.95)
  IN3 w0.06: v10(68.95,111.43) 68.83,111.31 68.83,111.19 68.89,111.14 69.04,111.14 69.17,111 69.17,110.87 69.11,110.81 69.11,110.8 69.08,110.77 69.08,110.65 68.51,110.08 68.51,109.79 68.59,109.71 68.8,109.71 68.83,109.74 v2(68.83,109.95)
  IN3 w0.084: v2(141.05,128.65) 141.25,128.45 141.25,128.26 142.23,127.28 142.23,126.47 143.28,125.42 143.28,125.29 v7(142.93,124.95)
  BOTTOM w0.119: v7(142.93,124.95) 142.93,125.26 R381.1
SKYCAM_CSI2_D#_L: length 8.4
  IN3 w0.084: v7(142.93,126.65) 143.28,126.99 143.28,127.17 141.98,128.47 141.98,128.78 141.54,129.21 139.1,129.21 138.49,129.83 138.17,129.83 137.82,130.18 137.82,130.33 v7(137.6,130.55)
  BOTTOM w0.119: v7(142.93,126.65) 142.85,126.56 R381.2
SKYCAM_CSI2_D_L: length 8.4
  IN3 w0.084: v7(138.2,130.55) 137.98,130.33 137.98,130.25 138.24,129.99 138.56,129.99 139.17,129.38 141.6,129.38 142.14,128.84 142.14,128.54 143.44,127.24 143.44,126.99 v7(143.78,126.65)
  BOTTOM w0.119: R380.2 143.87,126.56 v7(143.78,126.65)
SKYCAM_CSI3_D: length 98.7
  IN2 w0.079: v2(69.67,109.46) 69.67,109.49 69.33,109.83 69.33,109.93 69.32,109.95 69.32,110.29 69.96,110.94 71.21,110.94 71.8,110.35 79.56,110.35 81.59,112.37 81.59,115.69 84.73,118.83 90.65,118.83 95.75,123.93 95.75,124.27 96.21,124.74 96.72,124.74 99.95,127.97 103.07,127.97 103.94,127.09 107.23,127.09 107.45,127.31 111.48,127.31 112.61,126.18 117.4,126.18 118.31,125.26 118.31,123.97 119.47,122.81 119.63,122.81 120.28,122.16 125.01,122.16 125.98,123.13 125.98,123.24 127.92,125.19 129.81,125.19 130.58,125.96 133.12,125.96 134.38,127.22 137.99,127.22 138.95,128.18 141.61,128.18 141.98,128.55 141.98,129.12 142.2,129.35 142.34,129.35 v2(142.49,129.5)
  IN3 w0.06: v10(69.6,110.94) 69.6,110.46 69.38,110.24 69.38,109.76 v2(69.67,109.46)
  IN3 w0.084: v2(142.49,129.5) 142.65,129.35 142.96,129.35 143.16,129.14 143.16,128.3 144.37,127.09 144.37,126.66 145.39,125.64 145.39,125.36 v7(145.8,124.95)
SKYCAM_CSI3_D#: length 98.2
  IN2 w0.079: v2(142.54,128.95) 142.54,129.06 142.44,129.16 142.28,129.16 142.16,129.05 142.16,128.48 141.69,128 139.03,128 138.07,127.03 134.46,127.03 133.2,125.77 130.66,125.77 129.89,125 128,125 126.16,123.17 126.16,123.05 125.09,121.98 120.2,121.98 119.55,122.63 119.39,122.63 118.13,123.89 118.13,125.19 117.32,125.99 112.53,125.99 111.4,127.12 107.52,127.12 107.31,126.91 103.87,126.91 102.99,127.78 100.03,127.78 96.8,124.55 96.29,124.55 95.93,124.2 95.93,123.85 90.72,118.65 84.81,118.65 81.78,115.61 81.78,112.3 79.64,110.16 71.72,110.16 71.13,110.75 70.04,110.75 69.5,110.21 69.5,110.04 69.54,110 v2(69.67,110)
  IN3 w0.06: v10(69.6,111.43) 69.52,111.43 69.48,111.39 69.48,111.29 69.62,111.15 69.67,111.15 69.84,110.98 69.84,110.89 69.72,110.77 69.72,110.41 69.65,110.34 69.65,110.26 69.88,110.04 69.88,109.98 69.84,109.95 69.72,109.95 v2(69.67,110)
  IN3 w0.084: v2(142.54,128.95) 142.54,129.1 142.63,129.19 142.89,129.19 143,129.07 143,128.23 144.21,127.03 144.21,126.59 145.23,125.58 145.23,125.14 145.03,124.95 v7(144.95,124.95)
SKYCAM_CSI3_D#_L: length 8.9
  IN3 w0.084: v7(144.95,126.65) 145.36,127.05 145.36,127.1 143.56,128.89 143.56,129.3 142.86,130 139.21,130 139.02,130.2 139.02,130.33 v7(138.8,130.55)
SKYCAM_CSI3_D_L: length 8.9
  IN3 w0.084: v7(145.8,126.65) 145.52,126.93 145.52,127.17 143.72,128.96 143.72,129.37 142.93,130.16 139.28,130.16 139.18,130.27 139.18,130.33 v7(139.4,130.55)
SKYCAM_CSI_CLK_D: length 101.2
  IN2 w0.079: v2(141.44,126.16) 141.25,125.97 141.25,125.77 140.92,125.44 140.65,125.44 140.24,125.85 140.08,125.85 139.95,125.72 139.95,125.58 140.37,125.16 140.37,124.89 140.09,124.62 139.83,124.62 139.36,125.09 139.22,125.09 139.07,124.94 139.07,124.82 139.55,124.34 139.55,124.07 139.31,123.83 137.87,123.83 137.69,124.02 137.69,124.75 137.59,124.85 137.39,124.85 137.29,124.75 137.29,124.02 137.1,123.83 136.67,123.83 136.48,124.02 136.48,124.77 136.4,124.85 136.17,124.85 136.09,124.77 136.09,124.02 135.9,123.83 135.51,123.83 135.32,124.02 135.32,124.77 135.24,124.85 135.01,124.85 134.93,124.77 134.93,124.02 134.74,123.83 133.08,123.83 132.5,124.42 131.35,124.42 130.59,123.66 130.4,123.66 129.79,123.05 129,123.05 128.81,122.86 128.81,122.74 129.09,122.46 129.09,122.2 128.81,121.92 128.55,121.92 128.27,122.2 128.16,122.2 126.62,120.67 119.65,120.67 119.36,120.96 119.18,120.96 118.12,122.02 118.02,122.02 117.88,121.87 117.61,121.87 117.33,122.15 117.33,122.41 117.54,122.62 117.54,122.73 117.04,123.23 115.43,123.23 114.58,124.08 111.44,124.08 109.85,125.67 101.55,125.67 101.29,125.93 99.89,125.93 97.24,123.28 97.24,122.91 96.72,122.39 96.47,122.39 91.23,117.15 90.83,117.15 90.5,116.82 85,116.82 82.99,114.81 82.99,111.61 80.29,108.91 75.31,108.91 75.19,109.03 71.5,109.03 71.06,109.47 70.65,109.47 70.34,109.16 70.34,108.82 70.13,108.61 69.89,108.61 v2(69.67,108.4)
  IN3 w0.06: v2(69.67,108.4) 69.37,108.7 69.37,108.91 69.14,109.15 69.14,110.34 69.28,110.48 v10(69.28,110.69)
  IN3 w0.084: v7(141.62,124.95) 141.25,125.32 141.25,125.97 v2(141.44,126.16)
  BOTTOM w0.119: R382.1 141.71,125.03 v7(141.62,124.95)
SKYCAM_CSI_CLK_D#: length 101.1
  IN2 w0.079: v2(140.91,126.16) 141.06,126 141.06,125.85 140.84,125.62 140.73,125.62 140.31,126.04 140,126.04 139.76,125.8 139.76,125.5 140.19,125.08 140.19,124.97 140.02,124.8 139.91,124.8 139.43,125.28 139.14,125.28 138.89,125.02 138.89,124.74 139.37,124.26 139.37,124.15 139.23,124.02 137.95,124.02 137.87,124.1 137.87,124.83 137.67,125.03 137.31,125.03 137.11,124.83 137.11,124.1 137.03,124.02 136.75,124.02 136.67,124.1 136.67,124.85 136.48,125.03 136.09,125.03 135.9,124.85 135.9,124.1 135.82,124.02 135.59,124.02 135.51,124.1 135.51,124.85 135.32,125.03 134.93,125.03 134.74,124.85 134.74,124.1 134.67,124.02 133.16,124.02 132.58,124.6 131.27,124.6 130.51,123.84 130.32,123.84 129.71,123.23 128.92,123.23 128.62,122.93 128.62,122.67 128.9,122.39 128.9,122.28 128.74,122.11 128.63,122.11 128.34,122.39 128.08,122.39 126.55,120.86 119.72,120.86 119.43,121.15 119.26,121.15 118.2,122.2 117.94,122.2 117.8,122.06 117.69,122.06 117.52,122.23 117.52,122.34 117.72,122.54 117.72,122.8 117.12,123.41 115.51,123.41 114.66,124.27 111.52,124.27 109.93,125.85 101.63,125.85 101.37,126.11 99.81,126.11 97.06,123.36 97.06,122.99 96.64,122.57 96.4,122.57 91.16,117.33 90.75,117.33 90.42,117 84.93,117 82.8,114.88 82.8,111.68 80.22,109.09 75.39,109.09 75.27,109.22 71.57,109.22 71.14,109.65 70.57,109.65 70.15,109.23 70.15,108.89 70.06,108.8 69.8,108.8 v2(69.67,108.93)
  IN3 w0.06: v2(69.67,108.93) 69.52,108.93 69.26,109.19 69.26,110.29 69.48,110.51 69.48,110.61 69.48,110.77 69.34,110.91 69.34,110.96 69.44,111.07 69.44,111.14 69.4,111.18 v10(69.28,111.18)
  IN3 w0.084: v2(140.91,126.16) 141.09,125.97 141.09,125.26 v7(140.77,124.95)
  BOTTOM w0.119: v7(140.77,124.95) 140.69,125.03 R383.1
SKYCAM_CSI_CLK_D#_L: length 7.4
  IN3 w0.084: v7(140.77,126.65) 141.14,127.01 141.14,127.24 139.75,128.63 138.9,128.63 138.26,129.27 137.42,129.27 136.62,130.07 136.62,130.33 v7(136.4,130.55)
  BOTTOM w0.119: R383.2 140.69,126.56 v7(140.77,126.65)
SKYCAM_CSI_CLK_D_L: length 7.4
  IN3 w0.084: v7(137,130.55) 136.78,130.33 136.78,130.14 137.49,129.43 138.33,129.43 138.96,128.79 139.81,128.79 141.3,127.31 141.3,126.97 v7(141.62,126.65)
  BOTTOM w0.119: v7(141.62,126.65) 141.71,126.56 R382.2
SKYCAM_I2C_CLK: length 87.9
  TOP w0.119: RH6.1 124.65,130.25 125.17,130.77 v1(125.34,130.77)
  VCC w0.089: v21(128.9,129.5) 128.96,129.45 v9(128.96,128.98)
  IN1 w0.109: v2(59.46,119.78) 59.46,120.06 60.27,120.87 60.57,120.87 61.42,121.72 61.42,122.01 61.9,122.5 62.17,122.5 65.29,125.61 66.89,125.61 67.72,126.45 69.94,126.45 70.51,125.87 80.91,125.87 81.1,126.07 84.79,126.07 85.56,125.3 85.79,125.3 86.59,124.5 86.61,124.5 86.99,124.13 88.59,124.13 89.25,124.79 92.69,124.79 93.05,125.15 94.42,125.15 95.06,125.79 95.06,126.51 95.52,126.97 95.52,127.55 96.45,128.49 97.7,128.49 97.89,128.67 100.97,128.67 101.65,129.36 103.09,129.36 103.21,129.24 104.96,129.24 105.61,128.59 v2(105.74,128.59) ; v21(128.9,129.5) 128.83,129.58 127.66,129.58 126.86,130.37 125.73,130.37 v1(125.34,130.77) 125.14,130.97 123.9,130.97 123.39,130.46 123.29,130.46 v2(122.86,130.03)
  IN3 w0.06: v3(59.74,119.42) 59.74,119.5 v2(59.46,119.78)
  IN3 w0.084: v3(105.33,128.56) 105.71,128.56 v2(105.74,128.59) ; v2(122.86,130.03) 122.14,129.3 122.12,129.3 121.54,128.72 v3(121.54,128.59)
  IN4 w0.06: v5(62.11,119.23) 61.9,119.23 61.7,119.43 60.27,119.43 60.27,119.42 v3(59.74,119.42)
  IN4 w0.089: v3(121.54,128.59) 121.44,128.59 119.98,130.06 119.98,130.66 119.71,130.93 116.74,130.93 116.2,131.47 113.39,131.47 113.04,131.12 111.94,131.12 111.02,132.03 107.84,132.03 105.69,129.89 105.69,128.92 v3(105.33,128.56)
SKYCAM_I2C_DATA: length 87.7
  VCC w0.089: v21(127.52,129.31) 127.52,128.86 127.91,128.48 127.91,128.47 128.06,128.32 128.06,128.32 128.08,128.3 128.79,128.3 128.96,128.47 v9(128.96,128.58)
  IN1 w0.109: v2(58.88,119.47) 59.02,119.33 60.4,119.33 60.74,119.67 60.98,119.67 62.04,120.73 62.04,121.3 62.35,121.61 62.35,121.98 65.38,125.02 66.99,125.02 67.93,125.95 69.73,125.95 70.3,125.38 76.89,125.38 77.74,124.53 85.76,124.53 86.66,123.64 88.8,123.64 89.46,124.3 92.43,124.3 93.15,123.57 94.25,123.57 94.42,123.75 94.42,124.45 95.92,125.96 96.78,125.96 99,128.17 101.98,128.17 102.08,128.07 102.68,128.07 103.36,128.75 104.76,128.75 105.41,128.1 106.01,128.1 v2(106.22,128.31) ; v21(127.52,129.31) 127.49,129.33 127.49,129.39 126.73,130.15 125.55,130.15 124.93,130.77 123.98,130.77 123.41,130.2 v2(123.41,130.03) v1(123.41,129.47)
  IN3 w0.06: v2(58.88,119.47) 59.03,119.47 v3(59.19,119.31)
  IN3 w0.084: v3(122.02,128.54) 122.3,128.82 122.31,128.82 123.41,129.91 v2(123.41,130.03) ; v2(106.22,128.31) v3(106.22,128.74)
  IN4 w0.06: v5(61.13,119.23) 60.24,119.23 60.21,119.2 59.3,119.2 v3(59.19,119.31)
  IN4 w0.089: v3(122.02,128.54) 122.02,128.34 121.77,128.08 121.28,128.08 119.47,129.9 116.67,129.9 115.58,131 113.58,131 113.23,130.65 111.74,130.65 110.83,131.56 108.08,131.56 106.22,129.7 v3(106.22,128.74)
SKYCAM_USER_CSI0_D: length 120.4
  TOP w0.119: v13(117.84,126.61) 117.95,126.72 117.95,126.95 117.71,127.19 L9.4 117.71,127.77 R82.1
  IN3 w0.084: v3(73.14,100.71) 73.21,100.78 73.51,100.78 73.58,100.71 75.19,100.71 75.68,101.2 76.2,101.2 76.4,101.4 76.4,101.92 76.51,102.02 76.67,102.02 76.92,101.78 77.32,101.78 77.57,102.02 83.56,102.02 83.96,102.43 89.22,102.43 89.45,102.2 89.74,102.2 90.16,102.62 90.31,102.62 90.73,102.2 90.9,102.2 90.99,102.11 92.25,102.11 92.75,102.61 92.75,103.03 92.84,103.13 97.05,103.13 97.11,103.2 100.19,103.2 100.57,102.82 100.8,102.82 101.18,103.2 109.97,103.2 112,105.22 120.6,105.22 121.68,106.3 128.61,106.3 129.23,106.92 129.68,106.92 129.87,107.11 129.87,108.02 130.34,108.48 130.34,108.85 130.42,108.93 130.58,108.93 130.77,109.12 130.77,109.48 130.58,109.67 130.42,109.67 130.34,109.76 130.34,109.92 130.71,110.29 130.71,110.51 130.36,110.85 130.36,110.97 131.31,111.92 131.31,115.17 130.77,115.72 130.77,118.17 130.61,118.33 130.28,118.33 130.07,118.54 130.07,118.73 130.21,118.87 130.57,118.87 130.77,119.07 130.77,119.45 130.59,119.63 130.17,119.63 130.1,119.7 130.1,119.95 130.19,120.05 130.19,120.05 131.33,121.19 131.33,122.16 131.33,123.07 131.66,123.41 131.66,123.7 131.33,124.04 131.33,124.27 131.41,124.36 131.79,124.36 131.97,124.54 131.97,124.92 131.79,125.1 131.41,125.1 131.33,125.19 131.33,125.4 131.42,125.49 131.81,125.49 131.97,125.64 131.97,126.04 132.15,126.23 132.15,127.65 129.05,130.76 125.57,130.76 123.96,132.38 121.46,132.38 120.73,131.64 120.73,131.34 120.94,131.13 120.94,130.89 120.73,130.67 120.73,130.06 119.74,129.07 119.74,128.89 118.67,127.83 117.7,127.83 117.53,127.65 117.53,127.27 117.67,127.13 117.92,127.13 117.98,127.06 117.98,126.75 v13(117.84,126.61)
  IN4 w0.06: v5(70.56,109.71) 70.57,109.7 70.57,109.28 71.12,108.72 71.12,106.5 70.88,106.26 70.88,105.83
  IN4 w0.089: 70.88,105.83 70.88,105.73 70.86,105.71 70.86,102.56 71.7,101.72 72.09,101.72 72.33,101.47 72.33,101.21 72.79,100.75 73.1,100.75 v3(73.14,100.71)
SKYCAM_USER_CSI0_D#: length 120.4
  TOP w0.119: R83.1 118.56,127.77 L9.1 118.38,127.46 118.21,127.29 118.21,126.8 118.4,126.61 v13(118.43,126.61)
  IN3 w0.084: v13(118.43,126.61) 118.43,126.84 118.36,126.9 118.21,126.9 118.15,126.97 118.15,127.13 117.99,127.29 117.74,127.29 117.69,127.33 117.69,127.59 117.77,127.67 118.74,127.67 119.9,128.83 119.9,129.01 120.89,130 120.89,130.61 121.11,130.83 121.11,131.19 120.89,131.41 120.89,131.57 121.53,132.21 123.89,132.21 125.51,130.6 128.98,130.6 131.99,127.59 131.99,126.29 131.8,126.1 131.8,125.71 131.75,125.65 131.35,125.65 131.16,125.46 131.16,125.12 131.34,124.94 131.72,124.94 131.8,124.86 131.8,124.6 131.72,124.52 131.34,124.52 131.16,124.34 131.16,123.97 131.5,123.63 131.5,123.48 131.16,123.14 131.16,121.71 131.16,121.25 130.03,120.12 130.03,120.11 129.93,120.02 129.93,119.64 130.11,119.46 130.52,119.46 130.6,119.38 130.6,119.14 130.5,119.04 130.15,119.04 129.9,118.79 129.9,118.47 130.21,118.17 130.54,118.17 130.6,118.1 130.6,115.65 131.15,115.1 131.15,111.99 130.2,111.04 130.2,110.78 130.55,110.44 130.55,110.36 130.17,109.99 130.17,109.69 130.35,109.51 130.51,109.51 130.61,109.41 130.61,109.19 130.51,109.09 130.35,109.09 130.17,108.91 130.17,108.55 129.71,108.08 129.71,107.18 129.61,107.09 129.17,107.09 128.55,106.46 121.61,106.46 120.53,105.38 111.93,105.38 109.91,103.36 101.11,103.36 100.73,102.98 100.64,102.98 100.26,103.36 97.05,103.36 96.98,103.29 92.78,103.29 92.58,103.1 92.58,102.68 92.18,102.28 91.06,102.28 90.97,102.36 90.8,102.36 90.37,102.78 90.09,102.78 89.67,102.36 89.51,102.36 89.28,102.59 83.89,102.59 83.49,102.19 77.5,102.19 77.25,101.94 76.99,101.94 76.74,102.19 76.44,102.19 76.24,101.99 76.24,101.47 76.13,101.36 75.61,101.36 75.12,100.87 73.64,100.87 73.57,100.94 73.3,100.94 v3(73.15,101.09)
  IN4 w0.06: v5(70.56,110.2) 70.56,109.99 70.76,109.79 70.76,109.59 70.69,109.52 70.69,109.33 71.24,108.77 71.24,106.54 71.24,106.54 71.24,106.45 71,106.21 71,105.9 71,105.9 71.06,105.85 71.09,105.85 71.1,105.84 71.1,105.83
  IN4 w0.089: 71.1,105.83 71.1,105.64 71.08,105.62 71.08,102.65 71.79,101.94 72.18,101.94 72.55,101.56 72.55,101.3 72.88,100.97 73.03,100.97 v3(73.15,101.09)
SKYCAM_USER_CSI0_D#_L: length 3.5
  TOP w0.119: R83.2 118.56,128.85 v1(118.56,129.16)
  IN1 w0.109: v2(118.15,128.74) 118.56,129.14 v1(118.56,129.16)
  IN3 w0.084: v7(119.66,130.55) 119.29,130.18 119.29,130.04 118.76,129.51 118.76,129.26 118.46,128.96 118.37,128.96 v2(118.15,128.74)
SKYCAM_USER_CSI0_D_L: length 3.5
  TOP w0.119: v1(117.71,129.16) 117.79,129.08 117.79,128.93 R82.2
  IN1 w0.109: v2(118.14,129.41) 118.14,129.19 118.02,129.07 117.8,129.07 v1(117.71,129.16)
  IN3 w0.084: v7(119.06,130.55) 119.13,130.48 119.13,130.11 118.58,129.56 118.58,129.31 118.39,129.12 118.19,129.12 118.14,129.17 v2(118.14,129.41)
SKYCAM_USER_CSI1_D: length 119
  TOP w0.119: R79.1 114.67,127.77 L7.1 114.67,127.05 114.38,126.75 114.38,126.45 114.78,126.05 116.78,126.05 117,125.82 117,125.71 117.07,125.64 117.28,125.64 117.37,125.55 117.37,125.44 v13(117.28,125.35)
  IN3 w0.084: v13(117.28,125.35) 117.42,125.49 117.42,125.59 117.28,125.73 116.93,125.73 116.86,125.8 116.86,125.87 116.94,125.95 118.76,125.95 119.04,126.23 119.04,127.18 120.54,128.69 120.54,128.81 121.65,129.92 121.65,130.66 122.6,131.6 123.72,131.6 125.31,130.01 128.78,130.01 131.43,127.36 131.43,126.52 130.61,125.7 130.61,121.48 129.31,120.18 129.31,120.06 129.09,119.84 128.9,119.84 128.72,119.66 128.72,119.28 128.9,119.1 129.27,119.1 129.35,119.01 129.35,118.65 129.27,118.57 128.9,118.57 128.72,118.39 128.72,118 128.9,117.82 129.77,117.82 130.01,117.58 130.01,116.51 130.05,116.47 130.05,115.34 130.56,114.84 130.56,112.24 129.62,111.3 129.62,109.06 129.03,108.48 129.03,107.75 128.3,107.02 121.38,107.02 120.35,105.99 111.76,105.99 109.68,103.91 96.82,103.91 96.75,103.85 91.11,103.85 90.85,103.58 90.11,103.58 89.69,103.16 83.66,103.16 83.24,102.74 76.26,102.74 74.83,101.31 73.94,101.31 73.29,101.96 73.29,102.09 73.09,102.29 73.09,102.47 73.16,102.54 73.22,102.54 v3(73.28,102.48)
  IN4 w0.06: v5(70.89,109.43) 70.89,109.7 70.94,109.75 71.09,109.75 71.42,109.41 71.42,107.61 71.81,107.23 71.81,105.9 71.75,105.85 71.75,105.83
  IN4 w0.089: 71.75,105.83 71.75,102.65 72.06,102.35 72.47,102.35 72.77,102.65 73.11,102.65 v3(73.28,102.48)
SKYCAM_USER_CSI1_D#: length 119.1
  TOP w0.119: R78.1 113.82,127.77 L7.4 113.82,127.12 114.12,126.83 114.12,126.34 114.67,125.79 116.67,125.79 116.74,125.72 116.74,125.39 v13(116.7,125.35)
  IN3 w0.084: v13(116.7,125.35) 116.7,125.94 116.88,126.11 118.69,126.11 118.87,126.3 118.87,127.25 120.38,128.75 120.38,128.88 121.49,129.99 121.49,130.72 122.53,131.77 123.79,131.77 125.38,130.18 128.84,130.18 131.59,127.42 131.59,126.45 130.77,125.63 130.77,121.55 130.77,121.55 130.77,121.42 129.47,120.12 129.47,119.99 129.16,119.68 128.96,119.68 128.88,119.59 128.88,119.34 128.96,119.26 129.33,119.26 129.51,119.08 129.51,118.58 129.34,118.4 128.96,118.4 128.88,118.32 128.88,118.07 128.96,117.98 129.83,117.98 130.17,117.64 130.17,116.58 130.21,116.54 130.21,115.41 130.72,114.91 130.72,112.17 129.78,111.23 129.78,108.99 129.2,108.41 129.2,107.69 128.37,106.86 121.45,106.86 120.42,105.83 111.83,105.83 109.75,103.75 96.88,103.75 96.82,103.68 91.18,103.68 90.91,103.42 90.18,103.42 89.76,103 83.73,103 83.31,102.57 76.33,102.57 74.9,101.15 73.88,101.15 73.13,101.89 73.13,102.02 72.93,102.22 72.93,102.53 73.15,102.75 73.17,102.75 v3(73.28,102.86)
  IN4 w0.06: 71.97,105.83 71.93,105.88 71.93,107.18 71.93,107.28 71.54,107.66 71.54,109.46 71.14,109.87 70.97,109.87 v5(70.89,109.95)
  IN4 w0.089: 71.97,105.83 71.97,102.74 72.15,102.56 72.38,102.56 72.68,102.86 v3(73.28,102.86)
SKYCAM_USER_CSI1_D#_L: length 4.8
  TOP w0.119: v1(113.82,129.16) 113.82,128.85 R78.2
  IN1 w0.109: v1(113.82,129.16) 113.99,129.16 v2(114.22,128.93)
  IN3 w0.084: v2(114.22,128.93) 114.36,129.07 115.39,129.07 116.08,129.76 116.82,129.76 117,129.94 117,130.29 v7(117.26,130.55)
SKYCAM_USER_CSI1_D_L: length 4.9
  TOP w0.119: R79.2 114.67,128.85 v1(114.67,129.16)
  IN1 w0.109: v1(114.67,129.16) 114.67,129.35 114.46,129.56 114.31,129.56 v2(114.22,129.46)
  IN3 w0.084: v2(114.22,129.46) 114.22,129.41 114.39,129.24 115.32,129.24 116.01,129.92 116.75,129.92 116.84,130.01 116.84,130.37 v7(116.66,130.55)
SKYCAM_USER_CSI_CLK_D: length 119.7
  TOP w0.119: v13(116.54,126.6) 116.44,126.6 116.34,126.7 116.34,126.8 116.28,126.87 116.28,126.93 116.6,127.26 L8.1 116.6,127.77 R81.1
  IN3 w0.084: v13(116.54,126.6) 116.65,126.71 116.65,126.86 116.53,126.98 116.29,126.98 116.24,127.03 116.24,127.15 117.31,128.22 118.5,128.22 119.31,129.03 119.31,129.28 120.24,130.21 120.24,131.71 121.33,132.8 124.09,132.8 125.73,131.16 129.21,131.16 132.55,127.81 132.55,125.96 132.36,125.77 132.36,121.65 131.15,120.45 131.15,115.91 131.7,115.36 131.7,111.62 131.18,111.1 131.18,108.86 131.22,108.81 131.22,107.9 129.83,106.5 129.38,106.5 128.79,105.91 121.87,105.91 120.79,104.83 112.16,104.83 110.03,102.71 102.97,102.71 102.6,102.34 100.5,102.34 100.03,102.81 97.27,102.81 97.16,102.69 93.51,102.69 93.38,102.69 92.4,101.72 90.84,101.72 90.74,101.81 89.29,101.81 89.06,102.03 84.13,102.03 83.72,101.62 80.85,101.62 80.3,101.06 77.73,101.06 76.98,100.32 73.1,100.32 72.72,100.7 72.72,100.94 72.4,101.26 72.4,101.53 72.35,101.58 72.15,101.58 72.06,101.49 v3(72.06,101.36)
  IN4 w0.06: 70.38,105.83 70.38,105.92 70.3,105.99 70.3,106.75 70.9,107.35 70.9,107.45 70.9,108.76 70.45,109.22 70.45,109.54 70.36,109.62 70.36,109.71 70.33,109.74 70.21,109.74 70.17,109.7 70.17,109.51 v5(70.24,109.43)
  IN4 w0.089: v3(72.06,101.36) 71.96,101.36 71.92,101.32 71.92,101.23 71.87,101.18 71.67,101.18 70.38,102.47 70.38,105.83
SKYCAM_USER_CSI_CLK_D#: length 119.7
  TOP w0.119: v13(115.96,126.6) 116.01,126.66 116.01,126.93 115.75,127.19 L8.4 115.75,127.77 R80.1
  IN3 w0.084: v13(115.96,126.6) 116.08,126.72 116.08,127.22 117.24,128.38 118.44,128.38 119.15,129.1 119.15,129.35 120.08,130.28 120.08,131.78 121.26,132.96 124.16,132.96 125.8,131.32 129.28,131.32 132.71,127.88 132.71,125.89 132.52,125.7 132.52,121.58 131.32,120.38 131.32,115.98 131.86,115.43 131.86,111.56 131.34,111.04 131.34,108.92 131.38,108.88 131.38,107.83 129.9,106.34 129.45,106.34 128.86,105.74 121.93,105.74 120.86,104.67 112.23,104.67 110.1,102.55 103.04,102.55 102.67,102.17 100.43,102.17 99.96,102.65 97.34,102.65 97.22,102.53 93.45,102.53 92.47,101.55 90.77,101.55 90.68,101.65 89.22,101.65 88.99,101.87 84.2,101.87 83.78,101.45 80.92,101.45 80.36,100.9 77.8,100.9 77.05,100.15 73.04,100.15 72.56,100.63 72.56,100.87 72.48,100.95 v3(72.06,100.95)
  IN4 w0.06: v5(70.24,109.95) 70.04,109.75 70.04,109.35 70.18,109.21 70.29,109.21 70.78,108.71 70.78,107.4 70.18,106.8 70.18,106.7 70.18,105.94 70.16,105.92 70.16,105.83
  IN4 w0.089: 70.16,105.83 70.16,102.38 71.58,100.97 72.05,100.97 v3(72.06,100.95)
SKYCAM_USER_CSI_CLK_D#_L: length 4.2
  TOP w0.119: v1(115.75,129.16) 115.75,128.85 R80.2
  IN1 w0.109: v1(115.75,129.16) 115.9,129.16 v2(116.22,128.85)
  IN3 w0.084: v7(118.46,130.55) 118.33,130.41 118.33,130.03 118.05,129.75 117.76,129.75 117.03,129.02 116.39,129.02 v2(116.22,128.85)
SKYCAM_USER_CSI_CLK_D_L: length 4.2
  TOP w0.119: v1(116.6,129.16) 116.48,129.04 116.48,128.97 R81.2
  IN1 w0.109: v2(116.22,129.38) 116.22,129.34 116.4,129.16 v1(116.6,129.16)
  IN3 w0.084: v2(116.22,129.38) 116.22,129.26 116.28,129.2 116.31,129.2 116.32,129.18 116.97,129.18 117.69,129.91 117.98,129.91 118.16,130.09 118.16,130.41 118.02,130.55 v7(117.86,130.55)
SLEEVE:
  vias: v1(10.29,142.24) v1(10.57,142.24) v1(10.86,142.24) v2(10.38,142.57) v2(10.81,142.57) v3(10.53,142.92) v3(10.85,142.92)
SLEEVE_L: length 11.2
  IN3 w1.016: 8.03,142.85 8.05,142.83 8.05,131.64
  vias: v1(8.05,144.03) v1(8.23,144.24) v1(8.34,144) v2(7.77,144.25) v2(7.71,143.74) v7(8.12,130.83) v7(8.37,130.81) v7(8.64,130.82)
SLP_S0#: length 12.8
  IN3 w0.06: 55.12,125.02 55.25,125.02 56.02,124.25 57.23,124.25 57.75,123.74 58.21,123.74 58.49,124.02 59.01,124.02 59.07,123.96 59.07,123.94 59.32,123.7 59.75,123.7 60,123.45 60.17,123.45 61.65,121.98 62.44,121.98 v10(62.61,121.81)
  IN3 w0.084: 55.12,125.02 54.54,125.02 53.74,125.82 52.75,125.82 v7(52.45,125.52)
  BOTTOM w0.119: RH71.1 52.88,125.95 v7(52.45,125.52)
SM_INTRUDER#: length 25.3
  IN1 w0.084: v1(47.75,129.91) 47.75,130.11 v2(47.62,130.24)
  IN3 w0.084: v3(47.88,130.62) 47.88,130.5 v2(47.62,130.24)
  IN4 w0.06: v5(65.41,122.77) 65.05,122.77 64.85,122.97 64.77,122.97 64.53,123.21 64.37,123.21 63.92,123.66 63.92,123.67 63.92,123.86 63.86,123.92 63.86,124.26 63.44,124.68 63.3,124.68 61.83,126.16 59.72,126.16 58.9,126.98 58.59,126.98 58.24,127.33 58.24,127.81 57.56,128.49 57.56,128.69 56.7,129.55 56.7,130.11 56.42,130.39
  IN4 w0.089: v3(47.88,130.62) 47.83,130.67 47.83,131.73 48.16,132.06 51.21,132.06 51.35,132.2 53.78,132.2 54.17,131.81 54.64,131.81 54.82,131.99 55.47,131.99 55.95,131.51 55.95,130.86 56.42,130.39
SM_PG_CTRL: length 66
  TOP w0.119: v1(79.6,121.27) 79.6,121.69 79.69,121.78 80.36,121.78 RC14.2
  IN1 w0.084: v1(79.6,121.27) 79.92,121.59 81.31,121.59 81.45,121.45 82.4,121.45 82.57,121.62 85.12,121.62 86.29,120.46 87.64,120.46 88.29,121.1 95.63,121.1 96.09,120.65 96.86,120.65 97.8,121.58 97.8,122.82 97.8,122.83 97.8,123.11 98.07,123.38 98.19,123.38 99.38,124.58 101.35,124.58 101.93,125.15 108.95,125.15 109.52,124.59 110.15,124.59 110.69,124.04 110.69,119.67 114.03,116.34 114.03,116.07 115.83,114.27 119.31,114.27 120.39,115.34 120.39,115.67 121.68,116.95 123.48,116.95 123.64,117.12 129,117.12 129.72,116.4 129.72,115.88 v2(129.68,115.84)
  IN3 w0.084: v2(129.68,115.84) 129.31,115.84 v7(129.19,115.72)
SMBALERT#: length 12.9
  IN4 w0.06: 53.24,112.1 55.25,112.1 55.83,112.68 56.36,112.68 56.58,112.46 57.3,112.46 57.8,112.96 58.02,112.96 58.22,112.76 59.36,112.76 60.88,114.28 61.21,114.28 61.29,114.2 61.95,114.2 62.15,114.4 v5(62.36,114.4)
  IN4 w0.089: v4(52.37,112.05) 52.44,111.98 52.79,111.98 52.91,112.1 53.24,112.1
  BOTTOM w0.119: RH98.2 53.03,113.16 52.37,112.5 v4(52.37,112.05)
SMBCLK: length 66.5
  IN1 w0.109: v2(91.39,102.83) 91.39,102.54 91.07,102.22 87.95,102.22 87.61,101.88 85.05,101.88 83.93,100.77 81.99,100.77 80.71,99.48 79.59,99.48 78.91,98.8 72.17,98.8 71.88,99.09 68.9,99.09 68.15,98.34 64.27,98.34 64.02,98.59 63.07,98.59 60.68,100.98 60.68,101.75 58.22,104.21 58.22,104.77 57.44,105.56 56.88,106.11 56.88,107.49 56.74,107.63 56.02,108.35 56.02,108.47 53.07,111.42 53.07,112.96 v2(53.25,113.14)
  IN3 w0.084: v2(53.25,113.14) 53.25,112.98 53.35,112.89 53.38,112.89 53.54,112.73 54.31,112.73 54.54,112.96 54.66,112.96 v7(54.86,113.16) ; v7(92.1,102.94) 92.1,102.89 91.96,102.75 91.48,102.75 v2(91.39,102.83)
  IN4 w0.06: v5(63.35,115.69) 63.14,115.69 62.93,115.89 62.77,115.89 62.69,115.81 62.52,115.81 62.44,115.89 62.28,115.89 62.07,115.68 62.07,115.6 61.82,115.36 61.82,115.28 61.7,115.16 61.54,115.16 61.46,115.24 61.29,115.24 61.18,115.13 60.88,115.13 59.45,113.7 55.77,113.7 55.23,113.16 v7(54.86,113.16)
  BOTTOM w0.119: v7(92.1,102.94) 92.23,102.81 92.23,100.6 91.44,99.81 JXDP1.53
SMBDATA: length 63.8
  IN1 w0.109: v2(90.84,102.83) 90.74,102.73 87.37,102.73 87.11,102.47 84.94,102.47 83.73,101.26 81.68,101.26 80.4,99.97 79.1,99.97 78.37,99.24 77.3,99.24 77.12,99.06 72.28,99.06 71.83,99.5 68.73,99.5 67.83,98.6 64.98,98.6 63.51,100.07 63.51,100.59 62.99,101.11 62.1,101.11 61.26,101.95 61.26,101.96 58.71,104.51 58.71,106.36 57.98,107.08 57.79,107.28 57.79,107.28 57.3,107.77 57.06,108.01 56.51,108.55 56.51,108.67 56.2,108.99 53.56,111.63 53.56,112.55 v2(54.11,113.1)
  IN3 w0.084: v2(90.84,102.83) 90.89,102.83 91.3,103.24 91.68,103.24 v7(91.77,103.15) ; v2(54.11,113.1) 54.11,113.09 54.1,113.1 v7(53.72,113.1)
  IN4 w0.06: v7(53.72,113.1) 54.24,112.58 55.36,112.58 55.74,112.96 56.25,112.96 56.63,112.58 57.25,112.58 57.75,113.08 58.11,113.08 58.29,112.89 59.32,112.89 61.03,114.6 61.67,114.6 v5(61.87,114.4)
  BOTTOM w0.119: v7(91.77,103.15) 91.77,102.83 91.94,102.67 91.94,100.79 90.84,99.7 JXDP1.51
SML0ALERT#: length 23.9
  IN4 w0.06: v5(61.87,115.04) 61.67,114.84 60.94,114.84 59.55,113.46 55.9,113.46 55.27,112.82 54.72,112.82 54.51,113.04 54.51,113.12 54.17,113.46 53.46,113.46 53.16,113.16
  IN4 w0.089: 53.16,113.16 52.87,112.87 51.89,112.87 50.9,111.88 50.9,109.67 51.09,109.48 51.09,107.86 50.86,107.64 50.86,106.05 49.86,105.05 49.86,103.19 v4(49.61,102.94)
  BOTTOM w0.119: v4(49.61,102.94) 50.42,102.94 50.57,103.09 RH128.2
SML0CLK: length 190.8
  TOP w0.119: RH54.1 57.22,111.69 v1(57.22,112.12)
  GND1 w0.119: v2(213.42,103.49) 213.37,103.55 v9(212.64,103.55)
  IN1 w0.109: v2(213.42,103.49) 210.91,103.49 210.54,103.13 209.26,103.13 208.99,102.85 204.57,102.85 204.05,103.38 202.29,103.38 201.31,102.41 197.69,102.41 195.4,104.69 195.4,105.7 195.06,106.05 194.25,106.05 193.56,105.36 187.24,105.36 186.38,104.51 179.54,104.51 177.57,102.54 169.3,102.54 168.3,102.54 167.46,103.38 160.52,103.38 159.7,104.2 148.98,104.2 148.16,103.38 146.87,103.38 145.74,104.51 142.62,107.63 141.41,107.63 140.71,108.33 137.01,108.33 136.22,107.53 132.03,107.53 131.51,107.01 130.48,107.01 129.68,106.21 114.05,106.21 113.92,106.33 112.6,106.33 110.4,104.13 106.11,104.13 105.31,104.93 104.43,104.93 103.01,106.35 98.45,106.35 95.38,109.43 86.27,109.43 85.79,108.94 82.49,108.94 81.2,107.66 74.14,107.66 74.13,107.67 72.09,107.67 71.3,106.88 71.3,105.89 71.19,105.78 71.17,105.78 71.02,105.63 70.59,105.63 69.81,104.85 69.26,104.85 69.16,104.94 69.16,105.05 69.16,105.06 69.16,105.36 69.16,105.36 69.16,106.03 69.08,106.12 68.36,106.12 67.16,104.92 66.65,104.92 66.55,105.02 66.35,105.02 66.34,105.02 63.93,107.43 63.75,107.43 61.27,109.91 60.34,109.91 57.81,112.44 v2(57.33,112.44) 57.22,112.33 v1(57.22,112.12)
  IN3 w0.06: v2(57.33,112.44) 57.68,112.44 57.89,112.64 59.37,112.64 59.76,113.04 59.76,113.4 60.76,114.4 v10(61.37,114.4)
  IN3 w0.084: v2(213.42,103.49) 213.42,103.37 215.46,101.33 215.46,98.26 214.2,96.99 v7(213.7,96.99)
  BOTTOM w0.119: v7(213.7,96.99) 213.67,96.96 JNFC1.10
SML0DATA: length 194.3
  TOP w0.119: RH53.1 56.26,111.66 v1(56.72,112.12)
  GND1 w0.119: v9(213.14,104.43) 213.64,104.43 v2(213.93,104.14)
  IN1 w0.109: v1(56.72,112.12) v2(56.72,112.46) 57.05,112.8 57.83,112.8 60.46,110.17 61.38,110.17 61.9,109.64 61.95,109.64 63.73,107.86 63.95,107.86 66.02,105.8 67.11,105.8 67.78,106.47 68.54,106.47 68.63,106.38 68.93,106.38 69.63,107.08 70.31,107.08 70.38,107.15 71.19,107.15 72.12,108.08 74.33,108.08 74.4,108.15 80.92,108.15 82.29,109.51 85.66,109.51 86.18,110.03 95.55,110.03 98.72,106.86 103.19,106.86 104.01,106.05 106.49,106.05 106.88,105.65 108.43,105.65 108.53,105.76 111.33,105.76 112.4,106.82 114.12,106.82 114.25,106.7 125.27,106.7 127.3,108.73 128.69,108.73 129.91,107.5 131.3,107.5 131.83,108.02 136.02,108.02 136.82,108.83 140.9,108.83 141.61,108.12 142.82,108.12 146.25,104.69 160.17,104.69 160.96,103.9 167.63,103.9 168.5,103.03 169.1,103.03 169.1,103.03 177.37,103.03 179.33,105 180.64,105 181,105.35 186.47,105.35 186.97,105.85 193.36,105.85 194.04,106.54 195.26,106.54 195.89,105.91 195.89,104.9 197.89,102.9 201.11,102.9 202.08,103.87 210.36,103.87 210.63,104.14 v2(213.93,104.14)
  IN3 w0.06: 57.73,112.75 58.33,113.35 59.03,113.35 59.17,113.48 59.67,113.48 60.79,114.6 61.46,114.6 61.47,114.6 61.52,114.54 62.69,114.54 62.8,114.66 63,114.66 63.13,114.79 63.38,114.79 63.55,114.96 63.55,115.13 63.3,115.37 63.3,115.45 63.14,115.61 62.93,115.61 v10(62.85,115.69)
  IN3 w0.084: v7(213.7,96.6) 213.79,96.51 214.37,96.51 215.93,98.06 215.93,101.54 213.93,103.53 v2(213.93,104.14) ; v2(56.72,112.46) 57.01,112.75 57.73,112.75
  BOTTOM w0.119: v7(213.7,96.6) 213.66,96.56 JNFC1.12
SML1_SMBCLK: length 194.2
  IN2 w0.079: v2(190.63,138.21) 185.66,138.21 183.61,136.16 182.37,136.16 180.88,134.67 180.88,133.92 179.84,132.89 179.41,132.89 177.9,131.38 177.19,131.38 177,131.18 173.68,131.18 169.38,135.49 137.99,135.49 134.22,131.72 132.05,131.72 131.63,131.29 131.58,131.24 130.51,131.24 130.24,131.51 129.96,131.79 126.24,131.79 125.32,132.72 124.65,132.72 123.48,133.88 121.54,133.88 119.93,135.48 111.39,135.48 110.69,134.78 96.05,134.78 95.51,135.32 95.22,135.32 94.59,134.69 86.03,134.69 85.75,134.41 80.09,134.41 79.82,134.67 79.54,134.67 79.46,134.6 78.73,134.6 78.65,134.67 78.37,134.67 78.29,134.6 77.79,134.6 77.7,134.69 77.42,134.69 77.33,134.6 73.01,134.6 72.73,134.32 64.96,134.32 64.67,134.03 64.54,134.03 60.72,130.21 59.28,130.21 57.97,128.9 57.31,128.9 56.88,128.46 55.19,128.46 54.87,128.79 53.37,128.79 52.49,127.91 52.49,124.36 52.64,124.21 52.64,123.38 53.09,122.93 53.09,121.83 53.73,121.18 53.73,119.94 52.15,118.36 52.15,115.15 51.59,114.58 51.59,113.88 51.41,113.71 v2(51.41,112.97)
  IN3 w0.084: v2(190.63,138.21) 191.06,137.77 191.06,136.13 191.21,135.98 191.24,135.98 191.31,135.91 193.15,135.91 193.22,135.98 193.56,135.98 v7(193.82,136.24) ; v2(51.41,112.97) 51.41,112.84 v3(51.18,112.61)
  IN4 w0.06: 53.21,113.6 54.2,113.6 54.63,113.17 54.63,113.09 54.77,112.94 55.22,112.94 55.85,113.58 59.5,113.58 60.9,114.98 61.31,114.98 v5(61.37,115.04)
  IN4 w0.089: 53.21,113.6 52.72,113.11 51.68,113.11 v3(51.18,112.61) 50.62,112.05 50.62,108.07 50.39,107.84 50.39,106.25 49.39,105.24 49.39,105.07 48.71,104.38 v4(48.63,104.38)
SML1_SMBDAT: length 190.9
  IN2 w0.079: v2(192.02,138.6) 190.42,137 185.37,137 181.36,132.99 180.6,132.99 180.03,132.43 179.6,132.43 178.09,130.92 177.83,130.92 177.83,130.91 177.66,130.91 177.66,130.92 177.38,130.92 177.19,130.72 173.49,130.72 169.19,135.03 138.18,135.03 134.41,131.26 132.24,131.26 132.09,131.1 131.77,130.78 130.28,130.78 129.73,131.33 126.05,131.33 125.13,132.26 124.46,132.26 123.29,133.42 121.35,133.42 119.79,134.98 119.74,135.02 111.59,135.02 110.79,134.23 108.09,134.23 108.08,134.23 106.37,134.23 106.28,134.32 94.88,134.32 94.78,134.23 86.22,134.23 85.85,133.86 65.15,133.86 61.04,129.75 59.47,129.75 58.16,128.44 57.5,128.44 56.85,127.79 55.19,127.79 54.91,127.51 53.9,127.51 53.73,127.69 53.03,127.69 52.72,127.37 52.72,126.16 53.25,125.63 53.25,124.43 53.53,124.15 53.53,121.71 53.97,121.28 53.97,119.52 52.61,118.17 52.61,114.96 52.05,114.39 52.05,113.61 v2(51.82,113.38)
  IN3 w0.06: v10(62.85,114.4) 61.66,114.4 61.45,114.19 60.72,114.19 59.88,113.35 59.88,112.99 59.42,112.52 57.95,112.52 57.51,112.08
  IN3 w0.084: 57.51,112.08 56.05,112.08 55.8,112.33 54.77,112.33 54.57,112.12 53.2,112.12 52.79,112.53 52.49,112.53 52.03,112.98 52.03,113.24 51.89,113.38 v2(51.82,113.38) 51.76,113.32 51.18,113.32 50.32,112.46 50.29,112.46 50.04,112.21 v3(50.04,112.14) ; v7(192.02,138.17) v2(192.02,138.6)
  IN4 w0.089: v4(48.63,104.97) 48.92,105.26 48.92,105.62 49.92,106.62 49.92,108.09 50.15,108.32 50.15,112.02 v3(50.04,112.14)
  BOTTOM w0.119: U34.A7 191.82,137.96 v7(192.02,138.17)
SML1ALERT#: length 15.9
  IN4 w0.06: 55.47,121.16 55.85,121.16 55.86,121.15 58.33,121.15 58.4,121.08 59.83,121.08 60.14,121.38 60.7,121.38 60.71,121.36 61.21,121.36 61.29,121.28 61.46,121.28 61.55,121.38 61.56,121.38 61.62,121.44 61.7,121.44 61.75,121.48 v5(61.87,121.48)
  IN4 w0.089: 55.47,121.16 54.64,121.16 53.82,121.99 53.3,121.99 53.07,122.22 52.12,123.17 51.19,123.17 50.88,123.48 50.88,124.43 50.63,124.68 v4(50.47,124.68)
  BOTTOM w0.119: v4(50.47,124.68) 50.34,124.55 49.66,124.55 49.33,124.22 RH80.1 49.33,124.12 49.86,123.59 RH83.1
SNB_1.0V: length 1.5
  BOTTOM w0.508: PR815.2 178.71,121.37 PC810.1
SOC_SATALED#: length 5.7
  IN4 w0.06: v5(62.36,111.18) 62.11,110.93 62.11,110.6 62.01,110.5 61.81,110.5 61.68,110.37 61.68,110.22 61.53,110.07 61.46,110.07 61.45,110.05 61.45,109.84 60.76,109.16 60.76,109.07 60.55,108.85 60.55,107.85 60.46,107.76 60.46,107.37 60.46,106.56 v4(60.58,106.44)
SOC_SVID_ALERT#: length 4.7
  BOTTOM w0.06: UC1.B58 77.61,109.71 77.61,108.97
  BOTTOM w0.119: RC79.1 80.04,106.55 77.61,108.97
SOC_SVID_CLK: length 4
  BOTTOM w0.119: UC1.A56 77.33,108.73 79.15,106.91 RC80.1
SOC_SVID_DAT: length 4.6
  BOTTOM w0.119: RC78.1 80.82,106.16 77.87,109.11 UC1.A58
SPDIF_IN: length 1.4
  TOP w0.119: UA2.9 35.19,85.35 TC14.1
SPI1_INT#: length 10.4
  IN4 w0.06: v5(62.11,112.14) 61.9,112.14 61.67,111.9 61.67,111.83 61.57,111.74 61.57,111.74 61.46,111.62 61.45,111.62 60.83,111.62 59.12,109.91 59.12,108.49 58.78,108.15 58.78,106.09 58.46,105.77 58.08,105.77 57.94,105.63
  IN4 w0.089: v4(57.57,105.26) 57.94,105.63
  BOTTOM w0.119: v4(57.57,105.26) 57.65,105.18 57.65,104.88 57.96,104.56 RC88.2
SPI_CLK_ROM1: length 2
  BOTTOM w0.119: U39.6 49.28,113.87 49.28,115.67 RH93.1
SPI_CLK_ROM2: length 1.6
  TOP w0.119: RH52.1 51.03,113.65 50.39,113.01 U16.6
SPI_IO2_ROM1: length 2.1
  BOTTOM w0.119: U39.3 49.28,107.27 49.28,107.27 49.28,106 RH112.1
SPI_IO2_ROM2: length 4.8
  TOP w0.119: RH55.1 46.98,107.85 50.05,107.85 50.39,107.51 U16.3
SPI_IO3_ROM1: length 2.1
  BOTTOM w0.119: RH92.1 50.86,115.72 50.55,115.42 50.55,114.52 50.55,114.52 U39.7
SPI_IO3_ROM2: length 1.6
  TOP w0.119: RH50.1 49.83,113.84 49.12,113.12 U16.7
SPI_PCH_CLK: length 53.5
  TOP w0.119: JSPI1.7 52.71,147.13 52.98,146.85 52.98,146.34 52.73,146.09 v1(52.37,146.09) ; RH52.2 51.03,114.71 50.23,115.51 v14(50.04,115.51) 49.81,115.51 v1(49.66,115.36)
  IN1 w0.109: v1(49.66,115.36) 49.78,115.36 50.03,115.6 v2(50.03,115.84) 49.42,115.84 49.28,115.69 49.28,115.31 49.56,115.03 49.56,114.85 49.11,114.4 47.93,114.4 47.87,114.45 47.87,114.8 47.97,114.9 48.79,114.9 48.89,115 48.89,115.64 48.82,115.71 47.07,115.71 46.96,115.82 46.96,116.32 46.84,116.45 46.62,116.45 46.53,116.35 46.53,115.82 46.42,115.71 46.13,115.71 46.05,115.79 46.05,116.3 45.92,116.43 45.11,116.43 44.41,117.13 44.41,118.94 44.46,118.99 44.46,120.82 44.58,120.94 44.58,121.27 44.99,121.69 44.99,124.66 44.97,124.67 44.97,128.67 44.8,128.84 44.8,131.02 45.67,131.89 45.67,132.18 46.38,132.89 46.38,134.09 46.56,134.27 46.9,134.27 47.06,134.44 47.34,134.72 47.34,134.72 47.54,134.92 47.54,135.12 47.85,135.43 47.85,136.4 48.09,136.63 48.09,137.38 47.6,137.87 47.6,139.67 48.51,140.59 48.51,140.83 48.52,142.15 v1(48.67,142.31) 48.67,141.93 49.17,141.42 51,141.42 51.84,142.26 51.84,142.98 51.45,143.37 51.45,143.68 51.84,144.07 51.84,145.55 v1(52.37,146.09)
  IN3 w0.084: v7(49.69,115.84) 50.03,115.84 v2(50.03,115.84)
SPI_PCH_CS0#: length 64.1
  TOP w0.119: v1(54.21,148.77) 53.71,148.27 JSPI1.9
  IN1 w0.109: v1(54.21,148.77) 54.2,148.76 50.4,148.76 44.6,142.96 v1(44.6,142.31) 44.36,142.31 43.92,141.86 43.57,141.86 41.98,140.27 41.98,134.63 42.28,134.33 42.28,133.92 42.2,133.84 42.2,132.16 42.18,132.15 42.18,130.58 42.19,130.38 42.19,130.38 42.19,128.96 41.68,128.45 41.68,117.49 43.78,115.39 43.78,111.14 43.78,110.23 45.13,108.88 45.13,106.01 45.94,105.2 47.65,105.2 48.3,104.55 v2(48.3,104.48)
  IN3 w0.084: v2(48.3,104.48) 48.3,104.52 v7(48.03,104.79)
  BOTTOM w0.119: v7(48.03,104.79) 48.28,105.04 48.28,105.21 48.41,105.35 49.63,105.35 v14(50.09,105.81) 50.44,106.16 51.63,106.16 51.82,106.35 U39.1
SPI_PCH_CS1#: length 51.2
  TOP w0.119: v1(46.91,106.34) 47.37,106.34 47.37,106.34 47.73,106.34 47.85,106.47 U16.1 ; v1(49.81,146.09) 49.71,146.19 JSPI1.1
  IN1 w0.109: v1(46.91,106.34) 46.91,106.05 46.98,105.98 47.81,105.98 47.95,106.13 47.95,106.57 47.62,106.9 47.47,106.9 47.22,106.66 47.06,106.66 46.91,106.81 46.91,106.97 47.16,107.21 47.16,107.37 46.93,107.6 46.57,107.6 46.29,107.32 46.13,107.32 45.84,107.61 45.84,109.17 44.67,110.35 44.67,115.51 43.44,116.73 43.44,119.34 43.5,119.39 43.5,121.22 43.61,121.34 43.61,122.1 44.03,122.52 44.03,124.24 43.45,124.82 43.45,125.41 43.78,125.74 43.78,128.13 43.6,128.3 43.6,130.97 43.6,131.17 43.6,131.56 43.66,131.62 43.66,133.32 44.29,133.94 44.29,135.11 44.26,135.13 44.26,136.13 44.83,136.7 45,136.7 46.16,137.85 46.16,139.48 46.16,140.95 46.25,141.04 46.25,141.23 v1(46.38,141.37) 46.96,141.95 46.96,143.31 49.74,146.09 v1(49.81,146.09)
SPI_PCH_IO2: length 65
  TOP w0.119: RH55.2 45.98,107.48 45.4,106.9 RH56.2 45.31,106.77 v1(45.64,106.44) ; v1(55.21,148.76) 55.02,148.57 55.02,148.19 54.71,147.88 JSPI1.11
  IN1 w0.109: v2(48.25,105.92) 48.07,105.75 45.91,105.75 45.64,106.01 v1(45.64,106.44) 45.37,106.71 45.37,108.98 44.02,110.33 44.02,115.49 42.97,116.54 42.97,117.35 42.85,117.47 42.04,117.47 41.92,117.59 41.92,117.94 42.03,118.05 42.84,118.05 42.95,118.15 42.95,118.37 42.84,118.48 42.03,118.48 41.92,118.59 41.92,118.95 42.03,119.06 42.32,119.06 42.43,119.17 42.43,119.38 42.32,119.49 42.03,119.49 41.92,119.6 41.92,119.88 42.03,119.99 42.55,119.99 42.68,120.11 42.68,120.3 42.55,120.42 42.03,120.42 41.92,120.53 41.92,120.75 42.03,120.86 42.55,120.86 42.68,120.99 42.68,121.17 42.55,121.3 42.03,121.3 41.92,121.41 41.92,128.36 42.42,128.86 42.42,130.48 42.42,130.68 42.42,130.68 42.42,132.05 42.44,132.06 42.44,133.75 42.51,133.82 42.51,134.43 42.21,134.73 42.21,139.47 43.05,140.3 43.05,141.01 43.67,141.63 44.02,141.63 44.34,141.95 45.14,141.95 v1(45.49,142.31) 45.49,143.51 50.46,148.47 54.35,148.47 54.64,148.76 v1(55.21,148.76)
  IN3 w0.084: v7(48.58,105.88) 48.54,105.92 v2(48.25,105.92)
SPI_PCH_IO3: length 58.5
  TOP w0.119: JSPI1.13 55.71,147.99 56.02,148.3 v1(56.21,148.3) ; v1(50.36,143.05) 50.59,142.81 50.98,142.81 RC1.2 ; RH50.2 RH49.2 RH48.2 48.67,114.86 48.56,114.97 47.73,114.97 47.57,114.82 47.57,114.44 v1(47.59,114.43)
  IN1 w0.109: v1(47.59,114.43) 47.46,114.3 v2(47.17,114.3) 46.21,114.3 43.68,116.83 43.68,119.24 43.73,119.29 43.73,121.12 43.85,121.24 43.85,121.68 44.27,122.1 44.27,124.34 43.74,124.86 43.74,125.37 44.01,125.64 44.01,128.22 43.84,128.4 43.84,131.07 43.84,131.26 43.84,131.46 43.9,131.52 43.9,133.22 44.53,133.85 44.53,135.25 46.63,137.35 46.63,139.67 46.63,140.06 47.55,140.99 47.55,141.23 47.55,141.23 47.55,143.23 48.05,143.73 48.97,143.73 49.62,143.08 49.62,142.88 49.75,142.75 50.06,142.75 v1(50.36,143.05) 50.48,143.18 50.48,144.08 50.87,144.47 50.87,145.38 50.42,145.84 50.42,146.18 50.78,146.54 51.79,146.54 52.5,147.25 55.15,147.25 v1(56.21,148.3)
  IN3 w0.084: v2(47.17,114.3) v7(47.17,114.66)
  BOTTOM w0.119: v7(47.17,114.66) 46.97,114.86 46.97,116.03 47.27,116.34 48.9,116.34 48.9,116.34 48.9,116.34 49.32,116.34 49.47,116.18 50.15,116.18 50.28,116.06 RH92.2
SPI_PCH_SI: length 47.4
  TOP w0.119: v1(50.72,146.08) 50.71,146.1 JSPI1.3 ; RH51.2 50.09,114.98 49.07,114.98 48.54,115.51 v14(48.16,115.51) 47.84,115.51 v1(47.55,115.22) ; v1(48,142.81) 47.99,142.81 47.48,142.81 47.27,142.6 RC5.2
  IN1 w0.109: 48,142.81 48.52,143.33 49.03,143.33 49.36,143 49.36,142.68 49.53,142.51 50.22,142.51 50.72,143.01 50.72,143.98 51.11,144.37 51.11,145.67 50.72,146.06 v1(50.72,146.08) ; 48,142.81 47.79,142.6 47.79,141.14 47.79,141.13 47.79,140.89 46.86,139.97 46.86,139.77 46.87,137.25 44.76,135.15 44.76,133.75 44.14,133.12 44.14,131.42 44.07,131.36 44.07,131.17 44.08,128.49 44.25,128.32 44.25,125.54 43.98,125.27 43.98,124.96 44.5,124.44 44.5,122 44.09,121.58 44.09,121.14 43.97,121.02 43.97,119.2 43.92,119.14 43.92,116.93 45.63,115.22 v1(47.55,115.22) 48.38,115.22 v2(48.49,115.33) ; 48,142.81 v1(48,142.81)
  IN3 w0.084: v7(48.67,115.69) 48.67,115.51 v2(48.49,115.33)
  BOTTOM w0.119: RH94.2 48.42,115.69 v7(48.67,115.69)
SPI_PCH_SO: length 55.7
  TOP w0.119: RC7.2 49.56,142.66 49.11,143.1 46.76,143.1 v1(46.67,143.02) ; JSPI1.5 51.71,146.97 v1(51.59,146.85)
  IN1 w0.109: v2(46.33,106.37) 46.35,106.39 46.35,106.54 v1(46.02,106.87) 46.02,107.08 45.61,107.49 45.61,109.07 44.4,110.28 44.4,115.44 43.21,116.64 43.21,119.44 43.26,119.49 43.26,121.32 43.38,121.44 43.38,122.21 43.79,122.62 43.79,124.04 43.21,124.62 43.21,125.51 43.54,125.84 43.54,128.03 43.37,128.2 43.37,130.87 43.37,131.07 43.37,131.66 43.43,131.72 43.43,133.42 44.05,134.04 44.05,135.01 44.03,135.04 44.03,136.26 45.92,138.15 45.92,139.38 45.92,141.05 46.01,141.14 46.01,141.4 46.67,142.06 v1(46.67,143.02) 46.67,143.36 49.69,146.37 50.28,146.37 50.76,146.85 v1(51.59,146.85)
  IN3 w0.084: v7(47.76,104.13) 47.76,104.13 47.76,104.14 47.6,104.14 46.33,105.4 v2(46.33,106.37)
  BOTTOM w0.119: v7(47.76,104.13) 47.75,104.13 47.75,104.66 47.74,104.67 47.74,104.91 47.75,104.92 47.75,104.96 47.97,105.17 RH113.2
SPI_SI_ROM1: length 2.1
  BOTTOM w0.119: RH94.1 47.69,115.64 48.01,115.31 48.01,113.87 U39.5
SPI_SI_ROM2: length 5
  TOP w0.119: RH51.1 50.44,113.77 50.04,113.37 49.73,113.06 49.73,112.13 50,111.86 51.5,111.86 51.66,112.03 U16.5
SPI_SO_ROM1: length 16.8
  TOP w0.119: v1(43.85,109.01) 43.62,109.01 v14(42.8,108.18)
  IN1 w0.109: v1(43.85,109.01) 44.38,108.48 44.38,105.68 45.46,104.6 47.16,104.6 47.38,104.82 v2(47.38,104.84)
  IN3 w0.084: v2(47.38,104.84) 47.56,105.02 47.56,105.25 v7(47.56,105.25)
  BOTTOM w0.119: v7(47.56,105.25) 47.38,105.43 RH113.1 47.09,106.17 47.09,108.36 47.66,108.93 50.28,108.93 50.55,108.66 U39.2
SPI_SO_ROM2: length 3.5
  TOP w0.119: U16.2 49.12,107.39 48.92,107.6 47.38,107.6 46.66,106.87 RH57.1
SPK_L+:
  vias: v14(21.49,84.22)
SPK_L+_L: length 36.6
  TOP w0.203: UA2.23 32.42,79.29
  TOP w0.254: 32.42,79.29 v1(30.77,79.29)
  IN1 w0.254: v1(30.77,79.29) 30.07,80 28.96,80 v2(22.33,86.63)
  IN3 w1.016: 22.95,86.53 27.24,82.25 29.21,82.25 32.68,78.78 38.39,78.78 39.1,79.49 42.15,79.49
  vias: v1(43.32,79.94) v1(43.62,79.95) v1(43.71,79.64) v1(43.74,79.36) v2(43,79.49) v2(43.41,79.49) v7(21.88,87.11) v7(22,86.81) v7(22.16,87.26) v7(22.34,87)
SPK_L-:
  vias: v14(18.17,83.57)
SPK_L-_L: length 21.5
  TOP w0.203: v1(32.47,79.73) 32.51,79.69 UA2.22
  IN1 w0.254: v1(32.47,79.73) 32.47,80.06 32.58,80.16 v2(32.58,81.69)
  IN3 w0.254: v2(32.58,81.69) 30.52,83.75 27.92,83.75 22.8,88.86 v7(21.94,88.86)
  BOTTOM w0.254: LA14.1 19.11,86.05 RA60.2 19.11,88.1 19.53,88.52 21.59,88.52 v7(21.94,88.86)
SPK_L-_R: length 41.3
  TOP w0.203: UA2.21 32.45,80.09
  TOP w0.254: 32.45,80.09 32.12,80.09 31.86,79.83 30.82,79.83 30.8,79.85 v1(30.8,79.89)
  IN1 w0.254: v1(30.8,79.89) 30.8,79.99 30.16,80.62 29.13,80.62 22.59,87.16 22.12,87.16 v2(21.18,88.1)
  IN3 w1.016: 42.25,78.18 39.67,78.18 38.93,77.43 32.17,77.43 28.66,80.94 26.56,80.94 20.9,86.59 20.9,86.85
  vias: v1(43.05,78.02) v1(43.54,78.45) v1(43.76,78.03) v1(43.79,78.45) v2(43.1,78.43) v2(43.43,78.12) v7(20.82,87.89) v7(20.82,87.56) v7(20.82,87.23) v7(21.08,87.71)
SPK_R+_L: length 210
  TOP w0.203: 34.71,77.28 34.39,77.6 UA2.26
  TOP w0.254: v1(44.01,77) 40.97,77 40.36,77.61 39.47,77.61 38.3,76.45 38.3,76.06 37.93,75.68 36.31,75.68 34.71,77.28
  IN1 w0.254: v1(43.14,83.66) 43.77,83.03 43.77,81.15 42.39,79.77 42.39,77.74 43.13,77 v1(44.01,77)
  IN2 w1.016: 205.47,94.88 205.34,94.88 205.34,94.88 204.67,94.88 204.66,94.88 182.05,94.88 178.69,91.52 99.16,91.52 96.64,94.03 87.29,94.03 86.4,93.14 86.4,90.64 85.91,90.15 44.72,90.15 44.6,90.27 43.18,90.27 42.6,89.69 42.6,87.82 43.18,87.24 43.18,84.42 43.51,84.09
  IN4 w1.016: 216.28,102.97 214.31,101.01 208.54,101.01 207.33,99.79 207.33,98.1 206.65,97.42 206.65,95.75
  vias: v1(43.71,84.14) v1(43.81,83.76) v1(43.97,84.14) v2(43.03,84.52) v2(43.31,84.22) v2(206.33,94.6) v2(206.39,95.27) v2(206.77,94.6) v2(206.87,95.28) v3(206.27,94.94) v3(206.52,94.94) v3(206.77,94.94) v3(207.05,94.95) v4(216.53,103.65) v4(216.81,103.63) v4(217.12,103.63) v4(217.41,103.63)
SPK_R-_L: length 223.5
  TOP w0.203: UA2.25 33.99,77.28 34.5,76.77
  TOP w0.254: v1(40.16,77.05) 40.11,77 39.64,77 38.81,76.17 38.81,75.85 38.13,75.16 36.11,75.16 34.5,76.77
  IN1 w0.254: v2(221.36,110.01) 221.36,109.98 220.93,109.55 220.93,99.77 214.85,93.69 208.42,93.69 207.53,94.58 207.53,95.46 207.11,95.87 203.12,95.87 202.41,95.16 190.39,95.16 190.14,95.41 181.92,95.41 178.93,92.42 161.38,92.42 119.15,92.42 118.92,92.19 115.54,92.19 115.46,92.12 109.39,92.12 109,92.5 99.92,92.5 98.12,94.31 87.5,94.31 86.02,92.83 86.02,91.93 85.31,91.22 41.36,91.22 40.61,90.46 40.61,88.44 40.44,88.27 40.44,86.42 39.78,85.75 39.78,77.43 v1(40.16,77.05)
  IN3 w0.203: v7(221.77,110.08) 221.75,110.06 221.56,110.06 221.51,110.01 v2(221.36,110.01)
  BOTTOM w0.203: JIO1.51 v7(221.77,110.08)
SPK_R-_R: length 217.2
  TOP w0.203: UA2.24 32.74,78.89 32.59,78.74 32.59,78.43
  TOP w0.254: v1(44.04,76.49) 39.85,76.49 39.32,75.96 39.32,75.64 38.34,74.65 35.9,74.65 32.59,77.97 32.59,78.43
  IN1 w0.254: v1(42.96,85) 43.98,85 44.65,84.33 44.65,76.8 44.35,76.49 v1(44.04,76.49)
  IN1 w1.016: 42.82,87.57 42.52,87.87 42.52,89.63 43.22,90.33 85.71,90.33 86.91,91.52 86.91,92.46 87.87,93.42 97.75,93.42 99.55,91.62 108.63,91.62 109.13,91.12 115.87,91.12 115.87,91.12 119.15,91.12 119.56,91.53 161.01,91.53 161.01,91.53 179.4,91.53 182.39,94.52 189.77,94.52 190.02,94.28 204.22,94.28
  IN4 w1.016: 221.02,107.37 218.6,104.95 216.4,104.95 213.73,102.28 208.01,102.28 205.98,100.24 205.98,98.86 205.28,98.16 205.28,95.2
  vias: v1(43.36,86.02) v1(43.33,85.64) v1(43.61,86.02) v1(43.65,85.63) v2(205,94.07) v2(205.02,93.61) v2(205.41,94.06) v2(205.46,93.61) v3(204.97,94.74) v3(204.95,94.4) v3(205.3,94.4) v3(205.61,94.41) v4(221.46,109.24) v4(221.46,108.88) v4(221.46,108.51) v4(221.78,109.07)
SPKR: length 69.7
  IN4 w0.06: 54,119.75 55.79,119.75 55.87,119.84 58.38,119.84 58.9,120.36 60.49,120.36 60.6,120.47 60.89,120.47 60.94,120.52 v5(61.13,120.52)
  IN4 w0.089: 54,119.75 53.75,119.75 53.15,120.34 53.15,120.92 51.78,122.29 49.83,122.29 49.17,121.63 47.07,121.63 46.4,120.96 44.77,120.96 44.68,121.05 44.44,121.05 44.09,120.7 44.09,116.62 42.74,115.27 42.74,111.78 42.42,111.46 41.71,111.46 40.8,110.55 36.36,110.55 33.87,113.04 28.84,113.04 27.88,112.08 27.88,109.65 27.7,109.47 26.91,109.47 26.27,110.11 24.73,110.11 22.01,112.83 22.01,119.37 19.67,121.71 16.4,121.71 v4(16.07,121.38)
  BOTTOM w0.119: RA59.1 16.05,121.39 v4(16.07,121.38)
SS_0.95V_PRIM: length 2.8
  TOP w0.254: PR916.1 171.83,103.07 172.5,103.73 173.03,103.73 PU901.7
  TOP w0.508: PC921.1 171.45,102.15 PR916.1
SSD_PEDET: length 25.8
  IN4 w0.089: v4(25.09,100.68) 25.27,100.5 25.27,95.62 23.82,94.17 v4(23.82,91.46)
  BOTTOM w0.119: v4(25.09,100.68) 25.12,100.68 26.03,101.58 JNGFF2.69 ; v4(23.82,91.46) 22.39,90.02 R470.2 21.92,90.61 21.92,91.56 21.7,91.78 U51.2 18.46,91.78 18.08,91.4 18.08,89.39 v14(18.43,89.04)
SSD_PWR_EN: length 37.9
  IN1 w0.109: v2(35.36,101.03) v1(35.36,100.68)
  IN3 w0.06: v10(62.61,116.65) 62.38,116.65 62.14,116.89 60.45,116.89 60.27,117.07 59.47,117.07 58.26,115.85 58.2,115.85
  IN3 w0.084: 58.2,115.85 56.58,115.85 56.54,115.9 55.85,115.9 55.4,116.35 54.8,116.35 54.29,115.83 52.92,115.83 52.12,115.03 51.69,115.03 51.12,114.46 50.7,114.46 50.59,114.35 50.05,114.35 49.64,113.94 49.04,113.94 48.91,113.8 48.01,112.9 48.01,112.73 48.01,112.38 v3(47.9,112.28) ; v3(37.46,101.21) 37.38,101.3 35.62,101.3 v2(35.36,101.03)
  IN4 w0.089: v3(37.46,101.21) 39.57,103.32 41.9,103.32 45,106.42 45.83,106.42 46.74,107.32 46.74,107.44 48.03,108.74 48.03,109.45 48.53,109.95 48.53,111.66 v3(47.9,112.28)
SSD_PWR_EN_R: length 3.2
  TOP w0.203: U20.3 35.12,101.83 R180.2 R181.2 36.83,101.59 R179.2
SSD_RST#: length 17.2
  IN1 w0.084: v1(48.79,116.49) 48.51,116.77 v2(48.51,117.06)
  IN3 w0.06: 56.18,117.73 59.48,117.73 59.63,117.58 59.63,117.31 59.75,117.19 60.32,117.19 60.45,117.06 60.5,117.01 62.19,117.01 62.32,116.88 62.66,116.88 62.77,116.77 62.94,116.77 63.04,116.88 63.25,116.88 v10(63.35,116.97)
  IN3 w0.084: v2(48.51,117.06) 48.97,117.06 49.14,117.22 49.67,117.22 49.79,117.11 51.92,117.11 52.44,117.63 53.42,117.63 53.81,118.02 54.61,118.02 54.79,117.85 54.79,117.57 54.92,117.44 55.85,117.44 56.15,117.73 56.18,117.73
