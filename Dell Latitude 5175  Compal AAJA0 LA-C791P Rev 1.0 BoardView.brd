# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3VALW on BOTTOM (solid shape): 197.06,100.44 197.06,99.3 197.1,99.25 197.79,99.25 198.12,98.92 198.12,98.24 197.89,98.01 196.06,98.01 195.77,98.31 195.77,100.37 195.94,100.54 196.96,100.54
+3VALW on BOTTOM (solid shape): 175.29,115.33 175.29,114.39 175.97,113.71 175.97,112.66 175.82,112.51 174.9,112.51 174.73,112.69 174.73,114.34 174.85,114.47 174.85,114.72 174.86,114.78 174.85,114.84 174.85,115.17 174.86,115.23 174.86,115.28 174.98,115.41 175.21,115.41
+3VALW on BOTTOM (solid shape): 181.13,109.62 181.13,108.14 181.12,108.14 181.12,104.7 180.89,104.46 180.07,104.46 179.77,104.16 179.77,103.2 179.67,103.1 178.65,103.1 178.52,103.23 178.52,103.8 178.78,104.05 178.92,104.05 179.91,105.04 179.91,105.2 180.32,105.61 180.32,107.96 180.1,108.18 179.63,108.18 179.3,108.51 179.3,109.93 179.4,110.04 180.71,110.04
+3VALW on BOTTOM (solid shape): 198.37,130.76 198.37,130.12 198.32,130.08 198.18,130.08 197.93,129.83 197.93,129.27 197.74,129.08 197.31,129.08 195.42,127.18 195.42,126.51 189.37,126.51 189.37,127.05 188.72,127.05 188.72,126.51 188.17,126.51 188.17,127.05 187.52,127.05 187.52,126.51 186.54,126.51 186.38,126.66 186.38,128.21 186.74,128.56 189.87,128.56 189.97,128.46 190.16,128.46 190.26,128.56 194.28,128.56 194.43,128.5 194.59,128.56 195.66,128.56 196.98,129.89 197.06,129.89 197.25,130.08 197.25,130.71 197.35,130.8 198.32,130.8
+3VALW on GND1 (solid shape): 190.02,126.25 190.02,125.87 189.74,125.59 189.05,125.59 189,125.54 189,125.39 188.95,125.34 188.95,124.6 188.85,124.5 187.4,124.5 186.89,125.01 186.89,126.05 187.3,126.46 189.81,126.46
+3VALW on IN1 (solid shape): 25.08,63.3 25.08,62.52 24.8,62.25 24.8,60.54 24.67,60.4 23.53,60.4 23.47,60.47 23.47,61.02 23.57,61.12 24.08,61.12 24.19,61.23 24.19,62.58 24.35,62.73 24.35,62.93 24.35,62.93 24.35,63.31 24.44,63.39 24.98,63.39
+3VALW on IN1 (solid shape): 205.51,127.6 205.51,126.45 204.3,125.25 204.3,124.44 204.62,124.12 204.91,124.12 204.97,124.06 204.97,123.89 204.96,123.89 204.96,122.35 204.16,121.55 187.43,121.55 186.94,122.04 186.94,126.38 187.12,126.56 189.98,126.56 190,126.54 191.54,126.54 191.79,126.43 192.04,126.54 201.43,126.54 202.79,127.9 205.21,127.9
+3VALW on IN3 (solid shape): 40.06,105.37 40.06,105.02 39.85,104.82 38.71,104.82 38.56,104.97 38.56,105.22 38.86,105.53 39.9,105.53
+3VALW on IN3 (solid shape): 190.03,127.19 190.03,125.81 189.9,125.68 186.99,125.68 186.89,125.78 186.89,126.1 186.74,126.25 186.54,126.25 186.28,126.51 186.28,127.22 186.42,127.35 189.87,127.35
+3VALW on GND3 (solid shape): 189.99,127.24 189.99,125.66 189.87,125.54 186.91,125.54 186.85,125.59 186.85,125.81 186.79,126.11 186.49,126.2 186.41,126.2 186.36,126.24 186.36,127.22 186.51,127.37 189.86,127.37
+3VALW on IN4 (solid shape): 30.54,84.25 30.54,84.08 29.23,82.77 28.2,82.77 27.83,83.14 27.83,83.49 28.89,84.55 30.24,84.55
+3VALW on IN4 (solid shape): 39.8,105.4 39.8,104.51 38.89,103.6 38.23,103.6 38.02,103.8 38.02,104.28 38.48,104.74 38.48,105.27 38.79,105.58 39.62,105.58
+3VALW on TOP: 32.41,61 31.01,61 30.95,60.94 30.95,60.56 31.01,60.49 31.65,60.49 31.9,60.24 31.9,59.86 32.09,59.67 33.24,59.67 33.36,59.79 33.36,60.05
+3VALW on TOP: 22.98,63.75 22.98,62.91 23.62,62.27 24.75,62.27 24.89,62.4 24.89,63.19 24.8,63.27 23.66,63.27 23.46,63.48 23.46,63.81 23.39,63.88 23.12,63.88
+3VALW on BOTTOM: 216.66,119.7 216.81,119.7 217.52,118.98 217.62,118.98 217.63,118.99 218.06,118.99 218.07,118.98 218.11,118.98 218.17,118.92 218.17,118.84 218.1,118.76 217.21,118.76 216.79,119.18 216.69,119.18 216.61,119.27 216.61,119.65
+3VALW on VCC: 99.24,101.23 99.22,101.26 99.01,101.26 98.98,101.23 52.6,101.26 52.33,101.26 48.39,105.2 37.64,105.2 37.64,105.62 38.61,106.59 52.37,106.59 54.78,104.18 61.83,104.18 62.47,103.55 63.57,103.55 63.82,103.8 100.16,103.8 102.59,106.23 102.59,116.72 102.92,117.06 118.18,117.06 121.88,113.36 121.88,112.83 122.54,112.17 127.96,112.17 128.46,112.68 142,112.68 145.19,115.86 161.17,115.86 162.08,116.78 162.08,119.32 162.44,119.67 177.17,119.67 183.14,125.64 193.72,125.64 198.25,121.12 198.25,111.32 192.63,105.76 192.45,105.58 168.66,105.58 166.5,107.74 160.4,107.74 159.92,108.22 159.92,112.41 159.13,113.2 149.09,113.2 148.36,112.46 148.36,107.59 147.82,107.05 134.04,107.05 132.57,105.58 128.92,105.58 128.92,106.56 128.26,107.22 117.81,107.22 116.29,108.73 116.29,110.25 116.32,110.28 116.31,112.82 114.63,114.49 108.91,114.49 106.12,111.7 106.12,105.89 104.57,104.36 104.57,101.54 104.26,101.23 ; 1 cut-out
+3VALW on IN1: 199.8,132.82 201,132.82 202.69,131.14 204.37,131.14 205.13,130.37 205.13,129.26 205.07,129.2 204.62,129.2 204.56,129.26 204.56,130.03 203.92,130.66 202.34,130.66 200.81,132.18 199.8,132.18 199.73,132.25 199.73,132.76
+3VALW on GND3: 38.7,105.6 39.95,105.6 40.13,105.43 40.13,104.87 39.97,104.7 38.65,104.7 38.48,104.87 38.48,105.39
+3VALW on IN4: 23.89,62.37 23.99,62.26 25.13,62.26 25.31,62.45 25.31,63.94 25.06,64.2 24.12,64.2 23.89,63.96
+3VALW_DSW on TOP (solid shape): 51.39,101.82 51.39,100.51 51.29,100.42 50.19,100.42 49.87,100.74 49.76,100.74 49.62,100.88 49.07,100.88 49.02,100.83 49.02,100.58 48.97,100.53 48.37,100.53 48.26,100.64 48.26,101.77 48.4,101.91 51.3,101.91
+3VALW_DSW on VCC (solid shape): 63.78,118.61 63.78,118.23 63.73,118.18 63.37,118.18 63.12,118.43 61.87,118.43 60.86,117.41 60.55,117.41 60.5,117.46 60.5,117.82 61.63,118.95 63.44,118.95
+3VALW_DSW on IN3 (solid shape): 50.67,101.25 50.67,99.73 50.55,99.61 50.14,99.61 50.01,99.74 50.01,101.18 50.26,101.42 50.5,101.42
+3VALW_DSW on TOP: 52.22,126.86 54.17,126.86 54.64,127.33 54.64,127.73 54.71,127.8 54.99,127.8 55.16,127.64 55.16,126.85 54.33,126.02 53.11,126.02 52.86,126.28 52.27,126.28 52.2,126.35 52.2,126.84
+3VALW_DSW on BOTTOM: 53.17,127.24 52.9,127.24 52.86,127.29 52.86,127.85 52.91,127.9 53.99,127.9 54.3,127.58 54.3,126.82 54.19,126.7 53.89,126.7 53.68,126.91 53.5,126.91
+3VALW_EC on TOP (solid shape): outline of 136 points within 186.54,126.28 198.76,141.95
+3VALW_EC on BOTTOM (solid shape): 187.81,142.51 188.47,142.51 188.65,142.69 192.86,142.69 193.5,142.05 193.5,140.85 189.32,140.85 188.32,141.85 186.64,141.85 186.54,141.95 186.54,142.66 186.56,142.69 187.63,142.69
+3VALW_EC on BOTTOM (solid shape): 199.24,129.61 199.11,129.48 198.73,129.48 198.7,129.5 198.7,131.23 198.42,131.51 197.32,131.51 197.27,131.46 196.14,131.46 195.76,131.84 195.76,132.17 194.97,132.96 194.88,132.96 194.82,132.97 194.77,132.96 194.38,132.96 194.32,132.97 194.23,132.96 194.16,133.04 194.16,133.29 194.26,133.39 194.45,133.39 194.49,133.35 195.42,133.35 195.43,133.36 195.55,133.36 195.96,132.95 196,132.95 196.06,132.88 196.6,132.88 196.67,132.81 196.67,132.32 196.7,132.32 196.77,132.25 197.92,132.25 197.99,132.32 197.99,133.06 198.09,133.16 198.35,133.16 198.42,133.23 198.42,134.38 198.32,134.48 197.99,134.48 197.92,134.56 197.92,135.12 197.97,135.17 198.55,135.17 198.83,135.45 198.83,135.5 199.24,135.5
+3VALW_EC on IN3 (solid shape): 194.66,130.02 194.66,129.58 194.01,128.93 194.01,128.51 195.22,127.3 196.14,127.3 196.25,127.19 196.25,126.62 196.17,126.54 195.02,126.54 193.33,128.23 193.33,129.27 194.22,130.16 194.53,130.16
+3VALW_EC on IN4 (solid shape): 186.8,133.71 186.8,133.22 186.72,133.13 186.36,133.13 185.95,133.54 185.89,133.54 185.75,133.59 185.6,133.55 185.58,133.54 185.35,133.31 184.74,133.31 184.55,133.5 184.55,133.81 184.81,134.07 185.38,134.07 185.4,134.08 185.41,134.09 185.5,134.13 185.56,134.21 185.57,134.23 186.28,134.23
+3VALW_EC on IN4 (solid shape): outline of 97 points within 191.49,139.05 193.53,141.87
+3VALW_EC_L on TOP (solid shape): 197.05,134.43 197.05,133.39 196.98,133.31 195.81,133.31 195.15,133.97 193.7,133.97 193.6,134.08 193.6,134.38 193.75,134.53 196.95,134.53
+3VALW_PD on TOP (solid shape): 36.37,46.97 36.37,42.92 36.4,42.89 36.4,42.53 36.35,42.48 36.13,42.48 36.13,43.15 35.87,43.41 35.84,43.41 35.69,43.56 35.69,47.08 35.74,47.14 36.21,47.14
+3VALW_PD on TOP (solid shape): 41.4,44.37 41.4,43.83 41.08,43.51 40.35,43.51 39.75,42.92 39.55,42.92 39.42,42.79 39.42,42.66 39.32,42.56 39.14,42.56 39.06,42.64 39.06,42.74 39.12,42.79 39.12,43.09 39.57,43.55 39.8,43.55 40.18,43.93 40.18,44.52 41.25,44.52
+3VALWP on BOTTOM (solid shape): 188.07,126.41 188.82,126.41 188.82,126.91 189.27,126.91 189.27,126.41 192.27,126.41 192.53,126.15 192.53,124.07 193.27,123.33 193.27,120.82 192.99,120.54 192.18,120.54 191.91,120.27 185.84,120.27 185.19,120.92 185.19,126.13 185.52,126.45 186.45,126.45 186.5,126.41 187.62,126.41 187.62,126.91 188.07,126.91
+3VLP1 on BOTTOM (solid shape): 29.6,129.98 29.6,128.16 29.43,127.99 29.21,127.99 29.14,128.05 29.14,129.3 28.99,129.45 28.99,130.04 29.02,130.06 29.52,130.06
+3VS on TOP (solid shape): 23.19,32.72 23.19,32.26 23.07,32.14 21.6,32.14 21.48,32.27 21.48,32.74 21.63,32.88 23.03,32.88
+3VS on TOP (solid shape): 25.5,82.51 25.5,79.21 25.25,78.96 24.56,78.96 24.36,79.16 24.36,82.39 24.66,82.69 25.32,82.69
+3VS on TOP (solid shape): 211.67,134.09 211.67,133.9 211.55,133.78 209.31,133.78 209.18,133.91 209.18,134.11 209.28,134.21 211.55,134.21
+3VS on TOP (solid shape): 24.37,55.16 24.52,55 24.52,54.5 24.41,54.39 23.43,54.39 23.43,54.61 23.38,54.65 23.38,55.29 23.46,55.37 24.37,55.37
+3VS on TOP (solid shape): 24.49,49.02 24.54,48.97 24.54,48.59 24.37,48.43 24.37,48.25 23.41,48.25 23.23,48.44 23.23,49.02 23.44,49.24 24.49,49.24
+3VS on TOP (solid shape): 37.31,63.26 37.31,62.73 37.26,62.68 36.58,62.68 35.99,63.26 35.59,63.26 35.43,63.41 35.43,63.85 35.52,63.94 35.55,63.94 35.55,63.95 36.63,63.95
+3VS on TOP (solid shape): 41.86,60.14 41.86,58.16 41.78,58.08 41.45,58.08 41.38,58.16 41.38,59.71 41,60.09 40.72,60.09 40.59,60.21 40.59,60.34 40.64,60.39 41.6,60.39
+3VS on TOP (solid shape): 207.33,137.34 207.33,137.26 206.1,136.03 205.6,136.03 205.56,136.07 205.56,136.54 205.71,136.54 206.67,137.49 207.17,137.49
+3VS on TOP (solid shape): 45.49,105.3 45.49,104.38 45.11,104.38 44.93,104.21 44.93,100.46 44.86,100.38 43.33,100.38 42.84,100.87 42.84,104.97 43.18,105.31 43.8,105.31 43.81,105.32 45.47,105.32
+3VS on TOP (solid shape): 48.06,132.69 48.06,132.6 48.67,131.99 48.79,131.99 48.9,131.89 49.43,131.89 49.45,131.88 49.45,131.51 49.42,131.49 48.7,131.49 48.69,131.49 48.62,131.51 48.55,131.51 48.52,131.5 48.29,131.74 48.16,131.74 47.37,132.53 47.12,132.53 47.12,132.76 47.99,132.76
+3VS on BOTTOM (solid shape): 220.22,103.85 220.22,102.66 220.14,102.58 219.35,102.58 219.08,102.85 219.08,103.87 219.26,104.06 220.01,104.06
+3VS on BOTTOM (solid shape): 62.89,100.5 62.89,100.32 62.81,100.24 61.7,100.24 61.62,100.32 61.62,101.21 61.67,101.26 62.13,101.26
+3VS on BOTTOM (solid shape): 91.28,106.89 91.28,105.97 91.58,105.68 91.58,105.42 91.45,105.3 91.1,105.3 90.55,105.85 90.55,107.01 90.68,107.14 91.03,107.14
+3VS on BOTTOM (solid shape): 63.02,98.01 63.25,98.01 63.35,97.91 63.35,96.41 63.3,96.36 62.81,96.36 62.74,96.43 62.74,97.68 62.61,97.81 62.15,97.81 62.1,97.86 62.1,98.19 62.13,98.21 62.81,98.21
+3VS on BOTTOM (solid shape): 50.72,124.07 50.75,124.04 50.75,123.94 50.88,123.81 50.88,123.61 50.77,123.51 50.34,123.51 50.16,123.69 50.16,123.84 50.09,123.92 49.78,123.92 49.68,124.02 49.68,124.3 49.76,124.37 50.72,124.37
+3VS on BOTTOM (solid shape): 54.3,105.7 54.3,104.38 54,104.08 54,103.39 53.95,103.34 53.64,103.34 53.57,103.42 53.57,103.88 53.49,103.95 53.21,103.95 53.16,104 53.16,106.11 53.19,106.14 53.87,106.14
+3VS on BOTTOM (solid shape): 135.62,98.65 135.62,94.94 135.57,94.9 135.47,94.9 135.42,94.95 135.42,95.68 134.91,96.19 134.91,97.18 135.42,97.69 135.42,98.68 135.43,98.69 135.57,98.69
+3VS on BOTTOM (solid shape): 50.13,96.54 50.13,95.92 49.66,95.45 48.85,95.45 48.78,95.51 48.78,95.65 48.89,95.76 48.89,96.2 48.97,96.28 49.61,96.28 49.92,96.59 50.07,96.59
+3VS on BOTTOM (solid shape): 49.4,130.47 49.4,130.22 49.4,130.21 49.4,129.63 49.48,129.55 49.48,128.95 49.43,128.89 49.22,128.89 49.14,128.82 49.14,128.24 49.25,128.14 49.63,128.14 49.63,128.13 49.63,127.76 49.63,127.76 48.69,127.76 48.69,128.69 48.82,128.82 48.82,130.47 48.89,130.55 49.33,130.55
+3VS on BOTTOM (solid shape): 55.73,113.13 55.73,112.08 55.68,112.03 55.37,112.03 55.35,112.05 54.15,112.05 54.1,112 54.1,110.34 54.06,110.3 53.68,110.3 53.62,110.35 53.62,112.72 53.67,112.77 54,112.77 54.05,112.72 54.05,112.54 54.1,112.49 55.07,112.49 55.14,112.56 55.14,112.89 55.27,113.02 55.27,113.17 55.69,113.17
+3VS on GND1 (solid shape): 135.66,96.47 135.66,95.55 135.36,95.25 133.83,95.25 133.69,95.4 133.69,95.86 134.55,96.73 135.41,96.73
+3VS on GND1 (solid shape): 101.88,95.51 101.88,94.94 101.8,94.86 99.59,94.86 99.33,95.11 99.33,95.65 99.44,95.75 101.64,95.75
+3VS on GND1 (solid shape): 85.24,96.59 85.24,96.36 83.97,95.09 83.18,95.09 83.1,95.18 83.1,95.48 83.18,95.57 83.44,95.57 84.61,96.74 85.09,96.74
+3VS on IN1 (solid shape): 134.03,102.1 134.03,101.55 133.96,101.49 132.81,101.49 132.72,101.58 132.72,101.92 133.06,102.27 133.85,102.27
+3VS on IN1 (solid shape): 194.82,99.58 194.82,98.85 194.74,98.77 193.83,98.77 193.62,98.97 193.62,99.2 194.09,99.67 194.73,99.67
+3VS on IN1 (solid shape): 207.04,136.79 207.04,133.55 206.93,133.44 206.13,133.44 206.02,133.56 206.02,136.87 206.12,136.97 206.86,136.97
+3VS on IN1 (solid shape): 24.45,42.36 24.45,41.73 24.27,41.56 21.42,41.56 21.3,41.68 21.3,42.4 21.73,42.83 23.98,42.83
+3VS on IN1 (solid shape): 101.88,95.11 101.88,94.94 101.8,94.86 99.81,94.86 99.35,95.32 99.35,95.64 99.4,95.69 101.3,95.69
+3VS on IN1 (solid shape): 85.28,96.63 85.28,96.4 83.95,95.07 83.2,95.07 83.08,95.19 83.08,95.49 84.36,96.76 85.15,96.76
+3VS on IN1 (solid shape): 135.69,95.9 135.69,95.2 135.53,95.03 134.14,95.03 133.6,95.57 133.6,95.93 134.4,96.73 134.86,96.73
+3VS on IN1 (solid shape): 51.26,117.09 51.26,116.27 51.12,116.13 50.7,116.13 50.53,116.29 50.5,116.33 50.47,116.36 50.43,116.4 50.32,116.4 49.5,116.4 49.08,116.82 49.08,117.04 49.29,117.25 51.09,117.25
+3VS on IN2 (solid shape): 101.58,95.59 101.58,95.39 101.39,95.2 99.44,95.2 97.78,96.85 85.56,96.85 83.69,94.98 83.42,94.98 83.12,95.28 83.12,96.38 85.6,98.86 98.32,98.86
+3VS on IN2 (solid shape): 135.94,100.22 135.94,95.75 135.67,95.48 134.39,95.48 134.26,95.61 134.26,96.42 134.44,96.6 134.44,97.4 134.42,97.42 134.42,99.43 133.11,100.74 133.11,101.6 133.1,101.61 133.1,102.15 133.25,102.31 133.86,102.31
+3VS on IN2 (solid shape): 23.52,52.27 23.52,51.26 22.64,50.37 22.64,42.48 22.9,42.21 22.9,35.14 22.9,35.08 22.9,35.02 22.9,33.22 22.9,33.21 23.06,33.06 23.06,32.43 22.92,32.3 22.19,32.3 22.01,32.47 22.01,32.99 22.03,33.01 22.03,40.57 21.12,41.49 21.12,51.81 21.82,52.51 23.28,52.51
+3VS on IN3 (solid shape): 135.67,96.6 135.67,95.6 135.58,95.51 134.42,95.51 134.31,95.61 134.31,96.14 134.56,96.39 134.56,96.55 134.73,96.73 135.55,96.73
+3VS on IN3 (solid shape): 98.81,95.67 101.26,95.67 101.31,95.62 101.31,95.31 101.24,95.25 100.94,95.25 100.94,95.24 98.66,95.24 98.54,95.36 98.54,95.64 98.59,95.69 98.78,95.69
+3VS on IN3 (solid shape): 51.51,123.47 51.51,122.98 51.44,122.91 50.68,122.91 50.6,122.95 50.58,123.04 50.59,123.19 50.52,123.33 50.29,123.43 50.06,123.33 49.69,123.33 49.39,123.03 49.04,123.03 48.94,123.13 48.94,123.34 49.5,123.9 51.08,123.9
+3VS on GND3 (solid shape): 135.67,96.62 135.67,95.67 135.48,95.48 134.65,95.48 134.26,95.86 134.26,96.08 134.54,96.36 134.54,96.55 134.73,96.74 135.56,96.74
+3VS on GND3 (solid shape): 99,95.8 101.28,95.8 101.35,95.72 101.35,95.37 101.26,95.28 98.34,95.28 98.2,95.42 98.2,95.77 98.37,95.94 98.86,95.94
+3VS on IN4 (solid shape): 49.73,131.66 49.73,130.55 49.44,130.25 48.88,130.25 48.87,130.27 48.34,130.27 48.21,130.39 48.21,130.62 48.67,131.08 48.77,131.14 48.83,131.24 49.4,131.82 49.58,131.82
+3VS on TOP: 48.09,116.8 47.98,116.9 47.98,117.36 48.08,117.45 51.49,117.45 52.09,116.85 52.78,116.85 52.93,116.7 52.93,116.22 52.7,115.99 52.11,115.99 51.47,116.63 50.6,116.63 50.43,116.8
+3VS on TOP: 131.67,112.82 133.54,112.82 133.71,112.65 133.71,105.22 133.73,105.2 133.73,102.81 134.14,102.4 134.14,101.69 133.96,101.51 132.82,101.51 132.71,101.62 132.71,102.25 132.7,102.26 132.7,111.36 132.11,111.95 131.72,111.95 131.6,112.08 131.6,112.74
+3VS on VCC: outline of 145 points within 24.66,52.3 222.88,134.99 ; 1 cut-out
+3VS on IN1: 118.62,113.02 122.2,113.02 122.81,112.41 122.81,109.87 123.09,109.59 124.54,109.59 126.44,111.5 127.79,111.5 129.11,112.82 131.93,112.82 132.05,112.69 132.05,111.93 131.93,111.8 131.19,111.8 129.18,109.79 126.95,109.79 125.37,108.22 118.72,108.22 118.21,108.73 118.21,112.61
+3VS on IN1: 23.24,48.21 22.43,49.02 22.43,52.31 22.42,52.32 22.42,58.43 23.57,59.59 23.58,59.59 23.68,59.68 23.7,59.67 28.68,59.67 28.76,59.75 28.88,59.75 29.04,59.9 29.37,59.9 29.47,59.8 29.47,58.89 28.99,58.4 27.36,58.4 27,58.76 23.82,58.76 23.42,58.36 23.42,55.52 24.06,55.52 24.31,55.27 24.31,52.15 23.7,51.54 23.7,49.52 24.15,49.07 24.15,48.43 23.93,48.21
+3VS on IN3: 48.23,99.68 48.23,101.69 48.74,102.2 49.51,102.2 49.63,102.08 49.63,99 49.12,98.49 49.12,95.52 49,95.39 47.57,95.39 47.12,95.85 47.12,98.57
+3VS_AUDIO on TOP (solid shape): 6.71,119.64 6.71,119.42 6.59,119.3 6.42,119.3 6.06,119.66 4.67,119.66 4.64,119.69 4.64,120.09 4.72,120.16 6.19,120.16
+3VS_AUDIO on TOP (solid shape): 30.97,86.33 30.97,85.81 31.09,85.68 31.78,85.68 32.05,85.94 32.69,85.94 32.77,85.87 34.19,85.87 34.24,85.82 34.24,85.46 34.09,85.31 34.09,83.71 34.06,83.68 33.93,83.68 33.58,84.04 33.58,84.9 33.45,85.03 33.07,85.03 32.95,85.15 30.83,85.15 30.67,85.32 30.67,86.36 30.71,86.41 30.89,86.41
+3VS_AUDIO on BOTTOM (solid shape): 109.55,131.78 109.55,131 109.52,130.98 108.33,130.98 108.19,131.12 108.19,132.02 108.25,132.08 109.25,132.08
+3VS_AUDIO on BOTTOM (solid shape): 122.26,131.37 122.26,131.19 122.27,131.18 122.27,129.6 122.12,129.45 121.95,129.45 121.8,129.61 121.8,130.77 120.9,131.66 120.9,131.71 121.16,131.97 121.67,131.97
+3VS_AUDIO on IN4 (solid shape): 132.36,120.11 132.36,119.7 132.23,119.57 131.04,119.57 130.81,119.8 130.81,120.21 130.91,120.31 132.16,120.31
+3VS_CAM on TOP (solid shape): 146.6,131.42 146.6,130.7 146.55,130.65 145.81,130.65 145.77,130.69 145.77,130.81 145.68,130.9 144.81,130.9 144.79,130.92 144.79,131.5 144.84,131.55 146.47,131.55
+3VS_CAM on TOP (solid shape): 105.12,130.61 105.93,130.61 106.04,130.5 106.04,129.61 105.99,129.56 105.33,129.56 105.22,129.67 104.04,129.67 103.76,129.95 103.76,130.5 103.89,130.62 105.1,130.62
+3VS_CAM on BOTTOM (solid shape): 102.59,137.38 102.59,136.35 102.51,136.27 101.36,136.27 101.35,136.29 100.75,136.29 100.61,136.43 100.61,137.39 100.7,137.48 102.49,137.48
+3VS_CAM on IN1 (solid shape): 146.84,131.62 146.88,131.59 146.88,131.23 146.31,130.66 145.8,130.66 145.71,130.75 145.71,131.16 146.17,131.62
+3VS_CAM on IN3 (solid shape): 102.11,136.49 102.43,136.49 102.49,136.43 102.49,136.34 102.34,136.18 100.89,136.18 100.61,136.46 100.61,137.15 100.67,137.21 101.38,137.21
+3VS_CAM on IN3 (solid shape): 105.05,130.31 105.05,129.33 104.85,129.12 104.24,129.12 103.76,129.61 103.76,130.98 104.01,131.23 104.14,131.23
+3VS_CAM on IN3 (solid shape): 147.12,131.53 147.12,130.77 147,130.66 146.05,130.66 145.69,131.02 145.69,131.55 145.77,131.63 147.02,131.63
+3VS_CAM on IN4 (solid shape): 146.97,131.17 146.97,130.86 146.96,130.85 146.96,130.29 146.81,130.14 146.3,130.14 146.11,130.33 146.11,130.81 145.87,131.05 145.87,131.26 145.92,131.31 146.84,131.31
+3VS_CR on TOP (solid shape): 218.23,124.41 218.23,121.4 218.07,121.24 217.58,121.24 216.46,122.36 210.31,122.36 209.96,122.71 209.96,123.64 210.1,123.79 210.1,124.78 210.18,124.87 217.77,124.87
+3VS_CR on BOTTOM: 216.84,122.4 217.39,122.95 221.38,122.95 221.88,122.45 221.88,119.48 221.57,119.17 220.59,119.17 220.53,119.23 220.53,119.23 220.53,120.12 220.84,120.42 220.84,121.35 220.68,121.51 218.25,121.51 217.95,121.21 217.95,120.39 218.17,120.17 218.17,119.23 218.11,119.17 217.51,119.17 217.41,119.26 217.41,119.65 216.84,120.23
+3VS_HP on TOP (solid shape): 138.56,102.1 138.56,100.75 138.51,100.7 137.92,100.7 137.87,100.75 137.87,102.15 137.95,102.22 138.43,102.22
+3VS_HP on IN1 (solid shape): 140.54,107.56 140.54,107.3 138.66,105.43 136.5,105.43 135.32,104.24 135.31,104.24 135.05,103.99 135.05,103.14 135.67,102.53 136.39,102.53 136.98,101.94 137.27,101.94 137.59,101.62 140.08,101.62 140.31,101.39 140.31,100.9 140.22,100.82 139.81,100.82 139.81,100.82 138.97,100.82 138.94,100.84 136.93,100.84 136.38,101.39 136.17,101.59 135.88,101.88 135.22,101.88 134.61,102.49 134.61,102.5 134.23,102.87 134.23,104.23 136.09,106.09 138.38,106.09 139.95,107.66 140.44,107.66
+3VS_NFC on TOP (solid shape): 208.31,98.8 208.31,97.5 208.13,97.32 207.7,97.32 207.59,97.42 207.59,98.88 207.61,98.89 208.22,98.89
+3VS_NFC on TOP (solid shape): 212.75,100.75 212.75,100.15 212.59,99.99 212.05,99.99 211.99,99.93 211.99,98.67 211.94,98.62 210.72,98.62 210.62,98.72 210.62,99.99 210.6,100.01 210.6,100.2 210.69,100.29 211.51,100.29 212.03,100.8 212.7,100.8
+3VS_NFC on IN3 (solid shape): 213.86,99.11 213.86,98.64 213.71,98.48 213.62,98.48 213.53,98.39 208.72,98.39 208.5,98.18 208.5,96.85 208.36,96.7 207.78,96.7 207.73,96.75 207.73,98.44 208.51,99.21 213.75,99.21
+3VS_NFC on IN4 (solid shape): 213.85,99.22 213.85,98.78 213.62,98.54 208.36,98.54 208.25,98.64 208.25,98.92 208.65,99.32 213.75,99.32
+3VS_NFC on IN1: 207.64,98.75 208.23,99.33 211.53,99.33 211.92,98.94 211.92,98.73 211.28,98.08 208.93,98.08 208.18,97.34 207.78,97.34 207.64,97.48
+3VS_TPM on TOP (solid shape): 57.99,137.91 57.99,135.96 57.89,135.85 57.53,135.85 57.48,135.91 57.48,136.34 57.3,136.51 57.02,136.51 56.98,136.55 56.98,136.96 57.02,137 57.35,137 57.37,137.01 57.44,137.01 57.53,137.1 57.53,137.96 57.61,138.04 57.86,138.04
+3VS_TPM on IN1 (solid shape): 54.46,142.43 54.46,141.26 54.25,141.06 53.52,141.06 53.31,141.26 53.31,142.48 53.39,142.56 54.33,142.56
+3VS_TS on BOTTOM (solid shape): 174.68,100.04 174.68,98.05 174.62,98 174.44,98 174.37,98.06 174.37,98.95 173.91,99.41 173.68,99.41 173.37,99.72 173.37,100.11 173.53,100.27 174.45,100.27
+3VS_TS on BOTTOM (solid shape): 174.41,104.02 174.41,103.06 174.41,103.01 174.32,102.91 174.19,102.91 174.07,102.78 174.07,101.56 173.89,101.39 173.19,101.39 173.06,101.51 173.06,103.16 172.93,103.29 172.23,103.29 172.11,103.42 172.11,103.74 172.17,103.8 172.62,103.8 172.87,104.05 174.38,104.05
+3VS_TS on IN4 (solid shape): 174.45,100.98 174.45,100.19 174.27,100.02 173.53,100.02 173.23,100.32 173.23,101.5 173.33,101.6 173.82,101.6
+3VS_WLAN on TOP (solid shape): 46.11,139.19 45.75,139.19 45.58,139.02 45.58,137.97 46.02,137.53 46.02,136.85 45.9,136.72 43.89,136.72 43.69,136.92 43.69,138.39 43.76,138.47 44.17,138.47 44.25,138.55 44.25,139.54 44.53,139.82 44.53,140.32 44.65,140.45 46.11,140.45
+3VS_WLAN on BOTTOM (solid shape): 48.11,153.08 48.11,151.75 47.84,151.49 47.71,151.49 47.7,151.5 43.79,151.5 42.74,150.45 42.74,142.29 46.13,138.9 46.13,134.97 46.3,134.79 47.85,134.79 48.01,134.64 48.01,133.57 47.95,133.52 44.73,133.52 43.71,134.53 43.71,137.16 39.8,141.07 39.8,150.54 42.8,153.53 47.65,153.53
+3VS_WLAN on GND1 (solid shape): 45.2,140.4 45.29,140.34 45.24,139.91 45.52,139.74 45.52,138.55 45.24,138.27 44.27,138.27 44.14,138.39 44.14,138.88 44.26,138.99 44.26,139.85 44.81,140.4
+3VS_WLAN on IN1 (solid shape): 45.2,140.4 45.29,140.34 45.24,139.91 45.52,139.74 45.52,138.55 45.24,138.27 44.27,138.27 44.14,138.39 44.14,139.74 44.81,140.4
+3VS_WLAN on IN3 (solid shape): 45.92,139 45.92,137.78 45.52,137.78 44.6,138.7 44.6,139.51 44.75,139.66 45.26,139.66
+3VS_WLAN on GND3 (solid shape): 45.67,139.33 45.67,138.14 45.57,138.04 44.42,138.04 44.3,138.17 44.3,139.03 44.93,139.66 45.34,139.66
+3VS_WWAN on TOP (solid shape): 213.23,144.48 213.23,142.41 213.61,142.03 213.61,125.39 213.34,125.12 211.5,125.12 211.33,125.29 211.33,126.05 211.28,126.1 210.79,126.1 210.69,126.2 210.69,126.69 210.57,126.81 210.16,126.81 210.11,126.87 210.11,128.46 209.2,129.37 208.71,129.9 207.99,129.99 207.86,129.95 207.74,129.9 207.15,129.9 206.58,130.47 206.58,131.7 206.63,131.75 206.92,131.75 207.02,131.65 207.02,131.4 207.03,131.4 207.03,131.09 207.34,130.78 208.87,130.78 209.31,130.34 210.9,130.34 211.91,131.36 211.91,134.99 211.73,135.17 211.51,135.17 211.45,135.22 211.45,135.92 211.78,136.25 211.78,138.78 211.56,139.01 211.56,141.3 210.79,142.07 210.16,142.07 210.07,142.15 210.07,143.8 210.08,143.8 210.08,144.44 210.25,144.61 213.1,144.61
+3VS_WWAN on BOTTOM (solid shape): 212.95,131.08 212.95,129.86 212.83,129.73 209.83,129.73 209.68,129.88 209.68,131.08 209.76,131.16 212.88,131.16
+3VS_WWAN on BOTTOM (solid shape): 212.8,148.1 212.8,143.73 212.62,143.54 211.59,143.54 211.42,143.71 211.42,147.14 211.3,147.26 209.68,147.26 209.58,147.36 209.58,148.1 209.7,148.22 212.67,148.22
+5V_DOCK on TOP (solid shape): 152.35,101.79 152.35,100.45 152.25,100.35 151.18,100.35 151.05,100.47 151.05,101.41 151.21,101.56 151.21,101.74 151.3,101.84 152.31,101.84
+5V_DOCK on BOTTOM (solid shape): 152.48,103.22 152.48,102.33 152.45,102.3 150.22,102.3 150.11,102.4 150.11,103.11 150.39,103.39 152.3,103.39
+5V_DOCK on BOTTOM (solid shape): 137.24,101.64 137.24,100.84 136.44,100.04 136.44,94.9 136.39,94.85 135.9,94.85 135.8,94.95 135.8,100.8 136.85,101.86 137.02,101.86
+5V_DOCK on IN1 (solid shape): 152.53,100.85 152.53,100.4 152.43,100.29 151.23,100.29 151.1,100.42 151.1,100.83 151.28,101.01 152.37,101.01
+5V_DOCK on IN3 (solid shape): 152.55,102.48 152.55,100.45 152.43,100.32 151.76,100.32 151.18,100.9 151.18,102.35 151.43,102.61 152.43,102.61
+5V_USB_P1 on BOTTOM (solid shape): outline of 92 points within 11.24,36.82 23.45,46.8
+5V_USB_P1 on TOP: 25.55,62.91 26.38,62.91 26.57,62.72 26.57,60.62 26.29,60.34 25.38,60.34 25.3,60.43 25.3,62.65
+5V_USB_P1 on IN4: 25.91,47.39 15.77,37.24 15.32,37.24 15.28,37.2 11.54,37.2 11.25,37.5 11.25,39.97 11.93,40.65 13.99,40.65 17.16,43.82 17.24,43.82 17.24,43.92 17.27,43.95 17.27,44.18 17.92,44.83 18.15,44.83 22.9,49.58 22.9,59.92 23.73,60.75 23.73,60.76 24.67,61.7 25.32,61.7 25.5,61.88 25.5,62.14 25.64,62.28 26.4,62.28 26.56,62.13 26.56,59.78 25.91,59.13
+5VALW on TOP (solid shape): 215.32,106.11 215.32,104.94 215.25,104.87 214.37,104.87 214.25,104.98 214.25,106.32 214.39,106.46 214.97,106.46
+5VALW on TOP (solid shape): 43.59,33.93 43.59,33.12 43.44,32.97 41.81,32.97 41.7,33.07 41.7,34.03 41.76,34.08 43.44,34.08
+5VALW on TOP (solid shape): 151.82,107.71 151.82,107.23 152.09,106.95 152.09,106.06 152.02,105.98 151.36,105.98 151.28,106.06 151.28,106.95 151.22,107.01 151.22,107.66 151.32,107.76 151.76,107.76
+5VALW on TOP (solid shape): 28.57,113.77 28.57,113.52 28.74,113.35 28.74,112.4 28.66,112.32 28.04,112.32 27.99,112.37 27.99,112.93 27.98,112.94 27.98,113.87 28,113.9 28.45,113.9
+5VALW on TOP (solid shape): 195.97,102.35 196.16,102.35 196.62,101.88 196.62,101.32 196.11,100.82 196.11,99.42 195.89,99.2 195.89,98.37 195.86,98.34 195.35,98.34 195.22,98.47 195.22,102.17 195.4,102.35 195.96,102.35
+5VALW on BOTTOM (solid shape): 26.44,92.51 26.44,91.35 26.43,91.35 26.43,91.06 25.52,90.14 24.95,90.14 24.85,90.24 24.85,92.42 25.45,93.02 25.93,93.02
+5VALW on BOTTOM (solid shape): 69.14,97.5 69.14,96.94 69.47,96.61 69.47,95.95 69.42,95.9 68.73,95.9 68.62,96.01 68.62,96.73 68.78,96.89 68.78,97.53 68.83,97.58 69.06,97.58
+5VALW on BOTTOM (solid shape): 44.12,119.34 44.12,115.41 43.92,115.2 41.81,115.2 41.35,115.66 41.35,116.3 41.4,116.35 41.94,116.35 41.94,118.3 41.81,118.43 41.38,118.43 41.38,118.86 42.11,119.6 43.87,119.6
+5VALW on BOTTOM (solid shape): 72.64,97.5 72.64,97.04 72.92,96.76 72.92,95.98 72.85,95.9 72.19,95.9 72.1,95.99 72.1,96.65 72.29,96.84 72.29,97.53 72.34,97.58 72.57,97.58
+5VALW on BOTTOM (solid shape): 65.3,97.73 65.3,96.64 65.23,96.56 65.23,96.41 65.15,96.33 65.15,95.98 65.1,95.93 64.74,95.93 64.69,95.98 64.69,96.43 64.72,96.5 64.79,96.53 64.96,96.62 65.02,96.81 65.02,96.84 65.07,96.89 65.07,97.73 65.12,97.78 65.26,97.78
+5VALW on BOTTOM (solid shape): 20.97,61.61 20.97,59.57 20.78,59.38 20.57,59.38 20.49,59.41 20.47,59.49 20.47,59.52 20.47,60.06 20.24,60.29 20.01,60.06 20.01,59.52 20.01,59.49 19.99,59.41 19.91,59.38 18.88,59.38 18.71,59.55 18.71,61.57 18.88,61.75 20.83,61.75
+5VALW on IN1 (solid shape): 195.99,100.24 195.99,99.61 195.78,99.41 195.17,99.41 195.02,99.56 195.02,100.12 195.36,100.45 195.77,100.45
+5VALW on IN1 (solid shape): 69.81,96.78 70.68,96.78 71.02,97.12 72.15,97.12 72.28,97 72.28,96.43 64.73,96.43 64.68,96.47 64.68,97.08 64.75,97.14 69.45,97.14
+5VALW on IN4 (solid shape): 39.58,118.99 39.9,118.71 40.23,118.99 41.81,118.99 42.82,117.97 42.83,117.97 42.87,117.92 42.87,116.68 42.34,116.14 42.34,116.13 41.84,115.64 41.72,115.51 41.72,115.13 41.28,115.23 41.15,114.8 34.37,114.8 33.78,115.38 33.78,118.73 34.04,118.99
+5VALW on TOP: 152.68,124.72 152.4,124.44 152.4,123.41 152.21,123.22 151.18,123.22 151.09,123.31 151.09,128.14 151.32,128.36 152.55,128.36 152.68,128.23
+5VALW on TOP: 28.82,62.79 30,62.79 30.21,63.01 30.21,64.23 30.29,64.3 30.63,64.3 31.04,64.71 31.04,65.17 31.09,65.22 31.64,65.22 31.67,65.18 31.67,64.49 31.23,64.05 31.23,62.55 31,62.32 28.85,62.32 28.7,62.47 28.7,62.68
+5VALW on BOTTOM: 216.46,119.03 216.61,119.03 217.06,118.58 218.1,118.58 218.12,118.58 218.17,118.52 218.17,118.44 218.08,118.35 216.79,118.35 216.36,118.78 216.36,118.94
+5VALW on VCC: outline of 151 points within 16.69,25.59 206.15,145.33
+5VALW on IN1: 214.29,105.7 214.24,105.75 214.24,106.76 214.79,107.31 214.79,113.72 212.33,116.18 212.33,117.96 211.54,118.75 205.96,118.75 205.63,119.07 205.63,120.31 205.89,120.57 205.89,124.27 206.08,124.46 212.91,124.46 213.11,124.27 213.11,120.72 213.46,120.37 216.13,120.37 216.52,119.98 216.52,118.62 216.77,118.38 216.77,106.15 216.32,105.7
+5VALW_PD on TOP: 38.07,37.12 38.07,37.73 38.18,37.84 40.38,37.84 41.44,36.77 43.36,36.77 43.56,36.57 43.56,35.77 43.45,35.66 41.68,35.66 41.56,35.54 41.56,35.02 41.48,34.94 39.92,34.94 39.9,34.97 39.9,35.73 39.59,36.05 39.15,36.05
+5VALWP on TOP (solid shape): 41.94,120.69 41.94,119.42 41.17,118.66 39.78,118.66 39.52,118.91 39.52,120.56 39.78,120.82 41.81,120.82
+5VALWP on BOTTOM (solid shape): 41.99,120.87 41.99,119.67 41.12,118.81 41.12,115.97 41.15,115.94 41.15,115.86 40.72,115.43 37.67,115.43 36.52,116.58 36.52,120.56 36.91,120.94 41.91,120.94
+5VLP on BOTTOM (solid shape): 28.98,121.61 28.98,120.64 28.68,120.33 28.68,119.47 28.52,119.32 28.37,119.32 28.31,119.38 28.31,121.59 28.39,121.68 28.91,121.68
+5VS on TOP (solid shape): 191.03,108.78 191.03,108.03 189.75,106.75 188.74,106.75 188.49,106.99 188.49,107.74 189.81,109.06 190.75,109.06
+5VS on TOP (solid shape): 148.5,125.58 148.5,124.51 148.5,124.49 148.4,124.39 147.5,124.39 147.27,124.16 146.04,124.16 145.95,124.25 145.95,125.59 146,125.64 148.44,125.64
+5VS on TOP (solid shape): 192.59,101.21 194.89,101.21 195.05,101.06 195.05,100.52 195.04,100.52 195.04,100.31 194.77,100.04 194.22,100.04 193.94,100.32 191.51,100.32 189.28,102.55 189.28,103.26 189.68,103.66 190.13,103.66
+5VS on BOTTOM (solid shape): 123.17,134.98 123.17,132.98 123.41,132.73 123.41,129.98 123.32,129.89 122.57,129.89 122.48,129.97 122.48,131.63 122.19,131.92 122.19,134.95 122.34,135.1 123.05,135.1
+5VS on GND1 (solid shape): 190.96,108.85 190.96,108.24 190.63,107.91 190.35,107.91 189.92,108.35 189.92,108.8 190.17,109.06 190.75,109.06
+5VS on GND1 (solid shape): 147.66,126.83 147.66,126.11 147.13,125.58 147.13,124.42 146.95,124.25 146.02,124.25 145.9,124.37 145.9,126.35 146.43,126.88 147.6,126.88
+5VS on IN1 (solid shape): 147.66,126.82 147.66,125.97 147.32,125.63 147.32,124.56 146.95,124.18 146.33,124.18 146.28,124.23 146.28,126.88 146.34,126.94 147.54,126.94
+5VS on IN2 (solid shape): 189.23,110.84 189.48,110.84 190.44,109.88 190.44,109.1 190.88,108.66 190.88,108.17 190.56,107.85 189.8,107.85 188.37,109.28 188.37,110.74 188.56,110.93 189.13,110.93
+5VS on IN2 (solid shape): 149.81,126.71 149.81,125.62 149.53,125.34 147.98,125.34 147.78,125.87 147.57,125.34 146.44,125.34 146.34,125.44 146.34,126.89 146.42,126.96 149.55,126.96
+5VS on IN3 (solid shape): 147.76,126.99 147.76,126.22 147.57,126.02 146.26,126.02 146.2,126.08 146.2,127 146.2,127.08 146.25,127.13 147.62,127.13
+5VS on GND3 (solid shape): 147.68,127.06 147.68,126.17 147.53,126.02 146.7,126.02 146.67,126.03 146.64,126.04 146.3,126.04 146.19,126.15 146.19,127.12 146.24,127.17 147.57,127.17
+5VS on VCC: 131.07,121.01 129.66,122.42 125.58,122.42 120.93,127.07 120.93,131.1 122.17,131.1 122.22,131.05 122.22,128 126.74,123.48 138.1,123.48 138.99,124.37 139,124.37 139.15,124.52 139.15,124.54 140.87,126.25 146.82,126.25 146.9,126.17 146.9,125.39 147.14,125.15 147.14,124.48 146.94,124.27 146.56,124.27 146.51,124.32 140.38,124.32 138.48,122.42 133.73,122.42 132.32,121.01
+5VS_AUDIO on TOP (solid shape): 42.62,88.16 42.62,86.94 42.5,86.82 40.1,86.82 39.85,87.07 37.92,87.07 37.91,87.06 37.88,87.09 33.24,87.09 33.17,87.16 33.17,88.16 33.64,88.64 42.14,88.64
+5VS_AUDIO on TOP (solid shape): 24.59,115.32 25.13,115.32 25.32,115.13 25.32,113.71 25.28,113.66 24.22,113.66 23.74,114.15 23.67,114.15 23.56,114.17 23.46,114.18 23.4,114.17 23.35,114.15 22.8,114.15 22.78,114.14 21.08,114.14 21.02,114.19 21.02,115.27 21.07,115.32 23.27,115.32 23.56,115.61 24.29,115.61
+5VS_AUDIO on BOTTOM (solid shape): 17.32,136.39 17.32,135.04 17.09,134.81 16.71,134.81 16.56,134.97 16.56,135.32 16.28,135.6 16.28,136.46 16.33,136.51 17.2,136.51
+5VS_AUDIO on BOTTOM (solid shape): 14.25,137.18 14.25,136.13 13.87,136.13 13.77,136.24 13.77,136.77 13.55,136.98 12.74,136.98 12.67,137.05 12.67,137.63 12.73,137.68 13.74,137.68
+5VS_AUDIO on GND1 (solid shape): 33.8,87.98 33.8,87.39 33.74,87.33 31.98,87.33 31.94,87.38 31.94,87.7 31.84,87.8 31.84,87.99 32.08,88.24 32.08,88.33 32.25,88.49 33.29,88.49
+5VS_AUDIO on IN1 (solid shape): 33.84,88.03 33.84,86.93 33.77,86.87 32.46,86.87 32.1,86.87 31.96,87.01 31.96,87.72 31.88,87.8 31.88,88.06 31.94,88.12 31.95,88.12 32.31,88.48 33.39,88.48
+5VS_AUDIO on IN2 (solid shape): 18.12,136.11 18.12,133.49 17.98,133.35 16.13,133.35 16.07,133.41 16.07,136.06 16.33,136.32 17.9,136.32
+5VS_AUDIO on IN2 (solid shape): 21.66,115.42 21.66,113.38 21.49,113.21 19.2,113.21 19.05,113.36 19.05,115.09 19.69,115.73 21.35,115.73
+5VS_AUDIO on IN2 (solid shape): 21.14,106.59 21.14,104.28 21.06,104.2 19.67,104.2 18.99,104.88 18.99,106.71 19.11,106.84 20.89,106.84
+5VS_AUDIO on IN3 (solid shape): 33.42,88.36 33.42,87.12 33.15,86.85 31.08,86.85 30.75,87.17 30.75,88.96 31.02,89.22 32.55,89.22
+5VS_AUDIO on IN3 (solid shape): 20.73,105.25 21.5,105.25 22.37,104.37 22.37,102.24 22.21,102.07 20.54,102.07 20.35,102.26 20.35,104.06 20.12,104.3 20.12,105.04 20.32,105.25 20.73,105.25
+5VS_AUDIO on IN3: 15.27,134.91 15.12,135.06 14.31,135.06 10.57,138.8 10.57,140.58 10.66,140.68 12.39,140.68 14.66,138.41 14.66,137.89 15.99,136.56 17.21,136.56 17.4,136.37 17.4,135.13 17.23,134.96 15.87,134.96 15.82,134.91
+5VS_NFC on TOP (solid shape): 213.79,98.4 213.79,97.42 213.64,97.27 212.32,97.27 212.19,97.4 212.19,98.03 212.28,98.12 212.61,98.12 212.77,98.29 212.77,98.39 212.82,98.45 213.75,98.45
+5VS_NFC on IN1 (solid shape): 212.85,97.91 212.85,97.2 212.85,97.19 212.85,95.36 212.69,95.21 212.37,95.21 212.22,95.37 212.22,97.94 212.31,98.04 212.72,98.04
+AVDD1 on BOTTOM (solid shape): 11.91,136.72 11.91,136.08 11.84,136.01 11.43,136.01 11.33,135.91 11.33,135.22 11.07,134.97 11.07,133.34 11.05,133.31 10.92,133.31 10.87,133.36 10.87,134.42 10.82,134.48 10.82,134.48 10.77,134.53 10.77,136.62 10.92,136.77 11.86,136.77
+AVDD1 on IN4 (solid shape): 10.59,138.8 10.59,138.27 11.53,137.33 11.53,136.41 11.46,136.34 11,136.34 10.97,136.36 10.97,137.15 10.08,138.04 10.08,138.85 10.13,138.9 10.49,138.9
+AVDD2 on BOTTOM (solid shape): 10.58,123.83 10.58,122.99 10.28,122.7 10.28,122.19 10.25,122.16 9.73,122.16 9.7,122.19 9.7,122.73 9.32,123.11 9.32,123.69 9.54,123.91 10.5,123.91
+AVDD2 on BOTTOM (solid shape): 11.84,127.09 11.84,125.39 11.33,124.88 11.33,124.45 11.3,124.42 10.64,124.42 10.57,124.5 10.57,124.78 10.77,124.98 10.77,124.98 11.65,125.86 11.65,127.11 11.68,127.14 11.79,127.14
+DVDD on TOP (solid shape): 20.83,130.57 20.83,130.42 21.21,130.04 22.25,130.04 22.38,129.91 22.38,129.1 22.33,129.05 21.77,129.05 21.41,129.4 20.78,129.4 20.55,129.63 20.17,129.63 20.07,129.73 20.07,130.62 20.14,130.7 20.7,130.7
+DVDD on BOTTOM (solid shape): 20.84,128.76 20.84,128.19 20.99,128.03 21.24,128.03 21.43,127.84 21.43,127.55 21.31,127.43 20.81,127.43 20.55,127.17 20.03,127.17 19.96,127.23 19.96,127.74 20.03,127.8 20.25,127.8 20.37,127.92 20.37,128.77 20.42,128.82 20.78,128.82
+DVDD on IN1 (solid shape): 20.8,130.5 20.8,129.91 20.57,129.68 18.87,129.68 18.66,129.9 18.66,130.23 19.05,130.62 20.68,130.62
+DVDD on IN3 (solid shape): 19.1,130.26 19.1,129.71 19.75,129.06 21.09,129.06 21.66,128.49 21.66,128.02 21.24,127.61 20.96,127.61 20.85,127.72 20.85,127.8 20.63,128.01 20.52,128.01 20.19,128.35 19.92,128.35 19.75,128.52 19.66,128.7 19.48,128.79 18.37,129.89 16.81,129.89 16.75,129.95 16.75,130.46 16.84,130.55 18.82,130.55
+PVDD on TOP (solid shape): 40.92,80.36 40.92,79.92 40.41,79.92 39.95,80.38 38.86,80.38 38.79,80.46 38.79,80.56 38.84,80.61 40.67,80.61
+PVDD on TOP (solid shape): 42.75,82.62 42.75,81.85 42.65,81.75 42.01,81.75 41.99,81.78 41.99,82.24 41.83,82.39 41.25,82.39 41.12,82.26 41.12,81.88 41.07,81.83 40.67,81.83 40.44,81.6 38.89,81.6 38.81,81.68 38.81,81.73 38.87,81.79 40.12,81.79 41.17,82.84 42.52,82.84
+PVDD on IN1 (solid shape): 41.25,85.82 41.25,83.05 41.63,82.67 42.26,82.67 42.37,82.57 42.37,82.24 41.63,81.5 41.63,80.1 41.35,79.82 40.46,79.82 40.16,80.13 40.16,85.59 40.56,85.99 41.07,85.99
+VBUS1 on TOP (solid shape): 34.02,30.98 34.02,30.31 34.34,29.99 35.84,29.99 35.92,29.91 35.92,29.2 35.74,29.02 35.05,29.02 34.76,28.73 32.91,28.73 32.64,29 32.64,29.87 32.73,29.96 32.73,30.97 32.85,31.09 33.91,31.09
+VBUS1 on TOP (solid shape): 15.39,23.41 15.39,21 14.97,20.58 14.64,20.58 14.64,20.56 11.35,17.27 11.35,14.62 11.15,14.42 9.19,14.42 8.95,14.65 7.66,14.65 7.42,14.42 6.63,14.42 6.5,14.56 6.5,15.07 6.56,15.13 7.18,15.13 7.35,14.96 8.63,14.96 9.15,15.48 9.22,15.48 9.72,15.99 9.72,16.33 9.79,16.39 9.79,16.48 10.23,16.74 9.9,17.12 9.81,17.21 9.54,17.21 9.42,17.24 9.31,17.21 8.64,17.21 8.58,17.15 7.61,17.15 7.4,16.94 6.6,16.94 6.45,17.09 6.45,17.43 6.76,17.73 7.3,17.73 7.58,17.45 8.72,17.45 9.09,17.83 9.09,18.89 9.81,19.6 10.24,19.48 10.12,19.91 13.67,23.46 15.33,23.46
+VBUS1 on BOTTOM (solid shape): 36.88,29.68 36.88,29.33 36.15,28.6 33.11,28.6 32.65,29.06 32.65,29.74 32.89,29.99 36.58,29.99
+VBUS1 on IN4 (solid shape): 36.55,29.38 36.55,26.89 36.19,26.53 28.45,26.53 24.94,23.03 15.27,23.03 13.94,21.71 12.86,21.71 12.7,21.87 12.7,22.68 14.97,24.96 15.56,24.96 15.89,25.29 21.89,25.29 26.44,29.83 36.09,29.83
+VBUS1 on BOTTOM: 22.78,22.9 15.01,22.9 14.76,22.65 14.76,21.83 14.52,21.59 12.88,21.59 12.76,21.71 12.76,23 13.98,24.23 14.27,24.23 15.08,25.04 15.88,25.04 15.93,25.09 22.89,25.09 23.27,24.7 23.27,23.38
+VBUS1 on IN2: 9.87,19.85 9.8,20.37 9.75,20.45 9.78,20.53 12.78,23.53 14.28,23.53 14.53,23.28 14.53,21.71 10.05,17.23 10.05,17.22 10.02,17.15 9.94,17.12 9.58,16.79 9.94,16.46 10.02,16.44 10.05,16.36 10.05,14.89 9.64,14.49 6.64,14.49 6.63,14.53 6.6,14.64 6.55,14.74 6.55,14.76 6.55,14.94 6.58,14.99 6.73,15.14 7.05,15.14 7.14,15.17 7.21,15.12 7.81,15.21 7.34,15.6 7.24,15.6 7.19,15.69 7.19,16.79 7.03,16.95 6.63,16.95 6.62,16.99 6.57,17.11 6.5,17.22 6.49,17.25 6.5,17.28 6.64,17.64 6.52,17.99 6.49,18.03 6.82,18.35 7.6,18.35 9.19,19.94 9.27,19.97 9.35,19.92 ; 1 cut-out
+VBUS1_IN on TOP (solid shape): 18.03,21.96 18.03,18.1 17.68,17.74 16.26,17.74 16.03,17.97 16.03,20.01 16.05,20.03 16.05,22.04 16.2,22.19 17.81,22.19
+VBUS1_IN on TOP (solid shape): 43.21,42.76 43.21,38.14 42.82,38.14 42.62,37.94 42.62,37.44 42.53,37.35 42.03,37.35 41.96,37.42 41.96,38.27 41.88,38.36 40.58,38.36 39.97,38.97 39.59,38.97 39.47,39.08 39.47,39.33 39.34,39.46 39.14,39.46 39.04,39.56 39.04,39.79 39.13,39.88 39.38,39.88 39.5,39.99 39.5,40.21 39.65,40.36 39.81,40.36 40.07,40.62 41.48,40.62 41.94,41.07 41.94,42.84 42.01,42.92 43.05,42.92
+VBUS1_IN on IN1 (solid shape): 43.77,41.13 43.77,29.83 43.75,29.77 43.47,29.63 43.38,29.4 39.34,25.36 32.79,25.36 23.88,16.45 16.38,16.45 15.96,16.87 15.96,19.01 16.28,19.32 22.65,19.32 31.62,28.29 31.62,29.17 31.86,29.41 32.23,29.41 32.43,29.2 32.43,28.28 32.78,27.93 37.74,27.93 40.79,30.98 40.79,39.06 43.1,41.37 43.54,41.37
+VBUS1_PD on TOP (solid shape): 35.89,38.27 35.89,37.94 36.02,37.81 36.25,37.81 36.35,37.71 36.35,37.41 36.35,37.4 36.35,37.17 35.64,36.46 35.64,34.92 35.59,34.86 34.95,34.86 34.8,35.02 34.8,35.22 34.65,35.37 34.04,35.37 33.82,35.16 33.82,34.38 34.52,33.68 34.52,32.3 34.14,31.92 32.97,31.92 32.92,31.97 32.92,33.04 33.02,33.14 33.32,33.14 33.45,33.26 33.45,33.92 33.3,34.08 33.08,34.08 32.73,34.43 32.73,37.55 32.75,37.57 33.2,37.57 33.45,37.32 33.89,37.32 33.97,37.4 34.87,37.4 35.03,37.56 35.03,37.76 35.13,37.86 35.36,37.86 35.51,38.01 35.51,38.32 35.56,38.37 35.79,38.37
+VBUS1_PD on IN1 (solid shape): 36.85,38.89 36.92,38.9 37.27,38.9 37.35,38.89 37.42,38.9 37.77,38.9 37.85,38.89 37.92,38.9 38.27,38.9 38.35,38.89 38.42,38.9 38.77,38.9 38.85,38.89 38.92,38.9 39.32,38.9 39.85,38.37 39.85,38.06 39.75,37.96 39.22,37.96 39.03,38.15 39.03,38.36 38.89,38.5 35.97,38.5 35.81,38.34 35.81,37.18 35.76,37.12 35.24,37.12 35.08,37.28 35.08,38.43 35.56,38.9 36.77,38.9
+VCC_CORE on TOP (solid shape): 73.1,119.42 73.1,112.56 73.08,112.54 73.08,112.38 73.27,112.19 76.9,112.19 77.06,112.36 80.92,112.36 81.09,112.54 84.84,112.54 86.72,112.54 87.17,112.08 90.14,112.08 93.26,115.19 101.6,115.19 101.94,114.85 101.94,111.79 101.12,110.96 97.52,110.96 97.37,111.12 95.55,111.12 94.72,110.28 93.3,110.28 92.01,108.99 89.4,108.99 89.22,108.81 89.22,108.7 88.43,108.7 87.92,109.21 71.93,109.21 70.13,111.01 70.13,111.16 72.36,111.16 72.36,110.69 72.5,110.56 77.56,110.56 77.65,110.64 77.65,111.08 77.54,111.19 72.97,111.19 72.91,111.24 72.45,111.24 72.36,111.16 70.13,111.16 70.13,111.39 70.18,111.45 72.21,111.45 72.39,111.62 72.39,112.64 72.59,112.84 72.59,119.42 72.69,119.52 73,119.52
+VCC_CORE on BOTTOM (solid shape): 102.41,118.75 102.41,114.91 102.15,114.66 99.99,114.66 99.57,115.07 99.57,118.57 99.9,118.89 102.26,118.89
+VCC_CORE on BOTTOM (solid shape): 79.12,113.18 79.12,113.09 78.94,112.9 78.94,112.68 79.09,112.52 79.09,112.41 78.88,112.2 78.88,112.05 79.09,111.83 79.09,111.76 79.02,111.68 78.91,111.68 78.67,111.92 78.63,111.98 78.55,112.05 78.36,112.05 78.29,111.98 78.15,111.98 78.07,112.05 77.85,112.05 77.81,112.01 77.67,112.01 77.6,112.07 77.6,112.17 77.78,112.35 77.78,112.59 77.6,112.77 77.6,112.83 77.81,113.04 77.81,113.18 77.91,113.28 78.04,113.28 78.12,113.19 78.32,113.19 78.4,113.27 78.53,113.27 78.61,113.19 78.81,113.19 78.9,113.28 79.03,113.28
+VCC_CORE on BOTTOM (solid shape): 80.17,113.14 80.75,113.14 80.85,113.04 80.85,112.42 82.05,111.22 87.03,111.22 89.89,110.7 92.11,112.58 95.11,112.58 95.2,112.49 95.2,109.93 94.98,109.71 94.47,109.71 94.45,109.73 91.82,109.73 91.16,109.07 87.51,109.07 87.21,108.78 82.13,108.78 81.42,109.49 80.12,109.49 79.94,109.31 79.6,109.31 79.53,109.37 79.53,113.09 79.58,113.14 80.17,113.14
+VCC_CORE on GND1 (solid shape): 102.29,116.47 102.29,114.06 101.96,113.73 98.37,113.73 98.12,113.99 98.12,116.5 98.32,116.7 102.06,116.7
+VCC_CORE on IN1 (solid shape): 102.36,117.52 102.36,115.13 102.23,115 98.09,115 97.56,115.53 97.56,117.49 97.84,117.77 102.11,117.77
+VCC_CORE on IN1 (solid shape): outline of 300 points within 69.29,111.41 79.57,120.34
+VCC_CORE on IN2 (solid shape): 102.46,116.63 102.46,115.11 102.28,114.92 98.37,114.92 98.15,115.15 98.15,116.65 98.27,116.78 102.31,116.78
+VCC_CORE on IN2 (solid shape): outline of 348 points within 69.32,111.74 79.55,120.44
+VCC_CORE on IN3 (solid shape): outline of 665 points within 69.29,108.93 102.82,120.35
+VCC_CORE on GND3 (solid shape): 95.26,112.48 95.26,109.84 95.09,109.67 91.5,109.67 91.33,109.84 91.33,111.46 92.48,112.61 95.14,112.61
+VCC_CORE on GND3 (solid shape): 72.62,116.3 72.62,115.84 72.57,115.79 72.42,115.79 72.11,116.09 69.44,116.09 69.34,116.19 69.34,116.3 69.42,116.37 72.54,116.37
+VCC_CORE on GND3 (solid shape): 101.79,118.41 101.79,116.76 102.36,116.18 102.36,115.1 102.21,114.96 98.58,114.96 98.21,115.33 98.21,116.58 98.32,116.69 99.63,116.69 99.95,117 99.95,118.48 100.05,118.58 101.62,118.58
+VCC_CORE on GND3 (solid shape): 72.24,120.26 72.54,120.26 72.62,120.18 72.62,119.17 72.57,119.12 72.44,119.12 72.36,119.19 72.36,119.95 72.31,120 69.47,120 69.39,120.08 69.39,120.18 69.47,120.26 71.93,120.26 71.98,120.31 72.19,120.31
+VCC_CORE on GND3 (solid shape): 73.35,112.13 76.78,112.13 76.83,112.18 77.09,112.18 77.2,112.07 77.2,111.76 77.06,111.62 73,111.62 72.42,112.21 71.48,112.21 71.37,112.31 71.37,112.51 71.45,112.59 71.53,112.59 71.62,112.61 71.63,112.61 72.03,112.61 72.04,112.61 72.87,112.61
+VCC_CORE on GND3 (solid shape): 79.5,112.79 79.5,109.46 79.32,109.29 79.12,109.29 79.07,109.34 79.07,110.84 78.87,111.04 78.87,111.39 78.9,111.5 78.87,111.61 78.87,111.7 78.61,111.95 77.77,111.95 77.37,112.36 77.37,112.72 77.57,112.92 79.37,112.92
+VCC_CORE on IN4 (solid shape): outline of 885 points within 69.31,109.29 103.37,120.31
+VCC_CORE on VCC: 73.99,104.31 73.69,104.62 73.69,105.94 69.7,109.87 69.51,109.87 69.51,112.56 69.18,112.89 69.18,120.64 69.34,120.8 72.01,120.8 72.57,120.25 73.81,120.25 73.9,120.16 73.9,113.04 74.22,112.73 82.14,112.73 82.14,112.69 82.29,112.54 87.23,112.54 91.77,117.08 101.72,117.08 102.08,116.72 102.08,106.44 99.95,104.31 ; 1 cut-out
+VCC_GT on TOP (solid shape): outline of 207 points within 73.99,113.07 102.87,124.69
+VCC_GT on BOTTOM (solid shape): 101.85,124.48 101.85,122.9 102.18,122.57 102.18,121.17 101.83,120.82 99.22,120.82 99.02,121.02 99.02,124.51 99.35,124.84 101.49,124.84
+VCC_GT on BOTTOM (solid shape): outline of 398 points within 72.78,112.63 95.25,118.57
+VCC_GT on GND1 (solid shape): 74.51,115.87 76.45,115.87 76.56,115.76 76.56,115.63 76.49,115.56 76.25,115.56 76.15,115.46 73.96,115.46 73.85,115.57 73.85,115.75 74.13,116.03 74.35,116.03
+VCC_GT on GND1 (solid shape): 76.62,114.68 76.62,114.47 76.49,114.34 75.79,114.34 75.68,114.23 75.25,114.23 75.15,114.33 74.51,114.33 74.39,114.22 74.1,114.22 73.85,114.48 73.85,114.61 74,114.77 76.54,114.77
+VCC_GT on GND1 (solid shape): 75.95,113.67 76.59,113.67 76.61,113.65 76.61,113.22 76.56,113.17 74.9,113.17 74.88,113.19 73.91,113.19 73.81,113.29 73.81,113.52 73.93,113.64 74.84,113.64 74.93,113.73 75.65,113.73 75.68,113.76 75.86,113.76
+VCC_GT on GND1 (solid shape): 74.52,116.95 74.92,116.95 74.98,117.01 77.69,117.01 77.84,116.87 77.84,116.75 77.76,116.67 76.44,116.67 76.34,116.57 75.48,116.57 75.37,116.6 75.27,116.57 73.95,116.57 73.82,116.7 73.82,116.9 74.14,117.21 74.26,117.21
+VCC_GT on GND1 (solid shape): 75.55,118.1 75.95,118.1 76.07,118.22 76.58,118.22 76.67,118.13 77.79,118.13 77.85,118.07 77.85,117.89 77.81,117.85 76.31,117.85 76.15,117.7 74.47,117.7 74.39,117.78 74.23,117.78 74.14,117.69 73.97,117.69 73.84,117.82 73.84,117.98 74.08,118.22 74.42,118.22 74.53,118.12 74.99,118.12 75.1,118.23 75.42,118.23
+VCC_GT on GND1 (solid shape): 77.4,119.42 77.4,119.18 77.32,119.1 76.42,119.1 76.12,118.8 75.96,118.8 75.8,118.96 75.29,118.96 75.13,118.81 74.96,118.81 74.81,118.96 74.29,118.96 74.13,118.8 73.96,118.8 73.84,118.92 73.84,119.08 74.13,119.38 74.37,119.38 74.48,119.27 75.1,119.27 75.22,119.4 75.35,119.4 75.52,119.22 75.8,119.22 76.05,119.48 77.34,119.48
+VCC_GT on GND1 (solid shape): 102.83,124.35 102.83,120.73 102.33,120.23 98.77,120.23 98.61,120.39 98.61,121.56 98.72,121.71 98.77,121.9 98.77,122.9 98.72,123.09 98.61,123.24 98.61,124.32 98.9,124.62 102.56,124.62
+VCC_GT on IN1 (solid shape): 86.18,116.05 86.18,115.86 84.54,114.21 83.83,114.21 83.62,114.42 83.62,115.4 84.53,116.32 85.92,116.32
+VCC_GT on IN1 (solid shape): 94.76,118.42 94.76,116.32 94.42,115.98 92.57,115.98 91.98,116.58 91.98,116.98 93.6,118.6 94.58,118.6
+VCC_GT on IN1 (solid shape): 102.79,124.02 102.79,121.2 102.56,120.97 99.11,120.97 98.93,121.15 98.93,123.81 99.54,124.42 102.39,124.42
+VCC_GT on IN1 (solid shape): outline of 364 points within 73.7,113.18 80.36,120.35
+VCC_GT on IN2 (solid shape): 102.84,124.45 102.84,120.64 100.46,118.26 98.48,118.26 95.99,115.76 92.07,115.76 91.69,116.14 91.69,116.65 93.66,118.62 94.4,118.62 97.19,121.4 98.68,121.4 98.95,121.67 98.95,123.99 99.58,124.62 102.68,124.62
+VCC_GT on IN2 (solid shape): outline of 335 points within 73.81,113.2 79.48,120.46
+VCC_GT on IN3 (solid shape): 102.74,124.07 102.74,121.45 102.36,121.07 99.09,121.07 99.03,121.13 99.03,124.11 99.33,124.41 102.4,124.41
+VCC_GT on IN3 (solid shape): outline of 394 points within 73.56,112.98 94.7,120.34
+VCC_GT on GND3 (solid shape): 76.22,113.52 76.22,113.33 76.11,113.22 73.44,113.22 73.32,113.34 73.32,113.5 73.46,113.64 76.1,113.64
+VCC_GT on GND3 (solid shape): 76.23,119.11 76.23,118.92 76.12,118.81 73.45,118.81 73.32,118.94 73.32,119.11 73.44,119.22 76.12,119.22
+VCC_GT on GND3 (solid shape): 76.25,118.01 76.25,117.81 76.13,117.7 73.46,117.7 73.35,117.8 73.35,117.97 73.48,118.1 76.15,118.1
+VCC_GT on GND3 (solid shape): 76.25,116.88 76.25,116.7 76.13,116.58 73.49,116.58 73.37,116.7 73.37,116.88 73.47,116.99 76.14,116.99
+VCC_GT on GND3 (solid shape): 76.26,115.76 76.26,115.58 76.14,115.46 73.47,115.46 73.35,115.58 73.35,115.74 73.49,115.88 76.13,115.88
+VCC_GT on GND3 (solid shape): 76.26,114.64 76.26,114.45 76.15,114.34 73.48,114.34 73.35,114.46 73.35,114.62 73.49,114.76 76.14,114.76
+VCC_GT on GND3 (solid shape): 102.65,124.11 102.65,121.55 102,120.9 99.24,120.9 98.95,121.19 98.95,124.07 99.33,124.45 102.31,124.45
+VCC_GT on GND3 (solid shape): 79.63,116.02 80.9,116.02 81.1,115.81 81.1,115.36 81.03,115.28 79.12,115.28 79.1,115.26 76.68,115.26 76.63,115.31 76.63,116.17 76.91,116.45 79.2,116.45
+VCC_GT on GND3 (solid shape): 77.44,114.82 78.1,114.82 78.16,114.87 78.43,114.87 78.49,114.82 78.99,114.82 79.04,114.87 79.37,114.87 79.6,114.65 80.95,114.65 81.03,114.57 81.03,114.44 80.97,114.39 79.86,114.39 79.35,113.88 76.78,113.88 76.63,114.04 76.63,114.8 76.66,114.82 77.09,114.82 77.14,114.87 77.39,114.87
