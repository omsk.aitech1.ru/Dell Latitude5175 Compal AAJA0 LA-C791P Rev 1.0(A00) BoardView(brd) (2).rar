# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_DTX_N6_C: length 2.5
  TOP w0.119: U14.12 208.64,114.49 208.52,114.61 207.2,114.61 C134.2
PCIE_PRX_DTX_N6_RP: length 9.9
  TOP w0.119: U14.19 213.94,114.49 214.06,114.61 214.97,114.61 v13(215.2,114.37)
  IN3 w0.084: v7(221.52,114.88) 221.42,114.98 220.45,114.98 219.37,113.9 216.55,113.9 215.85,114.61 215.44,114.61 v13(215.2,114.37)
  BOTTOM w0.119: JIO1.27 v7(221.52,114.88)
PCIE_PRX_DTX_N7: length 40.2
  IN2 w0.079: v2(32.52,104.43) 32.62,104.53 32.62,104.95 32.92,105.25 33.07,105.25 33.3,105.25 34.07,104.48 36.43,104.48 38.31,106.35 40.46,106.35 40.85,105.96 47.73,105.96 48.11,105.58 49.13,105.58 49.61,105.09 54.57,105.09 54.99,105.51 57.32,105.51 57.63,105.19 58.94,105.19 59.26,105.51 59.65,105.51 60.16,105 60.77,105 61,105.22 62.23,105.22 62.48,105.47 64.55,105.47 64.69,105.61 64.95,105.61 64.95,105.61 65.1,105.61 66.19,104.52 68.38,104.52 v2(68.42,104.56)
  IN3 w0.084: v7(68.73,104.69) 68.54,104.69 v2(68.42,104.56) ; v2(32.52,104.43) v7(32.52,104.77)
PCIE_PRX_DTX_N7_R: length 6.7
  IN4 w0.06: v5(67.67,109.95) 67.67,109.72 67.46,109.52 67.46,109.3 67.55,109.22 67.55,108.17 68.36,107.35 68.36,107.15 68.36,107.15 68.36,106.11 68.67,105.8 68.67,105.77 69.14,105.31 69.26,105.31 69.63,104.94 69.63,104.66 69.54,104.58 69.43,104.58 v4(69.32,104.69)
PCIE_PRX_DTX_N8: length 42.8
  IN2 w0.079: v2(68.53,105.2) 68.53,105.27 68.35,105.45 67.86,105.45 67.24,104.83 66.21,104.83 65.08,105.96 64.43,105.96 64.22,105.75 62.2,105.75 62.07,105.62 61.45,105.62 61.32,105.49 60.94,105.49 60.83,105.38 60.13,105.38 59.69,105.82 54.75,105.82 54.4,105.47 51.06,105.47 50.18,106.35 48.35,106.35 48.14,106.56 47.04,106.56 46.83,106.77 44.89,106.77 44.68,106.56 40.8,106.56 40.57,106.79 36.92,106.79 35.8,105.66 35.8,105.41 36.01,105.2 v2(36.09,105.2)
  IN3 w0.06: v3(68.15,105.2) 68.15,105.3 68.3,105.45 68.5,105.45 68.53,105.43 v2(68.53,105.2)
  IN3 w0.084: v7(36.03,104.77) 35.98,104.77 35.86,104.89 35.86,105.1 35.97,105.2 v2(36.09,105.2)
  IN4 w0.06: v5(67.34,109.71) 67.34,108.2 68.24,107.3 68.24,107.2 68.24,106.06 68.55,105.75 68.55,105.58 68.55,105.48 68.4,105.33 68.3,105.33 68.3,105.33 68.21,105.33 68.15,105.27 v3(68.15,105.2)
PCIE_PRX_DTX_N9: length 64.8
  IN2 w0.079: v2(51.62,135.57) 51.43,135.57 51.43,135.57 50.13,135.57 49.42,134.86 45.88,131.32 45.88,130.02 45.63,129.77 45.63,128.91 45.63,127.77 44.83,126.97 44.83,123.66 44.61,123.44 44.61,121.94 44.27,121.6 44.27,121.03 44.25,121.01 44.12,120.89 44.12,119.18 44.05,119.11 44.05,116.99 44.74,116.3 44.74,115.15 45.67,114.22 45.67,113.43 46.82,112.27 48.39,112.27 49.97,110.69 56.31,110.69 56.58,110.95 61.1,110.95 62.03,110.02 62.33,110.02 64.16,108.2 65.41,108.2 65.82,108.61 67.61,108.61 v2(67.62,108.59)
  IN3 w0.06: v3(68.22,108.73) 68.14,108.81 68.05,108.81 67.98,108.73 67.88,108.73 67.76,108.73 v2(67.62,108.59)
  IN3 w0.084: v7(54.76,144.39) 54.66,144.3 53.53,144.3 52.94,143.71 52.94,143.02 53.1,142.86 53.1,136.65 52.13,135.68 51.72,135.68 v2(51.62,135.57)
  IN4 w0.06: v3(68.22,108.73) 68.27,108.78 68.47,108.78 68.61,108.92 68.61,109.42 68.41,109.62 68.41,109.85 v5(68.31,109.95)
PCIE_PRX_DTX_P6: length 163.8
  TOP w0.119: v13(205.62,114.96) 205.77,114.81 206.24,114.81 C132.1
  IN2 w0.079: v2(69.54,106.3) 69.72,106.13 69.93,106.13 70.31,105.75 70.78,105.75 71.01,105.98 71.01,106.5 72.04,107.53 74.01,107.53 74.99,106.55 75.63,106.55 75.83,106.35 75.95,106.35 76.28,106.02 78.64,106.02 78.97,106.35 81.46,106.35 82.92,107.81 89.22,107.81 89.45,108.04 95.36,108.04 98.21,105.19 105.71,105.19 106.3,104.59 107.25,104.59 107.37,104.72 111.49,104.72 112.43,105.66 113.5,105.66 122.49,114.65 128.04,114.65 128.74,115.35 130.04,115.35 130.95,114.44 130.95,114.1 132.96,112.09 133.27,112.09 136.43,108.93 137.96,108.93 142.58,104.31 145.87,104.31 146.76,103.42 148.12,103.42 149.03,104.33 152.06,104.33 152.86,105.13 158.1,105.13 158.9,104.33 181.9,104.33 182.47,104.9 197.73,104.9 200.44,107.62 200.44,111.49 203.75,114.8 205.45,114.8 v13(205.62,114.96)
  IN3 w0.06: v3(69.06,106.34) 69.1,106.3 v2(69.54,106.3)
  IN4 w0.06: v3(69.06,106.34) 69.06,106.24 68.99,106.16 68.89,106.16 68.79,106.26 68.79,107.37 68.79,107.47 67.99,108.28 67.99,109.42 68.2,109.63 68.2,109.78 68.11,109.87 68.11,109.87 67.99,109.99 v5(67.99,110.2)
PCIE_PRX_DTX_P6_C: length 2.4
  TOP w0.119: C132.2 207.09,114.87 208.52,114.87 208.64,114.99 U14.11
PCIE_PRX_DTX_P6_RP: length 9.9
  TOP w0.119: U14.20 213.94,114.99 214.06,114.87 215.04,114.87 215.07,114.9 215.09,114.9 v13(215.23,115.04)
  IN3 w0.084: v13(215.23,115.04) 215.5,114.77 215.91,114.77 216.62,114.06 219.31,114.06 220.38,115.14 221.4,115.14 v7(221.54,115.28)
  BOTTOM w0.119: JIO1.25 v7(221.54,115.28)
PCIE_PRX_DTX_P7: length 40.2
  IN2 w0.079: v2(33.11,104.43) 33.01,104.43 32.8,104.64 32.8,104.87 32.99,105.06 33.22,105.06 33.99,104.29 36.51,104.29 38.39,106.17 40.38,106.17 40.77,105.77 47.65,105.77 48.03,105.39 49.05,105.39 49.54,104.91 54.65,104.91 55.06,105.32 57.24,105.32 57.56,105.01 59.02,105.01 59.33,105.32 59.58,105.32 60.09,104.81 60.85,104.81 61.07,105.04 62.31,105.04 62.56,105.29 64.63,105.29 64.77,105.43 65.03,105.43 66.12,104.34 68.14,104.34 68.27,104.2 68.3,104.2 68.4,104.1 v2(68.4,104.03)
  IN3 w0.084: v7(33.03,104.77) 33.03,104.52 v2(33.11,104.43) ; v2(68.4,104.03) 68.5,104.13 v7(68.73,104.13)
PCIE_PRX_DTX_P7_R: length 6.7
  IN4 w0.06: v4(69.32,104.13) 69.21,104.23 69.21,104.41 69.27,104.46 69.59,104.46 69.75,104.61 69.75,104.99 69.31,105.43 69.19,105.43 68.79,105.82 68.79,105.85 68.48,106.16 68.48,107.1 68.48,107.4 67.67,108.22 v5(67.67,109.43)
PCIE_PRX_DTX_P8: length 42.8
  IN2 w0.079: v2(35.52,105.2) 35.61,105.28 35.61,105.74 36.85,106.97 40.65,106.97 40.88,106.74 44.6,106.74 44.81,106.96 46.9,106.96 47.12,106.74 48.22,106.74 48.43,106.53 50.25,106.53 51.13,105.65 54.32,105.65 54.67,106 59.77,106 60.2,105.57 60.75,105.57 60.86,105.68 61.24,105.68 61.37,105.81 61.99,105.81 62.12,105.93 64.14,105.93 64.35,106.14 65.16,106.14 66.29,105.02 67.17,105.02 67.79,105.64 68.41,105.64 v2(68.53,105.76)
  IN3 w0.06: v3(68.15,105.6) 68.38,105.6 v2(68.53,105.76)
  IN3 w0.084: v2(35.52,105.2) 35.66,105.06 35.66,104.91 v7(35.52,104.77)
  IN4 w0.06: v5(67.34,110.2) 67.34,109.99 67.14,109.79 67.14,109.6 67.22,109.51 67.22,108.15 68.12,107.25 68.12,106.01 68.43,105.7 68.43,105.53 68.35,105.45 68.22,105.45 68.15,105.53 v3(68.15,105.6)
PCIE_PRX_DTX_P9: length 64.7
  IN2 w0.079: v2(51.21,134.94) 50.76,135.38 50.21,135.38 49.52,134.7 46.06,131.24 46.06,129.94 45.82,129.7 45.82,128.99 45.82,127.69 45.02,126.89 45.02,123.59 44.79,123.36 44.79,121.86 44.45,121.52 44.45,120.96 44.38,120.88 44.31,120.81 44.31,119.1 44.24,119.03 44.24,117.06 44.92,116.38 44.92,115.23 45.85,114.29 45.85,113.5 46.9,112.46 48.46,112.46 50.05,110.87 56.24,110.87 56.5,111.14 61.17,111.14 62.11,110.21 62.41,110.21 64.24,108.38 65.33,108.38 65.74,108.79 67.3,108.79 67.36,108.85 67.36,109.12 67.44,109.2 67.55,109.2 v2(67.61,109.13)
  IN3 w0.06: v2(67.61,109.13) 67.61,108.99 67.75,108.85 67.93,108.85 68,108.93 68.15,108.93 68.23,109.01 v3(68.23,109.1)
  IN3 w0.084: v7(54.76,143.89) 54.76,144.04 54.66,144.13 53.6,144.13 53.1,143.64 53.1,143.09 53.26,142.92 53.26,136.58 51.85,135.17 51.43,135.17 v2(51.21,134.94)
  IN4 w0.06: v3(68.23,109.1) 68.23,109.03 68.36,108.9 68.42,108.9 68.49,108.97 68.49,109.37 68.43,109.43 v5(68.31,109.43)
PCIE_PS: length 7.6
  TOP w0.119: R151.2 214.18,109.48 214.18,111.88 213.65,112.41 211.84,112.41 211.42,112.83 210.96,112.83 210.54,113.25 U14.14
PCIE_PTX_DRX_N6: length 171.7
  TOP w0.119: U14.9 208.82,115.99 208.71,116.09 208,116.09 207.8,116.3 206.54,116.3 v13(206.37,116.14)
  IN3 w0.084: v13(206.37,116.14) 206.51,116.27 206.97,116.27 207,116.24 207,114.33 206.03,113.36 205.37,113.36 204.09,112.08 204.09,103.42 203.79,103.12 201.74,103.12 201.14,102.51 198.26,102.51 197.11,101.36 192.94,101.36 189.4,97.82 189.4,97.82 189.17,97.6 176.05,97.6 173.88,95.43 138.16,95.43 134.56,99.02 121.81,99.02 121.27,99.56 119.48,99.56 118.95,99.02 115.09,99.02 113.94,97.87 108.1,97.87 106.29,99.68 101.52,99.68 101.35,99.52 97.5,99.52 96.77,100.24 94.44,100.24 93.32,99.12 78.77,99.12 78.18,98.53 72.23,98.53 69.28,101.48 69.28,102.55 68.99,102.83 64.74,102.83 63.61,103.96 63.61,104.24 64.03,104.66 64.03,105.06 63.97,105.12 63.97,105.58 64.07,105.68 64.23,105.68 64.31,105.59 64.31,105.4 64.26,105.35 v7(64.26,105.29)
PCIE_PTX_DRX_N6_C: length 9.3
  IN3 w0.06: v10(67.99,110.69) 67.94,110.74 67.94,110.95 67.91,110.98 67.9,110.98 67.79,111.1 67.79,111.27 67.87,111.35 67.87,111.57 67.76,111.68 66.83,111.68 66.47,111.33 66.47,110.63 66.07,110.23 66.07,109.93 66.07,109.83 65.65,109.4 65.65,108.65 65.65,108.65 65.65,108.55 64.97,107.87 64.97,107.07 64.54,106.64 64.28,106.64 64.1,106.47 64.1,106.35 v7(64.19,106.26)
  BOTTOM w0.119: v7(64.19,106.26) 64.26,106.19 CH18.2
PCIE_PTX_DRX_N6_RP: length 11
  TOP w0.119: v13(216.54,112.38) 216.36,112.56 216.17,112.56 215.84,112.89 215.84,114.94 216.14,115.24 216.14,115.82 215.9,116.06 215.78,116.06 C130.2
  IN3 w0.084: v7(221.59,113.68) 221.44,113.82 220.23,113.82 219.1,112.69 216.84,112.69 v13(216.54,112.38)
  BOTTOM w0.119: JIO1.33 v7(221.59,113.68)
PCIE_PTX_DRX_N6_RP_C: length 1.9
  TOP w0.119: C130.1 214.86,116.11 214.06,116.11 213.94,115.99 U14.22
PCIE_PTX_DRX_N7: length 39
  IN2 w0.079: v2(65.86,103.44) 65.86,103.5 65.64,103.72 65.51,103.72 65.19,104.04 64.31,104.04 64.23,104.13 59.17,104.13 58.86,104.43 57.3,104.43 57.03,104.71 55.73,104.71 55.19,104.17 49.43,104.17 48.78,104.82 47.98,104.82 47.61,105.19 40.49,105.19 40.1,105.58 38.66,105.58 36.8,103.72 34.41,103.72 34.14,103.44 32.51,103.44 31.96,104 31.96,104.65 31.79,104.82 31.44,104.82 31.34,104.71 31.34,104.59 31.5,104.43 v2(31.57,104.43)
  IN3 w0.084: v2(65.86,103.44) 66.05,103.62 66.15,103.62 v7(66.23,103.55) ; v2(31.57,104.43) 31.52,104.48 v7(31.52,104.77)
PCIE_PTX_DRX_N7_C: length 8.9
  IN3 w0.06: 67.74,105.6 67.74,105.65 67.7,105.7 67.7,106.41 67.02,107.08 67.02,109.9 67.66,110.54 67.66,110.64 67.66,110.68 67.67,110.68 v10(67.67,110.94)
  IN3 w0.084: 67.74,105.6 67.74,105.33 67.39,104.98 67.39,104.7 67.57,104.52 67.57,104.09 67.31,103.83 66.8,103.83 66.73,103.75 66.73,103.63 v7(66.81,103.55)
PCIE_PTX_DRX_N8: length 37.7
  IN2 w0.079: v2(34.52,105.43) 34.37,105.27 34.37,105.15 34.48,105.04 34.87,105.04 34.96,105.13 34.96,105.64 34.96,105.79 34.96,105.79 34.96,105.97 36.53,107.54 40.89,107.54 41.12,107.31 44.3,107.31 44.52,107.53 47.24,107.53 47.47,107.31 48.49,107.31 48.62,107.18 50.55,107.18 51.18,106.55 52.68,106.55 52.95,106.82 54.71,106.82 55.11,106.42 59.48,106.42 59.59,106.53 61.18,106.53 61.33,106.37 61.98,106.37 62.06,106.45 63.78,106.45 63.97,106.64 65.28,106.64 66.15,105.77 66.63,105.77 v2(67.03,105.37)
  IN3 w0.084: v2(67.03,105.37) 66.99,105.37 66.75,105.14 66.75,104.85 v7(66.83,104.78) ; v2(34.52,105.43) 34.39,105.29 34.39,104.91 v7(34.52,104.77)
PCIE_PTX_DRX_N8_C: length 7.7
  IN3 w0.06: v7(66.8,105.78) 66.76,105.73 66.67,105.73 66.6,105.8 66.6,105.91 66.54,105.98 66.54,106.03 66.39,106.18 66.14,106.18 66.01,106.05 65.75,106.05 65.57,106.22 65.57,106.5 65.65,106.58 65.65,106.97 65.65,107.88 66.08,108.31 66.33,108.31 66.78,108.76 66.78,110.11 67.11,110.43 67.11,110.57 67.23,110.69 v10(67.34,110.69)
  BOTTOM w0.119: v7(66.8,105.78) 66.72,105.78 66.62,105.68 66.62,105.48 66.75,105.36 CH20.2
PCIE_PTX_DRX_N9: length 70.4
  IN2 w0.079: v2(54.25,143.22) 54.03,143.22 53.87,143.07 53.87,142.48 53.41,142.01 50.41,142.01 45.42,137.02 44.02,137.02 42.27,135.27 42.27,130.58 41.58,129.88 41.58,129.12 41.3,128.84 41.3,128.02 41.3,128.02 41.3,116.79 43.05,115.04 43.05,113.32 45.2,111.17 47.99,111.17 49.49,109.67 57.05,109.67 57.34,109.95 60.2,109.95 60.55,109.6 61.42,109.6 61.84,109.19 61.84,108.9 63.22,107.52 65.63,107.52 66.12,107.03 66.53,107.03 66.74,107.24 66.74,107.36 67.14,107.76 67.59,107.76 67.92,107.43 68.12,107.43 68.48,107.07 68.58,107.07 v2(68.78,107.27)
  IN3 w0.06: v7(69.15,107.3) 69.12,107.27 v2(68.78,107.27)
  IN3 w0.084: v2(54.25,143.22) 54.15,143.32 53.92,143.32 53.87,143.27 53.87,142.83 53.98,142.73 54.59,142.73 v7(54.76,142.89)
PCIE_PTX_DRX_N9_C: length 7.2
  IN3 w0.06: v7(69.74,107.3) 69.9,107.3 70.03,107.18 70.03,107.13 69.88,106.98 69.66,106.98 69.49,107.15 69.49,107.55 69.18,107.86 67.65,107.86 67.28,108.23 67.28,109.81 67.84,110.37 68.12,110.37 68.31,110.56 68.31,110.94 v10(68.31,110.94)
PCIE_PTX_DRX_P6: length 171.6
  TOP w0.119: v13(206.37,116.72) 206.54,116.56 207.9,116.56 208.11,116.35 208.75,116.35 208.88,116.49 U14.8
  IN3 w0.084: v13(206.37,116.72) 206.37,116.66 206.61,116.43 207.04,116.43 207.16,116.31 207.16,114.26 206.1,113.2 205.43,113.2 204.25,112.01 204.25,103.35 203.85,102.95 201.81,102.95 201.21,102.35 198.33,102.35 197.18,101.2 193,101.2 189.56,97.76 189.24,97.43 176.12,97.43 173.95,95.27 138.09,95.27 134.49,98.86 121.74,98.86 121.21,99.4 119.55,99.4 119.02,98.86 115.15,98.86 114,97.71 108.03,97.71 106.22,99.52 101.59,99.52 101.42,99.35 97.43,99.35 96.71,100.08 94.5,100.08 93.38,98.96 78.84,98.96 78.24,98.36 72.16,98.36 69.11,101.41 69.11,102.48 68.92,102.67 64.67,102.67 63.45,103.89 63.45,104.31 63.87,104.73 63.87,105 63.7,105.16 v7(63.7,105.29)
PCIE_PTX_DRX_P6_C: length 9.2
  IN3 w0.06: v10(67.99,111.18) 67.99,111.19 67.99,111.52 67.99,111.62 67.81,111.8 67.71,111.8 66.78,111.8 66.35,111.38 66.35,110.68 65.95,110.28 65.95,109.88 65.53,109.45 65.53,108.6 64.85,107.92 64.85,107.12 64.49,106.76 64.23,106.76 63.98,106.52 63.98,106.37 63.88,106.26 v7(63.8,106.26)
  BOTTOM w0.119: CH19.2 63.91,106.07 63.91,106.16 v7(63.8,106.26)
PCIE_PTX_DRX_P6_RP: length 11
  TOP w0.119: v13(216.56,113.03) 216.56,112.94 216.45,112.82 216.27,112.82 216.1,113 216.1,114.83 216.4,115.13 216.4,115.93 216.01,116.33 215.78,116.33 C129.2
  IN3 w0.084: v13(216.56,113.03) 216.74,112.85 219.03,112.85 220.16,113.98 221.49,113.98 v7(221.59,114.08)
  BOTTOM w0.119: JIO1.31 v7(221.59,114.08)
PCIE_PTX_DRX_P6_RP_C: length 1.9
  TOP w0.119: U14.23 213.94,116.49 214.06,116.37 214.94,116.37 C129.1
PCIE_PTX_DRX_P7: length 39
  IN2 w0.079: v2(31.03,104.43) 31.16,104.57 31.16,104.64 31.16,104.79 31.37,105 31.52,105 31.86,105 32.14,104.72 32.14,104.08 32.59,103.63 34.06,103.63 34.34,103.91 36.72,103.91 38.59,105.77 40.18,105.77 40.57,105.37 47.69,105.37 48.06,105.01 48.86,105.01 49.5,104.36 55.12,104.36 55.65,104.9 57.1,104.9 57.38,104.62 58.94,104.62 59.25,104.31 64.01,104.31 64.01,104.31 64.3,104.31 64.39,104.23 65.27,104.23 65.58,103.91 65.82,103.91 v2(65.88,103.97)
  IN3 w0.084: v2(31.03,104.43) v7(31.03,104.77) ; v2(65.88,103.97) 66.01,104.1 v7(66.23,104.1)
PCIE_PTX_DRX_P7_C: length 8.9
  IN3 w0.06: v10(67.67,111.43) 67.67,111.22 67.47,111.02 67.47,110.85 67.54,110.77 67.54,110.59 66.9,109.95 66.9,107.13 66.9,107.03 67.58,106.36 67.58,105.6
  IN3 w0.084: 67.58,105.6 67.58,105.4 67.23,105.05 67.23,104.63 67.41,104.45 67.41,104.16 67.24,103.99 66.93,103.99 v7(66.81,104.1)
PCIE_PTX_DRX_P8: length 37.7
  IN2 w0.079: v2(33.98,105.41) 34.13,105.41 34.19,105.35 34.19,105.07 34.4,104.86 34.95,104.86 35.14,105.05 35.14,105.9 36.6,107.36 40.82,107.36 41.05,107.13 44.37,107.13 44.6,107.35 47.17,107.35 47.39,107.13 48.41,107.13 48.55,106.99 50.48,106.99 51.1,106.37 52.76,106.37 53.03,106.64 54.63,106.64 55.03,106.24 59.56,106.24 59.67,106.34 61.1,106.34 61.26,106.19 62.06,106.19 62.13,106.26 63.86,106.26 64.04,106.45 65.21,106.45 66.08,105.58 66.37,105.58 66.5,105.45 v2(66.5,105.37)
  IN3 w0.084: v7(66.27,104.78) 66.41,104.78 66.59,104.96 66.59,105.28 v2(66.5,105.37) ; v2(33.98,105.41) 34.03,105.41 34.23,105.21 34.23,104.98 v7(34.03,104.77)
PCIE_PTX_DRX_P8_C: length 7.8
  IN3 w0.06: v7(66.34,105.81) 66.42,105.88 66.42,105.98 66.34,106.06 66.19,106.06 66.06,105.93 65.7,105.93 65.45,106.17 65.45,106.55 65.53,106.63 65.53,107 65.53,107.93 66.03,108.43 66.28,108.43 66.66,108.81 66.66,110.16 66.99,110.48 66.99,110.62 67.34,110.97 v10(67.34,111.18)
  BOTTOM w0.119: CH21.2 66.34,105.44 v7(66.34,105.81)
PCIE_PTX_DRX_P9: length 70.4
  IN2 w0.079: v2(68.78,106.74) 68.63,106.89 68.41,106.89 68.05,107.25 67.84,107.25 67.51,107.57 67.22,107.57 66.92,107.28 66.92,107.16 66.61,106.85 66.04,106.85 65.56,107.33 63.14,107.33 61.65,108.82 61.65,109.11 61.35,109.41 60.48,109.41 60.12,109.77 57.41,109.77 57.13,109.48 49.42,109.48 47.92,110.98 45.12,110.98 42.86,113.24 42.86,114.96 41.11,116.72 41.11,127.94 41.11,128.92 41.39,129.2 41.39,129.96 42.09,130.66 42.09,135.35 43.94,137.2 45.34,137.2 50.34,142.19 53.33,142.19 53.69,142.55 53.69,143.05 v2(53.49,143.25)
  IN3 w0.06: v7(69.15,106.75) 69.14,106.74 v2(68.78,106.74)
  IN3 w0.084: v7(54.76,142.39) 54.59,142.56 53.91,142.56 53.71,142.76 53.71,143.03 v2(53.49,143.25)
PCIE_PTX_DRX_P9_C: length 7.4
  IN3 w0.06: v10(68.31,111.43) 68.24,111.36 68.24,111.15 68.11,111.02 68.11,110.85 68.19,110.78 68.19,110.61 68.07,110.49 67.78,110.49 67.78,110.49 67.16,109.86 67.16,108.18 67.6,107.74 69.13,107.74 69.37,107.5 69.37,107.1 69.73,106.75 v7(69.74,106.75)
PCIE_RCOMPN: length 3.4
  BOTTOM w0.203: 62.51,108.7 62.51,109.43 UC1.A9
  BOTTOM w0.305: RC66.2 63.64,106.68 62.51,107.81 62.51,108.7
PCIE_RCOMPP: length 2.8
  BOTTOM w0.203: 62.95,108.64 62.83,108.76 62.83,109.28 UC1.B10
  BOTTOM w0.305: 62.95,108.64 63.78,107.81 RC66.1
PCIE_RP_RST#: length 6.2
  IN1 w0.084: v1(210.28,111.18) 210.28,114.69 209.31,115.66 v1(209.31,116.99)
PCIE_WAKE_I#: length 267.5
  IN2 w0.079: v2(53.19,150.87) 60.67,150.87 73.61,137.93 96.46,137.93 96.61,138.08 98.81,138.08 v2(99.25,137.63)
  IN3 w0.084: v2(99.25,137.63) 99.25,137.4 v3(99.46,137.19) ; v3(181.69,134.97) 182.05,134.6 185.46,134.6 185.75,134.89 185.75,134.9 v7(185.78,134.93) 185.78,134.91 185.79,134.93 185.79,135.11 186.49,135.81 186.49,136.32 186.71,136.54 187.5,136.54 188.5,135.54 188.5,135.11 188.87,134.74 v10(189.82,134.74) ; v2(53.19,150.87) 53.14,150.82 53.14,150.54 v7(53.16,150.51)
  IN4 w0.089: v7(53.16,150.51) 50.83,148.17 41.42,148.17 22.42,129.17 22.42,127.46 21.62,126.67 21.62,120.05 22.2,119.47 22.2,112.91 24.81,110.3 26.35,110.3 26.9,109.74 v4(27.58,109.74) ; v4(207.11,145.68) 206.57,145.15 199.31,145.15 198.44,144.28 186.75,144.28 184.85,142.38 184.85,140.3 184.27,139.72 184.27,139.2 184.14,139.07 184.14,137.84 183.59,137.29 183.59,137 181.69,135.1 v3(181.69,134.97) 181.69,134.71 177.94,130.96 173.29,130.96 168.94,135.31 137.61,135.31 137.03,134.73 137.03,133.99 136.28,133.25 136.09,133.25 135.68,132.85 134.57,132.85 134.38,132.65 133.88,132.65 133.65,132.43 132.94,132.43 131.64,131.13 126.94,131.13 126.19,131.89 125.05,131.89 121.6,135.33 104.61,135.33 102.23,137.71 99.97,137.71 v3(99.46,137.19)
  BOTTOM w0.119: JNGFF3.55 53.66,147.39 53.16,147.89 v7(53.16,150.51) ; R342.1 185.36,134.5 185.75,134.89 185.75,134.9 v7(185.78,134.93) ; v4(207.11,145.68) 207.11,145.18 208.42,143.86 208.42,135.85 209.32,134.96 JNGFF1.46
PCIE_WAKE_O#: length 162.4
  IN1 w0.084: v2(181.33,134.53) 181.33,133.87 179.84,132.38 179.37,132.38 178.19,131.2 178.19,130.49 177.74,130.04 177.1,130.04 176.68,130.46 172.38,130.46 168.89,133.95 168.88,133.95 167.9,134.94 139.92,134.94 135.98,130.99 133.84,130.99 132.3,129.45 129.23,129.45 129.02,129.23 128.63,129.23 128.16,128.76 126.83,128.76 126.75,128.68 125.83,128.68 125.4,129.12 123.27,129.12 123.16,129.22 122.79,129.22 121.67,130.34 121.67,131.21 121.48,131.4 121.48,132.87 119.43,134.91 95.92,134.91 95.51,135.32 95.16,135.32 94.62,134.78 86.94,134.78 85.4,133.24 77.08,133.24 76.5,132.67 75.15,132.67 74.57,133.25 72.5,133.25 71.9,133.85 69.11,133.85 68.01,132.74 65.61,132.74 65.26,133.09 62.95,133.09 60.43,130.56 59.52,130.56 59.06,130.11 57.79,130.11 57.15,129.47 57.15,129.43 56.42,128.69 54.8,128.69 54.46,129.04 54.17,129.04 53.87,128.74 53.43,128.74 52.5,127.81 51.91,127.81 v2(51.87,127.77)
  IN3 w0.084: v3(184.86,135.24) 184.74,135.24 184.29,135.69 181.6,135.69 181.33,135.42 v2(181.33,134.53) ; v7(56.46,125.39) 56.19,125.39 55.38,126.19 55.38,126.75 55.03,127.1 54.88,127.1 54.87,127.1 54.47,127.1 54.05,127.52 53.89,127.52 53.69,127.72 51.92,127.72 v2(51.87,127.77) 51.63,128 51.28,128 51.18,128.11 v7(51.18,128.08)
  IN4 w0.089: v5(189.32,134.74) 189.2,134.74 188.93,135 186.45,135 186.23,135.22 184.89,135.22 v3(184.86,135.24)
  BOTTOM w0.119: RH62.2 51.18,128.58 v7(51.18,128.08)
PD_AUX_N: length 3
  IN1 w0.109: v1(34.09,44.22) 34.13,44.22 34.26,44.09 34.26,43.28 35.09,42.45 35.51,42.45 35.69,42.27 v1(35.69,42.17)
PD_AUX_P: length 2.9
  TOP w0.119: v1(35.69,42.97) U32.J1
  IN1 w0.109: v1(34.65,44.22) 34.49,44.06 34.49,43.37 35.18,42.68 35.5,42.68 35.69,42.87 v1(35.69,42.97)
PD_DEBUG1: length 6.6
  TOP w0.119: U32.L2 34.07,42.17 33.04,43.2 31.37,43.2 31.37,44.49 31.49,44.62 R273.2 31.71,45.63 R265.2
PD_DEBUG2: length 6.1
  TOP w0.06: U32.K2 35.09,42.17 34.98,42.28 34.98,42.29 34.84,42.42 34.49,42.42 34.45,42.45
  TOP w0.119: R266.2 32.49,45.52 R272.2 32.25,44.63 32.11,44.49 32.11,43.75 32.41,43.45 33.15,43.45 34.14,42.45 34.45,42.45
PD_DEBUG3: length 1.8
  TOP w0.119: U32.L3 33.88,40.86 R280.2
PD_DEBUG4: length 2.2
  TOP w0.06: 34.59,41.9 34.95,41.9 35.18,41.67 U32.K3
  TOP w0.119: R278.2 33.17,41.8 33.27,41.9 34.59,41.9
PD_EE_CLK: length 15
  TOP w0.119: v1(42.76,53.32) 42.76,53.33 TC15.1
  IN1 w0.084: v1(39.69,41.67) 39.69,42.03 41.4,43.74 42.23,43.74 42.42,43.93 42.42,45.11 42.94,45.63 42.94,51.46 42.47,51.93 42.47,53.03 v1(42.76,53.32)
PD_EE_CS#: length 26.6
  TOP w0.119: v1(43.47,57.74) 43.41,57.8 42.68,57.8 41.38,56.5 37.05,56.5 36.86,56.3 U28.1 ; TC20.1 v1(41.57,44.9)
  IN1 w0.084: v1(39.19,41.67) 39.19,41.79 41.57,44.17 v1(41.57,44.9) 41.57,44.96 42.76,46.15 42.76,51.38 42.28,51.86 42.28,55.05 43.64,56.4 43.64,57.57 v1(43.47,57.74)
PD_EE_MISO: length 28
  TOP w0.119: U28.2 37.48,54.59 37.72,54.83 37.72,56.08 37.92,56.28 41.47,56.28 42.61,57.42 v1(43.26,57.42) ; v1(41.57,45.48) 41.44,45.35 TC21.1
  IN1 w0.084: v1(43.26,57.42) 43.26,56.28 42.1,55.13 42.1,51.78 42.57,51.3 42.57,46.39 41.66,45.48 v1(41.57,45.48) 41.15,45.06 41.15,44.02 38.94,41.8 38.94,41.52 39.04,41.42 39.42,41.42 39.67,41.17 v1(39.69,41.17)
PD_EE_MOSI: length 15
  TOP w0.119: TC16.1 42.79,52.09 v1(42.76,52.05)
  IN1 w0.084: v1(42.76,52.05) 43.13,51.68 43.13,45.52 42.6,45 42.6,43.84 41.94,43.18 41.94,42.33 40.54,40.92 39.56,40.92 39.32,41.17 v1(39.19,41.17)
PD_EE_WP#: length 1.4
  TOP w0.119: U28.3 35.97,53.32 R244.2
PD_GPIO0: length 8.2
  TOP w0.06: 38.94,42.86 38.94,42.42 U32.B2
  TOP w0.119: 38.94,42.86 38.94,43.14 39.57,43.78 39.75,43.78 40,44.03 40,45.44 39.81,45.63 39.4,45.63 39.26,45.77 39.26,47.09 39.64,47.48 39.64,48.07 R255.1
PD_GPIO1: length 7.1
  TOP w0.06: 38.44,42.84 38.44,42.42 U32.C2
  TOP w0.119: 38.44,42.84 38.44,43.44 39.04,44.04 39.04,48.34 R257.1
PD_GPIO2: length 5.3
  IN1 w0.084: v1(38.19,38.16) 38.19,34.1 38.87,33.42 v1(38.87,33.14)
PD_GPIO3: length 8
  TOP w0.119: v1(36.31,30.87) 36.41,30.77 R308.1
  IN1 w0.084: v1(36.31,30.87) 36.24,30.87 35.99,31.11 35.99,33.52 35.76,33.75 35.76,34.42 36.2,34.86 36.2,36.71 36.69,37.2 v1(36.69,37.66)
PD_GPIO4: length 5.4
  TOP w0.119: v1(39.43,33.75) 39.43,33.74 39.6,33.74 R302.1
  IN1 w0.084: v1(38.69,38.16) 38.69,36.37 39.43,35.63 v1(39.43,33.75)
PD_GPIO5: length 12.4
  TOP w0.119: R300.1 38.66,33.62 v1(38.1,33.62)
  IN1 w0.084: v1(37.69,38.16) 37.91,37.94 37.91,33.8 v1(38.1,33.62) 38.1,33.59 v2(38.38,33.31) ; v1(36.41,29.5) v2(35.84,29.5)
  IN2 w0.079: v2(38.38,33.31) 38.38,31.59 36.3,29.5 v2(35.84,29.5)
PD_GPIO6: length 4
  TOP w0.119: R301.1 36.86,34.51 36.86,36.67 36.94,36.75 36.94,37.98 36.76,38.16 U32.G10
PD_GPIO8: length 9.5
  IN1 w0.084: v1(35.66,48.7) 36.01,48.7 36.63,48.08 36.63,43.87 36.27,43.51 36.27,41.44 36.43,41.29 36.43,40.41 v1(36.19,40.17)
PD_HOLD#: length 3.6
  TOP w0.119: R239.2 42.47,56.96 41.92,56.42 41.92,54.83 42.16,54.59 U28.7
PD_SBU1: length 4.3
  TOP w0.119: U32.K8 34.94,38.92 33.81,38.92 33.39,39.34 32.24,39.34 31.95,39.63 31.6,39.63 R284.1
PD_SBU2: length 4.3
  TOP w0.119: U32.L8 34.69,39.32 34.62,39.39 34.39,39.39 34.34,39.33 34.34,39.17 34.29,39.12 33.86,39.12 33.79,39.19 33.79,39.39 33.71,39.47 33.59,39.47 33.46,39.6 32.35,39.6 32.06,39.89 31.81,39.89 R281.1
PECI_EC: length 4.4
  BOTTOM w0.119: R327.1 185.9,139.6 185.9,139.23 186.28,138.85 187.91,138.85 188.7,138.06 188.99,138.06 U34.A12
PEDET: length 65.5
  IN4 w0.06: v4(62.01,105.2) 62.01,104.27 62.05,104.23 62.05,103.65 ; v5(63.16,110.94) 63.16,110.73 63.36,110.52 63.36,110.37 63.28,110.28 63.28,110.12 63.36,110.04 63.36,109.87 63.3,109.81 63.23,109.74 62.82,109.74 62.32,109.24 62.32,109.1 61.74,108.52 61.74,108.08 61.56,107.9 61.56,107.72 62.01,107.26 62.01,105.83
  IN4 w0.089: 62.05,103.65 62.05,102.45 61.99,102.39 61.99,101.86 61.39,101.26 61.39,100.36 59.12,98.08 51.92,98.08 51.7,97.87 50.54,97.87 49.72,97.05 47.16,97.05 46.49,96.38 43.95,96.38 42.99,95.43 41.1,95.43 40.26,94.59 38.97,94.59 37.75,93.37 37.75,90.19 v4(37.86,90.08) ; 62.01,105.83 v4(62.01,105.2)
  BOTTOM w0.119: RH133.2 61.94,105.12 v4(62.01,105.2) ; R471.1 R470.1 20.42,89.32 20.69,89.05 v14(20.93,89.05) 21.39,89.05 21.64,89.31 22.55,89.31 24.28,91.04 24.28,92.17 25.29,93.18 26.11,93.18 29.21,90.08 v4(37.86,90.08)
PEQ: length 2.3
  BOTTOM w0.119: R434.2 R433.2 54.36,102.42 54.26,102.33 U47.8
PEWAKE#: length 15.1
  IN3 w0.084: v7(28.88,108.24) 28.88,107.94 27.95,107.01 27.95,102.75 v7(29.72,100.98)
  BOTTOM w0.119: v7(29.72,100.98) 29.78,100.92 JNGFF2.54 ; v7(28.88,108.24) 28.71,108.41 27.75,108.41 27.58,108.57 R408.1 28.47,109.72 R407.1
PI0: length 1.5
  BOTTOM w0.119: U47.60 49.39,100.62 R443.2
PI1: length 4
  BOTTOM w0.119: R440.2 48.37,101.67 49.21,101.67 49.31,101.56 R439.2 51.43,101.29 U47.1
PLT_RST#: length 379.4
  TOP w0.119: 195.88,105.81 196.14,105.81 196.31,105.65 196.31,104.79 196.49,104.6 R166.1 196.99,105.01 197.76,105.78 T14.1 198.37,105.78 v1(198.55,105.96) ; 195.88,105.81 U19.1 ; 195.88,105.81 195.42,105.81 195.23,105.62 U19.2 ; U6.H2 130.16,129.86 130.39,130.09 131.53,130.09 131.85,130.41 131.85,132.44 131.41,132.88 v1(129.88,132.88) ; R30.1 207.59,135.68 v1(209.19,135.68) ; U8.1 48.45,128.2 48.29,128.36 v1(48.29,128.67)
  GND1 w0.084: v2(51.5,139.8) 51.03,140.27 v9(50.96,140.27)
  IN1 w0.084: v1(129.88,132.88) 129.6,133.16 127.32,133.16 123.21,137.27 98.53,137.27 98.08,137.73 93.41,137.73 93.26,137.57 85.8,137.57 84.25,136.02 80.7,136.02 80.02,136.69 70.72,136.69 68.15,139.27 65.74,139.27 65.22,138.74 63.16,138.74 61.34,136.92 59.17,136.92 58.55,136.3 57.3,136.3 57.01,136.59 56.05,136.59 54.59,138.05 v2(53.75,138.05) 52.11,138.05 51.39,137.34 51.39,135.84 51.18,135.63 51.18,135.41 50.79,135.01 50.79,132.6 50.74,132.56 50.74,132.17 50.63,132.06 50.63,131.5 49.48,130.34 49.4,130.34 48.43,129.37 48.43,128.81 v1(48.29,128.67) 48.21,128.74 v2(47.92,128.74) ; v2(214.24,104.8) 213.99,105.04 207.05,105.04 206.76,104.75 201.99,104.75 200.82,103.58 199.12,103.58 198.6,104.1 198.6,105.9 v1(198.55,105.96) 197.55,106.96 197.55,109.67 195.4,111.81 195.4,112.93 194.42,113.91 v2(194.42,113.95)
  IN1 w0.109: v1(129.88,132.88) 130.14,133.14 131.66,133.14 131.75,133.23 134.18,133.23 138.23,137.28 169.33,137.28 169.87,137.28 172.55,134.6 172.55,134.28 173.95,132.88 177.05,132.88 178.75,134.58 178.75,134.82 178.77,134.85 180.14,136.22 180.14,137.16 181.22,138.24 181.6,138.24 182.51,139.15 182.64,139.15 190.15,146.66 194.11,146.66 194.73,147.28 213.03,147.28 217.13,143.18 217.13,138.02 216.71,137.61 214.58,137.61 213.21,136.24 213.21,135.98 v2(213.18,135.95) 211.31,135.95 210.96,135.6 209.27,135.6 v1(209.19,135.68)
  IN2 w0.079: v2(214.24,104.8) 214.39,104.96 214.39,113.82 213.45,114.76 213.45,117.64 213.93,118.13 213.96,118.13 v2(213.97,118.12) ; v2(198.3,135.4) 199.01,135.4 200.44,136.82 210.42,136.82 211.29,135.95 v2(213.18,135.95) ; v2(53.75,138.05) 51.98,139.82 51.51,139.82 v2(51.5,139.8)
  IN3 w0.084: v3(40.36,111.03) 40.31,110.98 40.31,107.03 40.82,106.52 40.82,102.76 40.54,102.48 v7(40.54,101.84) ; v7(47.58,128.67) 47.59,128.68 47.85,128.68 v2(47.92,128.74) ; v7(212.72,135.95) v2(213.18,135.95) 213.18,135.58 214.78,133.97 214.78,125.03 213.97,124.22 v2(213.97,118.12) 214.77,118.12 215.56,117.32 v7(217.26,117.32) ; v2(198.3,135.4) 198.27,135.42 197.31,135.42 195.6,133.71 195.52,133.71 v3(195.33,133.52) ; v2(214.24,104.8) 214.41,104.63 214.41,103.72 217.05,101.09 217.05,100.46 217.88,99.63 v3(217.89,99.63) ; v7(194.98,114.11) 194.59,114.11 v2(194.42,113.95)
  IN4 w0.084: v4(193.82,133.24) 195.04,133.24 v3(195.33,133.52)
  IN4 w0.089: v3(217.89,99.63) 217.96,99.7 v7(219.73,99.7) ; v4(47,123.57) 46.33,122.9 43.84,122.9 43.03,122.09 43.03,121.85 41.86,120.68 41.86,119.97 43.46,118.38 43.46,116.65 42.27,115.46 42.27,112.94 v3(40.36,111.03)
  BOTTOM w0.119: 47.55,127.35 47.4,127.35 47,126.95 v4(47,123.57) RH82.1 ; 47.55,127.35 RH67.1 48.5,126.98 49.42,126.98 49.54,126.86 49.54,126.59 49.71,126.42 UH3.4 ; 47.55,127.35 47.53,127.36 47.53,128.62 v7(47.58,128.67) ; Q16.2 195.07,114.2 v7(194.98,114.11) ; JNGFF1.42 211.62,135.96 211.63,135.95 v7(212.72,135.95) ; JIO1.16 217.3,117.28 v7(217.26,117.32) ; v7(40.54,101.84) 40.54,100.73 38.71,98.9 31.32,98.9 30.78,98.35 JNGFF2.50
PM_SYS_RESET#: length 78.9
  TOP w0.119: RC34.1 83.22,101.5 81.31,103.42 79.04,103.42 v1(78.99,103.47) ; v1(62.99,106.87) 62.99,111 63.95,111.97 63.95,112.73 64.39,113.17 64.39,114.87 64.07,115.2 62.26,115.2 61.62,115.84 61.62,123.85 62.4,124.64 62.4,125.37 64.64,127.6 72.21,127.6 73.14,128.53 JAPS2.6
  IN1 w0.084: v1(78.99,103.47) 78.71,103.75 77.25,103.75 76.04,102.54 75.69,102.54 75.59,102.44 75.09,102.44 74.62,102.9 74.62,103.28 74.37,103.53 73.82,103.53 73.34,103.05 72.72,103.05 71.96,103.8 69.26,103.8 68.9,103.45 68.16,103.45 67.17,104.43 66.26,104.43 66.14,104.55 66.04,104.55 63.72,106.87 v1(62.99,106.87) 62.99,107.01 62.34,107.65 61.73,107.65 61.55,107.47 61.25,107.47 60.28,108.44 59.45,108.44 v2(59.44,108.42)
  IN3 w0.06: v2(59.44,108.42) 59.25,108.23 v3(59.25,107.74)
  IN4 w0.06: v3(59.25,107.74) 59.25,105.45 58.8,105.01
  IN4 w0.089: 58.8,105.01 57.71,103.91 56.43,103.91 v4(56.21,104.13)
  BOTTOM w0.119: v4(56.21,104.13) 56.21,104.43 RH111.1
PME#: length 9.7
  IN4 w0.06: v5(62.11,122.45) 62.07,122.45 61.75,122.77 60.99,122.77 60.91,122.69 60.77,122.69 60.66,122.81 59.95,122.81 59.87,122.73 59.18,122.73 59.17,122.72 59.16,122.72 59.09,122.65 58.25,122.65 58.13,122.53 57.5,122.53 56.94,123.09 56.94,123.38 56.77,123.55 56.29,123.55
  IN4 w0.089: 56.29,123.55 55.7,123.55 55.44,123.29 55.01,123.29 54.44,123.87 v4(54.28,123.87)
  BOTTOM w0.119: v4(54.28,123.87) 54.28,123.74 TC37.1
PMU_VCC: length 9.2
  TOP w0.119: R197.2 R196.2 ; R196.2 v1(210.08,97.42) ; R196.2 209.99,98.06 209.59,98.47 v14(209.59,100.61)
  IN1 w0.084: v2(210.57,97.4) 210.54,97.42 v1(210.08,97.42)
  IN3 w0.084: v2(210.57,97.4) 211.77,96.19 v7(213.69,96.19)
  BOTTOM w0.119: JNFC1.14 213.66,96.16 v7(213.69,96.19)
POGO_DET#: length 92.2
  TOP w0.119: v1(146.68,107.89) 147.09,107.89 147.29,107.69 PR549.2 ; v1(187.86,107.13) 187.86,107.81 v14(187.04,108.63) 186.25,109.42 186.25,111.33 185.8,111.78 185.8,113.52 185.89,113.6 185.89,115.66 185.42,116.13 184.44,116.13 184.22,116.35 184.22,118.86 185.43,120.08 185.43,124.32 184.89,124.87 184.89,126.35 185.08,126.55 PU200.1
  TOP w0.254: PU300.4 148.55,118.68 148.37,118.5 147.65,118.5 147.52,118.63 v1(147.52,119.03)
  IN1 w0.084: v1(187.86,107.13) 187.55,106.82 179.19,106.82 177.02,104.65 173.37,104.65 171.6,106.41 171.6,107.42 170.98,108.04 168.73,108.04 v2(168.22,107.53) 167.31,106.62 165.56,106.62 164.92,105.98 161.89,105.98 161.26,106.61 151.27,106.61 150.93,106.95 150.05,106.95 149.65,106.55 148.51,106.55 v2(146.96,108.09) 146.89,108.09 v1(146.68,107.89) ; v1(147.52,119.03) 147.97,119.03 v2(147.98,119.04)
  IN3 w0.084: v3(148.45,119.04) v2(147.98,119.04) ; v2(146.96,108.09) 146.79,108.27 146.71,108.27 v7(146.65,108.33) ; v2(168.22,107.53) 168.2,107.51 v7(168.2,107.18)
  IN4 w0.089: v7(146.65,108.33) 146.65,110.29 148.3,111.94 148.3,112.45 148.56,112.72 148.56,118.93 v3(148.45,119.04)
  BOTTOM w0.119: v7(146.65,108.33) 146.66,108.32 146.66,107.37 PD503.1
  BOTTOM w0.254: v7(168.2,107.18) 169.58,105.79 169.58,104.78 170.33,104.03 PD502.1
POGO_DET#_L: length 162.3
  TOP w0.254: PU300.1 149.85,122.17 149.54,122.48 147.73,122.48 147.46,122.21 146.91,122.21 146.56,121.86 v14(146.56,121.83) 146.56,121.27 147.05,120.78 PR300.2 PR303.1 147.46,119.94 147.01,119.5 147.01,117.55 147.83,116.74 v13(149.16,116.74)
  IN2 w0.079: v2(132.44,106.19) 132.62,106.19 133.51,105.3 133.51,102.78 132.93,102.19 132.93,98.12 134.1,96.94 v2(134.1,96.87)
  IN3 w0.084: v2(134.1,96.87) 134.1,96.69 v7(134.31,96.47) ; v2(132.44,106.19) 132.42,106.21 v3(132.42,106.6) 132.42,106.62 133.02,107.23 134.75,107.23 135.87,106.1 145.64,106.1 v3(145.91,106.38)
  IN4 w0.089: v3(132.42,106.6) 132.73,106.91 136.27,106.91 137.27,105.91 142.77,105.91 144.17,104.51 144.17,103.62 144.69,103.11 147.94,103.11 150,105.17 150.68,105.17 151.18,104.66 152.77,104.66 153.46,105.36 155.61,105.36 155.83,105.58 157.55,105.58 158.12,105.01 158.98,105.01 159.54,105.57 174.9,105.57 175.37,105.1 180.23,105.1 181.67,106.53 182.77,107.64 183.62,107.64 184.68,108.7 189.03,108.7 192.02,111.69 192.66,111.69 192.94,111.97 192.94,112.06 193.74,112.86 193.74,114.47 194.74,115.46 194.74,121.59 191.51,124.81 185.72,124.81 184.59,125.95 184.59,130.38 183.99,130.98 183.99,133.3 183.99,133.3 183.99,134.01 184.24,134.26 184.24,134.95 184.24,135.48 185.37,136.61 185.37,136.9 185.68,137.21 185.68,138.43 186.75,139.5 190.01,139.5 v4(190.27,139.25) 190.27,137.86 190.82,137.31 v4(190.82,137.24) ; v13(149.16,116.74) 148.75,116.33 148.75,112.6 148.49,112.34 148.49,111.82 146.93,110.25 146.93,108.09 146.27,107.43 146.27,106.73 v3(145.91,106.38)
  BOTTOM w0.119: JIO4.30 135.12,95.66 v7(134.31,96.47)
POGO_DET#_R: length 63.3
  TOP w0.119: v1(145.77,121.15) 145.35,121.15 v14(144.87,121.63)
  TOP w0.254: v1(151.03,120.91) 151.03,121.54 152.58,123.09 152.58,129.92 v1(152.5,130) ; v1(148.89,122.06) 149.2,121.76 v1(149.2,121.17)
  IN1 w0.084: v1(152.5,130) 152.56,129.94 v2(152.96,129.94)
  IN1 w0.254: v1(151.03,120.91) 149.46,120.91 v1(149.2,121.17) ; v1(148.89,122.06) 148.71,122.24 146.87,122.24 v1(145.77,121.15)
  IN3 w0.084: v10(190.96,134.59) 190.28,134.59 189.97,134.28 189.66,134.28 189.24,133.85 189.24,133 189.04,132.8 188.38,132.8 188.2,132.62 186.87,132.62 186.34,132.09 186.34,131.09 185.98,130.73 185.94,130.73 185.43,130.22 v7(185.43,129.96) 184.67,130.72 181.7,130.72 181.31,130.33 179.14,130.33 178.36,131.11 167.45,131.11 165.6,132.96 156.29,132.96 153.27,129.94 v2(152.96,129.94)
  BOTTOM w0.119: v10(190.96,134.59) 190.98,134.61 190.98,135.1 190.75,135.33 190.41,135.33 U34.F10
POGO_DET_R: length 44.4
  TOP w0.254: v13(149.16,116.16) 147.91,116.16 147.01,117.06 145.83,117.06 145.14,117.76 PR302.1 145.12,118.05 PQ300.2
  IN2 w0.079: v2(133.59,96.87) 133.59,97.12 132.74,97.97 132.74,102.27 133.33,102.86 133.33,104.99 v2(132.65,105.67)
  IN3 w0.084: v7(133.78,96.48) 133.78,96.67 v2(133.59,96.87) ; v3(146.18,106.14) 145.96,105.92 135.8,105.92 134.67,107.04 133.22,107.04 132.87,106.69 132.87,105.92 132.65,105.7 v2(132.65,105.67)
  IN4 w0.089: v3(146.18,106.14) 146.47,106.43 146.47,107.33 147.12,107.98 147.12,110.18 148.69,111.75 148.69,112.27 148.98,112.56 148.98,115.98 v13(149.16,116.16)
  BOTTOM w0.119: JIO4.32 134.72,95.75 134.31,96.17 134.1,96.17 v7(133.78,96.48)
PWR_BTN_DOCK1#: length 10.4
  TOP w0.119: v1(38.01,49.13) R259.1
  IN1 w0.084: v1(38.01,49.13) 38.01,43.49 37.89,43.38 37.87,43.36 37.69,43.18 37.69,42.04 37.93,41.81 37.93,41.44 37.99,41.39 37.99,40.96 37.93,40.9 37.93,39.92 v1(38.19,39.66)
PWR_BTN_DOCK#: length 274.3
  TOP w0.119: QT1.6 35.07,55.74 34.76,56.05 33.77,56.05 33.58,56.24 33.58,57.6 33.87,57.89 36.03,57.89 37.16,56.76 41.33,56.76 42.62,58.05 43.23,58.05 v1(43.28,58.11) ; v1(202.89,108.83) 203.26,108.45 203.26,107.4 204.28,106.39 204.28,104.56 205.73,103.11 205.73,101.61 207.39,99.95 v1(207.39,99.84)
  IN1 w0.084: v1(207.39,99.84) 207.32,99.76 207.32,97.35 207.15,97.19 198.92,97.19 198.76,97.02 181.17,97.02 179.26,95.11 176.83,95.11 175.79,94.07 169.66,94.07 169.58,93.99 118.16,93.99 117.73,94.42 100,94.42 98.71,95.72 86.73,95.72 84.31,93.3 83.28,93.3 81.81,91.83 45.97,91.83 45.41,92.38 44.02,92.38 43.68,92.04 40.05,92.04 37.96,89.95 37.96,89.08 38.25,88.79 39.18,88.79 39.65,88.32 39.65,86.75 38.98,86.08 38.98,84.81 38.4,84.23 38.4,76.23 43.17,71.46 43.17,58.22 v1(43.28,58.11) ; v2(202.56,109.02) 202.76,108.83 v1(202.89,108.83)
  IN3 w0.084: v3(201.89,109.27) 201.94,109.27 202.2,109.02 202.56,109.02 v2(202.56,109.02)
  IN4 w0.089: v4(199.26,139.23) 199.16,139.13 199.16,135.12 202.86,131.42 202.9,131.42 206.26,128.07 206.26,123.13 205.98,122.86 205.98,119.74 203.31,117.07 203.31,113.8 201.89,112.38 v3(201.89,109.27)
  BOTTOM w0.119: R333.1 198.98,139.51 v4(199.26,139.23)
PWR_LED#: length 55.2
  IN3 w0.084: v7(217.15,117.75) 217.1,117.8 215.86,117.8 215.73,117.93 214.76,118.9 214.76,124.15 215.25,124.64 215.25,138.76 213.78,140.22 212.17,140.22 205.32,147.07 202.54,147.07 200.05,144.58 200.05,140.3 v3(199.77,140.02)
  IN4 w0.089: v3(199.77,140.02) 198.83,140.02 197.61,138.8 195.58,138.8 194.53,137.75 194.11,137.75 193.82,137.47 v5(193.82,137.24)
  BOTTOM w0.119: JIO1.14 217.22,117.68 v7(217.15,117.75)
PWR_SW_IN#: length 14
  TOP w0.119: v1(198.84,138.16) 198.84,138.17 U1.3
  IN1 w0.084: v1(198.84,138.16) 198.16,137.48 198.04,137.48 v2(197.61,137.05)
  IN3 w0.084: v2(197.61,137.05) 197.61,137.12 v3(197.33,137.4)
  IN4 w0.089: v3(197.33,137.4) 197.33,137.23 v4(197.05,136.95) 196.84,136.74 196.42,136.74 v4(194.32,136.74)
  BOTTOM w0.119: C231.1 197.9,142.6 198.08,142.42 R494.2 197.99,141.95 197.99,140.02 198.17,139.84 R334.2 198.06,139.5 197.79,139.23 197.79,138.67 196.59,137.47 D35.1 196.6,137.4 v4(197.05,136.95)
PWRBTN#: length 147.2
  TOP w0.119: v1(186.63,107.11) 186.91,106.83 v14(186.91,101.41) 186.91,100.38 v13(187.5,99.79) ; PU1500.1 v1(180.14,117.35)
  IN1 w0.084: v1(186.63,107.11) 186.88,107.37 v2(186.88,108.42) ; v1(180.14,117.35) 180.58,117.35 182.27,115.66 v2(183.46,115.66)
  IN3 w0.084: v3(188.59,110.12) 186.89,108.42 v2(186.88,108.42) ; v2(183.46,115.66) v3(184.43,115.66) ; v7(198.5,140.72) 198.8,141.02 198.8,143.59 202.46,147.25 205.4,147.25 212.18,140.48 213.93,140.48 214.51,139.89 214.81,139.89 216.82,137.88 216.82,124.88 218.86,122.84 218.86,117.53 220.31,116.08 v7(221.5,116.08)
  IN4 w0.089: v3(188.59,110.12) 188.51,110.21 186.67,110.21 186.16,110.73 186.16,111.3 184.43,113.03 v3(184.43,115.66) ; v4(202.59,99.13) 202.56,99.09 202.56,98.74 202.59,98.71 202.59,98.68 202.61,98.66 202.61,96.35 201.51,95.24 192.99,95.24 v4(192.63,95.6)
  BOTTOM w0.119: v13(187.5,99.79) 186.97,100.32 184,100.32 183.1,99.42 SW3.1 SW3.3 182.83,95.57 183.64,96.38 186.21,96.38 187.07,95.52 192.56,95.52 v4(192.63,95.6) ; v7(198.5,140.72) 198.46,140.76 R494.1 ; JIO1.21 220.79,116.08 v7(221.5,116.08) 221.94,116.08 222.25,115.76 222.25,107.76 215.02,100.54 208.16,100.54 206.81,99.19 202.62,99.19 202.59,99.16 v4(202.59,99.13)
PWRGD_XDP: length 2.6
  BOTTOM w0.119: RC122.2 86.51,100.85 87.24,100.12 JXDP1.39
REM_DIODE1_N: length 145.5
  TOP w0.119: v1(83.56,120.96) 84.14,121.55 Q11.3 ; C128.1 141.3,118.37 141.3,119.23 Q12.1 140.97,119.85 Q12.2 140.12,120.5 138.18,118.56 v13(138.18,117.88)
  IN1 w0.084: v1(83.56,120.96) 84.94,120.96 86.03,119.87 88.04,119.87 88.71,120.55 95.38,120.55 96.02,119.9 96.02,115.87 97.41,114.48 102.5,114.48 105.64,117.62 111.94,117.62 113.48,116.09 113.48,115.84 115.62,113.69 121.06,113.69 122.71,115.34 122.71,116.15 122.96,116.4 123.71,116.4 123.87,116.56 126.28,116.56 v2(126.73,116.11)
  IN3 w0.084: v2(126.73,116.11) 126.73,116.08 v3(127.08,115.74) ; v3(151.92,131.63) 153.62,133.33 165.76,133.33 167.6,131.49 178.51,131.49 179.29,130.7 181.15,130.7 182.1,131.65 184.37,131.65 185.12,130.9 185.59,130.9 185.79,131.1 185.82,131.1 185.97,131.25 185.97,132.02 185.71,132.27 185.71,133.14 185.74,133.17 v7(185.74,133.37)
  IN4 w0.089: v3(127.08,115.74) 127.64,115.74 128.98,117.08 129.39,117.08 130.44,118.13 132.33,118.13 132.77,118.56 136.24,118.56 136.92,117.88 v13(138.18,117.88) 138.52,118.23 139.18,118.23 139.51,118.56 139.51,121.4 139.75,121.65 139.75,123.58 140.19,124.01 140.34,124.01 146.28,124.01 147.31,125.04 148.09,125.04 148.38,125.33 148.38,126.37 148.8,126.79 149.48,126.79 149.78,127.09 149.78,129.5 151.91,131.63 v3(151.92,131.63)
  BOTTOM w0.119: U34.E13 187.83,135.74 187.73,135.63 186.38,135.63 186.28,135.53 C242.2 186.28,135.02 185.74,134.47 v7(185.74,133.37)
REM_DIODE1_P: length 142.6
  TOP w0.119: C128.2 141.05,118.44 141.05,119.08 140.92,119.2 Q12.3 139.2,119.2 138.79,118.79 v13(138.79,117.85) ; v1(83.56,120.05) 84.41,120.9 Q11.1 85.57,120.9 Q11.2
  IN1 w0.084: v1(83.56,120.05) 83.87,120.36 85.28,120.36 85.95,119.69 88.11,119.69 88.79,120.36 95.3,120.36 95.83,119.83 95.83,115.79 97.33,114.29 102.57,114.29 105.72,117.44 111.86,117.44 113.29,116.01 113.29,115.76 115.57,113.48 121.12,113.48 122.9,115.27 122.9,116.07 123.04,116.21 126.08,116.21 v2(126.16,116.13)
  IN3 w0.084: v7(185.98,133.03) 185.98,132.27 186.16,132.09 186.16,131.17 185.9,130.92 185.86,130.92 185.66,130.72 185.04,130.72 184.29,131.47 182.18,131.47 181.23,130.52 179.22,130.52 178.43,131.3 167.52,131.3 165.68,133.15 153.83,133.15 v3(152.3,131.61) ; v3(127.14,115.26) 127.04,115.26 v2(126.16,116.13)
  IN4 w0.089: v3(127.14,115.26) 127.35,115.46 127.63,115.46 129.06,116.89 129.47,116.89 130.51,117.93 132.41,117.93 132.84,118.37 136.16,118.37 136.84,117.69 137.82,117.69 138,117.52 138.01,117.52 138.02,117.51 138.45,117.51 v13(138.79,117.85) 139.06,117.85 139.7,118.48 139.7,121.33 139.94,121.57 139.94,123.5 140.27,123.82 146.36,123.82 147.39,124.85 148.17,124.85 148.57,125.25 148.57,126.29 148.88,126.6 149.56,126.6 149.97,127.01 149.97,129.29 v3(152.3,131.61)
  BOTTOM w0.119: v7(185.98,133.03) 186.06,133.11 186.06,134.44 186.31,134.69 187.05,134.69 187.2,134.84 C242.1 187.27,135.24 U34.F13
REM_DIODE2_N: length 353.5
  IN4 w0.089: v4(184.73,139.51) 185.23,140.01 185.23,141.9 186.04,142.72 190.94,142.72 191.17,142.95 191.6,142.95 191.9,143.25 199.28,143.25 200.61,144.57 208.54,144.57 210.01,143.11 210.01,127.82 209.36,127.17 209.36,119.84 207.03,117.52 206.11,117.52 205.04,116.44 205.04,107.96 203.99,106.91 202.95,106.91 201.18,105.14 201.18,103.85 201.97,103.05 201.97,95.98 201.52,95.53 193.52,95.53 191.86,97.19 184.85,97.19 184.26,96.59 179.35,96.59 176.64,93.88 166.98,93.88 166.32,93.21 147.03,93.21 146.37,93.88 143.95,93.88 142.4,92.32 111.61,92.32 111.22,92.71 98.24,92.71 97.48,93.47 87.74,93.47 86.4,92.13 86.4,91.9 84.87,90.38 43.74,90.38 43.41,90.05 42.24,90.05 41.03,88.83 v4(41.03,88.33)
  BOTTOM w0.119: U34.D13 188.08,136.24 187.44,136.89 186.45,136.89 186.33,137.01 C239.2 185.97,137.35 184.63,138.69 184.63,139.41 184.73,139.51 v4(184.73,139.51) ; C341.2 20.09,67.5 Q20.3 20.07,67.71 20.07,69.59 20.49,70.01 20.49,73.74 24.81,78.05 24.81,87.69 26.33,89.21 37.21,89.21 37.8,88.62 40.74,88.62 v4(41.03,88.33) ; Q21.1 25.48,14.62 24.83,15.27 Q21.2 24.83,16.32 25.08,16.58 25.69,16.58 C352.1 25.86,17.19 26.19,17.52 27,17.52 27.87,18.38 27.87,24.52
  BOTTOM w0.127: 27.87,24.52 24.96,27.44 24.96,59.95 20.42,64.48 v14(20.42,65.26) 20.42,66.06 C341.2
REM_DIODE2_P: length 292.2
  IN4 w0.089: v4(40.57,88.33) 40.86,88.04 41.24,88.04 41.38,88.18 41.38,88.64 42.21,89.47 43.39,89.47 43.81,89.9 85.03,89.9 86.78,91.65 86.78,91.95 87.92,93.09 97.32,93.09 98.08,92.33 110.17,92.33 110.58,91.93 154.49,91.93 155.14,92.58 167.41,92.58 v4(167.53,92.69) ; v4(168.76,99.15) 168.76,99.27 169.11,99.62 174.66,99.62 175.15,100.11 181.39,100.11 184.21,102.93 v4(184.21,103.2)
  BOTTOM w0.119: 28.1,18.21 26.77,16.88 C352.2 26.77,16.33 26.65,16.21 26.37,16.21 26.13,15.97 Q21.3 ; v4(184.21,103.2) 184.14,103.27 184.14,139.47 184.46,139.8 184.91,139.8 185.24,139.46 185.24,138.62 186.05,137.82 186.64,137.82 187.1,137.35 C239.1 187.68,137.35 188.3,136.74 U34.C13 ; v4(40.57,88.33) 40.5,88.4 37.71,88.4 37.12,88.99 26.49,88.99 25.04,87.54 25.04,77.96 20.73,73.64 20.73,69.32 Q20.1 20.62,68.27 Q20.2 21.01,67.35 C341.1 ; v4(168.76,99.15) 168.69,99.09 168.69,97.79 167.53,96.64 167.53,92.96 167.53,92.95 v4(167.53,92.69)
  BOTTOM w0.127: C341.1 20.79,66.17 20.79,64.65 v14(21.41,64.03) 25.18,60.25 25.18,27.53 28.1,24.62 28.1,18.21
REM_DIODE3_N: length 171.9
  TOP w0.119: Q3.2 214.13,137.35 Q3.1 214.79,138 v1(216.18,139.39)
  IN1 w0.084: v2(78.51,134.33) 78.51,134.54 78.75,134.78 79.8,134.78 80.23,134.35 84.94,134.35 86.52,135.94 94.2,135.94 94.7,136.43 95.97,136.43 96.34,136.06 98.22,136.06 98.34,136.18 110.13,136.18 110.17,136.15 120.43,136.15 124.52,132.06 125.8,132.06 126.39,131.47 127.27,131.47 127.48,131.26 130.12,131.26 130.35,131.03 131.56,131.03 132.16,131.63 132.9,131.63 133.37,132.1 134.62,132.1 138.7,136.18 168.88,136.18 173.39,131.67 177.29,131.67 179.65,134.03 179.94,134.03 180.4,134.49 180.4,135.03 182.08,136.71 v2(182.08,138.05) 182.55,138.52 183.58,138.52 184.47,139.41 184.47,139.85 184.73,140.12 185.24,140.12 185.66,140.53 186.05,140.53 186.65,141.13 187.74,141.13 192.8,146.18 194.31,146.18 194.93,146.8 203.5,146.8 207.65,142.65 208.84,142.65 209.63,141.86 209.63,140.97 210.28,140.32 215.24,140.32 v1(216.18,139.39)
  IN3 w0.084: v7(187.22,138.34) 186.86,137.98 185.87,137.98 185.12,138.74 182.77,138.74 v2(182.08,138.05) ; v7(77.9,134.06) 78.24,134.06 v2(78.51,134.33)
  BOTTOM w0.119: v7(77.9,134.06) 77.9,134.03 77.78,133.91 Q14.3 77.91,132.08 C257.2 ; v7(187.22,138.34) 187.36,138.2 187.7,138.2 188.17,137.74 U34.A13
REM_DIODE3_P: length 166.6
  TOP w0.119: v1(216.17,138.47) 215.43,137.74 Q3.3
  IN1 w0.084: v1(216.17,138.47) 214.5,140.13 210.21,140.13 209.45,140.89 209.45,141.78 208.77,142.46 207.57,142.46 203.79,146.24 195.24,146.24 194.83,145.84 192.71,145.84 187.82,140.94 186.72,140.94 186.02,140.24 185.63,140.24 v2(184.98,139.59) 184.98,139.35 180.59,134.96 180.59,134.41 179.98,133.8 179.69,133.8 177.37,131.48 173.15,131.48 168.69,135.94 138.73,135.94 134.7,131.92 133.45,131.92 131.93,130.4 129.89,130.4 129.74,130.55 127.93,130.55 127.19,131.28 126.31,131.28 125.72,131.87 124.44,131.87 120.51,135.8 120.44,135.88 96.26,135.88 95.9,136.25 94.77,136.25 94.24,135.71 86.56,135.71 85.01,134.17 79.84,134.17 v2(79.68,134.33)
  IN3 w0.084: v2(184.98,139.59) 185.12,139.59 186.22,138.49 186.22,138.43 v7(186.31,138.34) ; v7(79.17,134.66) 79.5,134.33 v2(79.68,134.33)
  BOTTOM w0.119: C257.1 78.83,131.95 Q14.2 78.65,132.65 78.49,132.65 78.25,132.89 78.25,133.23 78.43,133.42 Q14.1 79.17,134.55 v7(79.17,134.66) ; U34.B13 188.2,137.24 187.56,137.88 186.89,137.88 186.73,138.04 186.61,138.04 v7(186.31,138.34)
REXT: length 1.6
  BOTTOM w0.119: R435.1 59.06,102.78 U47.20
RING2: length 1.8
  TOP w0.127: v14(10.59,139.13) 8.83,139.13
RING2_L: length 8.8
  IN1 w1.016: 7.78,131.6 7.78,135.07 10.57,137.85 10.57,139.23
  vias: v1(9.91,140.54) v1(10.11,140.71) v1(10.11,140.38) v2(7.38,130.9) v2(7.71,130.52) v7(8.12,130.42) v7(8.39,130.42) v7(8.64,130.42)
RP_CEXT: length 1.8
  TOP w0.119: UV1.2 120.34,111.96 120.27,112.03 CV10.1
RP_CFG0: length 3.3
  TOP w0.119: RV11.2 RV10.2 119.96,109.08 120.29,109.41 120.29,109.92 120.83,110.46 UV1.5
RP_CFG1: length 8.2
  TOP w0.119: UV1.40 126.47,112.71 126.26,112.51 122.43,112.51 121.61,113.32 RV1.2 RV2.2
RP_DP_CBL_DET: length 3
  TOP w0.119: UV1.10 121.31,107.96 120.17,106.82 RV15.1 119.76,106.81 RV16.1
RP_DP_CLK_AUXP: length 19.6
  TOP w0.119: v1(132.08,105.81) 132.05,105.83 132.05,107.18 131.56,107.67 131,107.67 D11.1 130.75,107.68 130.32,107.68 RV12.1 130.09,107.69 129.91,107.69 129.74,107.85 129.74,108.04 129.44,108.34 129.26,108.34 129.15,108.46 UV1.28
  IN1 w0.109: v1(132.08,105.81) 132.08,105.69 131.55,105.17 131.06,105.17 v2(130.81,104.92)
  IN2 w0.079: v2(130.41,95.25) 130.24,95.42 130.24,96.33 129.73,96.85 129.73,97.84 128.99,98.58 128.99,102.66 130.64,104.31 130.64,104.75 v2(130.81,104.92)
  IN3 w0.084: v7(130.31,94.63) 130.22,94.72 130.22,95.06 v2(130.41,95.25)
  BOTTOM w0.119: v7(130.31,94.63) 130.27,94.68 130.27,94.82 130.32,94.87 JIO4.54
RP_DP_DAT_AUXN: length 19.7
  TOP w0.119: UV1.27 129.08,107.96 129.2,108.08 129.33,108.08 129.48,107.93 129.48,107.74 129.8,107.42 129.97,107.42 RV14.1 130.43,107.42 130.59,107.42 D13.1 131.15,107.41 131.45,107.41 131.79,107.07 131.79,105.9 v1(131.7,105.81)
  IN1 w0.109: v2(130.25,104.9) 130.75,105.4 131.42,105.4 131.7,105.68 v1(131.7,105.81)
  IN2 w0.079: v2(129.88,95.25) 130.05,95.43 130.05,96.26 129.54,96.77 129.54,97.77 128.8,98.5 128.8,102.73 130.45,104.38 130.45,104.7 v2(130.25,104.9)
  IN3 w0.084: v7(129.92,94.63) 130.06,94.77 130.06,95.07 v2(129.88,95.25)
  BOTTOM w0.119: JIO4.56 129.92,94.92 130.01,94.84 130.01,94.72 v7(129.92,94.63)
RP_DP_HPD: length 34.7
  TOP w0.119: UV1.11 121.12,107.46 120.12,106.46 120.12,105.96 RV17.1 119.76,104.47 120.33,103.9 v1(120.41,103.9)
  IN1 w0.084: v1(120.41,103.9) 120.46,103.85 123.37,103.85 123.98,103.24 v2(124.26,103.24)
  IN2 w0.079: v2(120.44,94.92) 120.75,95.23 120.75,96.12 121.66,97.03 121.66,101.32 122.39,102.06 122.66,102.06 123.84,103.24 v2(124.26,103.24)
  GND3 w0.084: v8(120.85,95.09) 120.61,95.09 v2(120.44,94.92)
  IN4 w0.089: v4(120.54,94.73) 120.52,94.74 120.85,95.07 v8(120.85,95.09)
  BOTTOM w0.119: JIO4.44 132.32,94.54 130.77,92.99 121.53,92.99 120.51,94.01 120.51,94.71 v4(120.54,94.73)
RP_DP_N0: length 11.6
  TOP w0.119: v1(127.28,101.35) 127.46,101.53 127.46,101.95 127.72,102.21 127.72,103.39 D17.1 127.66,103.71 127.66,104.12 CV17.2
  IN1 w0.109: v2(127.28,100.98) v1(127.28,101.35)
  IN2 w0.079: v2(128.65,95.3) 128.82,95.46 128.82,96.71 127.45,98.08 127.45,98.31 127.45,98.31 127.45,100.81 v2(127.28,100.98)
  IN3 w0.084: v7(128.73,94.61) 128.84,94.72 128.84,95.11 v2(128.65,95.3)
  BOTTOM w0.119: JIO4.62 128.72,94.9 128.78,94.84 128.78,94.66 v7(128.73,94.61)
RP_DP_N0_C: length 1.8
  TOP w0.119: CV17.1 127.65,105 127.65,105.16 127.58,105.24 127.31,105.24 127.09,105.47 127.09,105.7 126.97,105.82 UV1.22
RP_DP_N1: length 11
  TOP w0.119: v1(125.76,101.35) 125.9,101.49 125.9,102.3 126.06,102.45 126.06,102.61 D21.1 126.08,103.01 126.08,103.44 CV21.2
  IN1 w0.109: v1(125.76,101.35) 125.71,101.3 v2(125.71,100.98)
  IN2 w0.079: v2(127.5,95.3) 127.67,95.47 127.67,96.23 127,96.89 125.95,97.94 125.93,97.96 125.93,97.97 125.9,97.99 125.9,98.15 125.9,100.78 v2(125.71,100.98)
  IN3 w0.084: v7(127.53,94.62) 127.68,94.76 127.68,95.11 v2(127.5,95.3)
  BOTTOM w0.119: v7(127.53,94.62) 127.61,94.69 127.61,94.82 127.52,94.91 JIO4.68
