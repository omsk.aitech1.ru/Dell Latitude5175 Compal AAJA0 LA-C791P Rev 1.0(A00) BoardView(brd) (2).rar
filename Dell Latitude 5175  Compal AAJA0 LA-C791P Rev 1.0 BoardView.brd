# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_CA_0_8: length 23
  IN3 w0.06: 80.07,122.58 79.62,122.13 v10(78.47,122.13)
  IN3 w0.076: v10(85.89,126.29) 85.72,126.29 85.5,126.51 85.19,126.51 84.74,126.97 84.35,126.97 84.3,127.02 84.3,127.14 84.38,127.22 84.81,127.22 85.27,126.77 85.55,126.77 85.76,126.55 85.97,126.55 86.14,126.72 86.14,126.95 86.23,127.04 86.9,127.04 87.38,126.56 87.84,126.56 88.07,126.33 88.07,126.06 87.94,125.93 87.61,125.93 87.5,125.83 87.4,125.83 87.3,125.72 87.02,125.72 86.95,125.65 86.95,125.55 87.02,125.47 87.56,125.47 87.66,125.57 88.01,125.57 88.18,125.39 88.18,125.21 87.99,125.02 86.48,125.02 86.32,124.87 86.32,123.89 85.91,123.47 85.91,122.45 85.7,122.24 83.35,122.24 82.3,123.29 80.95,123.29 80.72,123.07 80.55,123.07 80.07,122.58
M_A_CA_0_9: length 23.5
  IN3 w0.06: 80.37,125.04 79.72,125.04 79.64,124.96 79.64,123.19 79.26,122.82 78.51,122.82 v10(78.47,122.77)
  IN3 w0.076: 80.37,125.04 80.44,125.04 80.5,124.98 81.71,124.98 81.79,125.06 81.79,125.21 81.71,125.29 80.44,125.29 80.37,125.36 80.37,125.52 80.44,125.59 81.51,125.59 81.58,125.67 81.58,125.82 81.51,125.9 81.03,125.9 80.95,125.97 80.95,126.13 81.03,126.2 81.43,126.2 81.51,126.28 81.51,126.69 81.58,126.76 81.76,126.76 81.84,126.69 81.84,125.87 81.91,125.8 82.07,125.8 82.14,125.87 82.14,126.48 82.22,126.56 82.39,126.56 82.46,126.48 82.46,125.36 82.39,125.29 82.29,125.29 82.19,125.19 82.19,125.06 82.27,124.98 83.47,124.98 83.54,125.06 83.54,125.21 83.47,125.29 82.84,125.29 82.77,125.36 82.77,125.52 82.84,125.6 83.13,125.6 83.21,125.68 83.21,125.83 83.13,125.9 82.79,125.9 82.72,125.98 82.72,126.13 82.79,126.21 83.13,126.21 83.77,125.57 84.18,125.57 84.27,125.66 84.49,125.66 84.58,125.57 84.73,125.57 84.81,125.64 84.81,125.82 84.89,125.9 85.06,125.9 85.14,125.82 85.14,125.64 85.22,125.56 85.55,125.56 85.62,125.64 85.62,125.8 85.7,125.87 86.03,125.87 86.39,126.23 v10(86.39,126.29)
M_A_CA_1_0: length 18.3
  IN4 w0.061: v5(78.02,123.43) 79.35,123.43 79.43,123.35 79.43,123.04 79.5,122.96 81.84,122.96 82.23,122.57 83.72,122.57 83.78,122.62 83.78,123.07 84,123.29 84,124 83.8,124.2 83.01,124.2 82.93,124.28 82.93,124.51 83.03,124.61 84.15,124.61 84.28,124.48 84.28,123.95 84.35,123.88 84.35,123.77 84.2,123.62 84.2,123.44 84.27,123.37 84.38,123.37 84.56,123.55 84.67,123.55 84.84,123.39 84.84,123.15 84.72,123.03 84.11,123.03 84.03,122.96 84.03,122.8 84.11,122.73 84.84,122.73 84.95,122.61 86.58,122.61 86.69,122.73 86.69,123.12 86.67,123.15 86.67,123.97 86.89,124.2 v5(86.89,124.29)
M_A_CA_1_1: length 17.3
  IN4 w0.061: v5(86.89,124.79) 86.8,124.88 86.66,124.88 86.61,124.82 86.61,124.51 86.49,124.39 86.49,123.12 86.41,123.04 86.25,123.04 86.18,123.1 86.18,123.29 86.08,123.39 85.85,123.39 85.77,123.31 85.77,123.11 85.7,123.03 85.54,123.03 85.47,123.11 85.47,123.31 85.39,123.39 85.12,123.39 84.46,124.05 84.46,124.58 84.25,124.78 82.91,124.78 82.73,124.61 82.73,124.18 82.87,124.04 83.71,124.04 83.82,123.92 83.82,123.3 83.64,123.12 83.64,123.08 83.64,123.08 83.64,122.78 83.57,122.7 82.29,122.7 81.89,123.1 80.82,123.1 80.77,123.15 80.77,123.26 80.7,123.32 80.57,123.32 80.49,123.25 80.49,123.17 80.42,123.1 80.26,123.1 80.19,123.17 80.19,123.61 80.11,123.69 79.96,123.69 79.88,123.61 79.88,123.17 79.81,123.1 79.66,123.1 79.58,123.18 79.58,123.61 79.53,123.66 v5(78.8,123.66)
M_A_CA_1_2: length 17.9
  IN4 w0.061: v5(86.89,125.29) 86.84,125.24 86.84,125.08 86.9,125.03 87.01,125.03 87.19,124.85 87.19,124.49 87.12,124.42 87.12,124.2 87.25,124.07 87.25,123.59 87.19,123.53 86.88,123.53 86.82,123.47 86.82,123.35 86.88,123.29 87.19,123.29 87.25,123.23 87.25,123.1 87.17,123.03 86.92,123.03 86.84,122.95 86.84,122.54 86.73,122.43 86.54,122.43 86.48,122.37 86.48,122.32 86.42,122.26 86.29,122.26 86.23,122.32 86.23,122.37 86.17,122.43 86.05,122.43 85.99,122.37 85.99,121.93 85.92,121.86 85.82,121.86 85.75,121.93 85.75,122.37 85.68,122.43 85.56,122.43 85.5,122.37 85.5,121.93 85.43,121.86 85.33,121.86 85.26,121.93 85.26,122.37 85.2,122.43 85.07,122.43 85.01,122.37 85.01,121.93 84.94,121.86 84.84,121.86 84.77,121.93 84.77,122.37 84.71,122.43 84.59,122.43 84.53,122.37 84.53,121.93 84.45,121.86 84.35,121.86 84.28,121.93 84.28,122.37 84.22,122.43 84.1,122.43 84.04,122.37 84.04,122.11 83.97,122.04 83.87,122.04 83.79,122.11 83.79,122.37 83.73,122.43 82.18,122.43 81.78,122.82 79.32,122.82 79.25,122.9 79.25,123.05 79.15,123.15 79.04,123.15 78.91,123.02 78.73,123.02 78.72,123.03 78.52,123.23 v5(78.37,123.23)
M_A_CA_1_3: length 15.2
  IN4 w0.06: 79.37,122.57 78.88,122.57 78.67,122.78 78.67,122.86 78.55,122.97 78.38,122.97 78.22,122.81 78.17,122.81 78.17,122.81 78,122.81 78,122.81 77.96,122.81 77.85,122.71 77.85,122.68 77.72,122.55 77.65,122.55 77.57,122.47 77.57,122.47 77.45,122.36 77.45,122.19 77.53,122.11 77.53,121.89 77.53,121.89 77.53,121.72 77.53,121.72 77.68,121.57 77.68,121.4 77.61,121.33 77.55,121.28 77.53,121.26 77.53,121.25 77.53,121.24 77.53,121.08 77.77,120.83 77.77,120.76 77.77,120.76 78.01,120.52 v5(78.22,120.52)
  IN4 w0.061: v5(87.39,124.29) 87.39,122.9 86.2,121.7 83.99,121.7 83.4,122.29 81.88,122.29 81.5,122.67 79.48,122.67 79.37,122.57
M_A_CA_1_4: length 18.9
  IN3 w0.076: v10(87.39,124.79) 87.25,124.65 87.25,123.61 87.16,123.53 87.01,123.53 86.94,123.59 86.77,123.59 86.69,123.67 86.69,123.82 86.77,123.9 86.89,123.9 86.97,123.98 86.97,124.13 86.89,124.21 86.77,124.21 86.69,124.28 86.69,124.43 86.77,124.51 86.89,124.51 86.97,124.59 86.97,124.71 86.89,124.79 86.6,124.79 86.48,124.67 86.48,123.79 86.26,123.57 86.26,123.39 86.31,123.34 86.77,123.34 86.92,123.18 86.92,123.08 86.8,122.96 86.69,122.96 86.56,123.09 86.25,123.09 86.08,122.92 86.08,122.57 86.18,122.47 86.34,122.47 86.45,122.59 v6(86.45,122.84) ; v6(83.4,123.59) 83.72,123.91 83.72,124.12 83.63,124.21 83.53,124.21 83,123.68 83,123.57 83.55,123.03 v6(85.12,123.03)
  IN4 w0.061: v5(78.8,124.09) 80.62,124.09 80.92,124.39 81.68,124.39 82.47,123.59 v6(83.4,123.59) ; v6(86.45,122.84) 85.31,122.84 v6(85.12,123.03)
M_A_CA_1_5: length 17
  IN4 w0.06: 86.71,121.37 86.92,121.58 87.8,121.58
  IN4 w0.061: v5(88.89,124.79) 88.85,124.75 88.85,123.69 88.79,123.63 88.65,123.63 88.59,123.57 88.59,123.45 88.65,123.39 88.79,123.39 88.85,123.33 88.85,123.2 88.79,123.14 88.45,123.14 88.38,123.07 88.38,122.97 88.45,122.9 88.79,122.9 88.85,122.84 88.85,122.72 88.79,122.66 88.46,122.66 88.39,122.58 88.39,122.48 88.46,122.41 88.79,122.41 88.85,122.35 88.85,122.16 88.72,122.03 88.25,122.03 87.8,121.58 ; v5(78.47,121.48) 78.85,121.48 79.09,121.73 80.11,121.73 80.19,121.8 80.19,122.02 80.27,122.09 80.42,122.09 80.5,122.02 80.5,121.8 80.57,121.73 80.72,121.73 80.79,121.8 80.79,122.06 80.93,122.19 81.31,122.19 81.9,121.6 81.9,121.49 81.9,121.44 82.04,121.3 82.47,121.3 82.58,121.2 83.64,121.2 83.79,121.04 86.38,121.04 86.71,121.37
M_A_CA_1_6: length 20
  IN4 w0.061: v5(78.37,123.66) 78.5,123.66 78.7,123.86 80.92,123.86 81.13,123.65 81.46,123.65 81.71,123.4 82.42,123.4 82.69,123.13 83.36,123.13 83.64,123.41 83.64,123.71 83.51,123.84 82.68,123.84 82.53,124 82.53,124.63 82.88,124.99 84.35,124.99 84.66,124.68 84.66,124.15 85.24,123.57 86.03,123.57 86.32,123.86 86.32,124.51 86.42,124.6 86.42,124.92 86.63,125.14 86.63,125.41 86.75,125.52 87.04,125.52 87.14,125.42 87.14,125.16 87.26,125.05 87.51,125.05 87.65,125.19 87.65,125.44 87.12,125.98 87.12,126.37 87.27,126.52 87.46,126.52 87.58,126.4 87.58,126.03 87.71,125.9 87.96,125.9 88.57,125.29 v5(88.89,125.29)
M_A_CA_1_7: length 19.4
  IN3 w0.076: v6(89.12,126.94) v6(89.12,127.57)
  IN4 w0.06: 79.68,124.59 78.63,124.59 78.33,124.29 78.25,124.29 78.02,124.05 v5(78.02,123.9)
  IN4 w0.061: v5(89.39,124.29) 89.39,124.12 89.56,123.96 89.7,123.96 89.83,124.09 89.83,125.48 89.66,125.65 89.66,126.4 v6(89.12,126.94) ; 79.68,124.59 80.25,124.59 81.35,125.69 82.1,125.69 83.59,127.18 83.59,128.03 84.65,129.09 85.87,129.09 86.17,129.38 86.17,129.38 86.3,129.52 86.51,129.52 86.67,129.36 86.67,129.19 86.8,129.05 87.64,129.05 v6(89.12,127.57)
M_A_CA_1_8: length 18.8
  IN3 w0.076: v6(80.14,124.81) 83.52,124.81 84.12,125.42 85.09,125.42 85.1,125.4 85.63,125.4 85.8,125.57 86.43,125.57 86.59,125.72 86.59,125.85 86.75,126.01 86.89,126.01 87.02,125.88 87.22,125.88 87.35,126.01 87.44,126.01 87.57,126.14 87.57,126.33 87.65,126.41 87.75,126.41 87.83,126.33 v6(87.83,126.18)
  IN4 w0.061: v5(89.39,124.79) 89.39,124.72 89.46,124.65 89.53,124.65 89.65,124.77 89.65,125.38 89.51,125.53 89.32,125.53 89.15,125.7 89.15,125.93 89.26,126.03 89.33,126.03 89.43,126.13 89.43,126.4 89.29,126.55 88.88,126.55 88.81,126.62 88.81,126.91 88.73,126.99 88.36,126.99 88.29,126.91 88.29,126.74 88.59,126.44 88.59,126.26 88.51,126.18 88.51,126.07 88.48,126.04 88.22,126.04 88.07,126.19 88.07,126.63 87.91,126.79 87.71,126.79 87.66,126.74 87.66,126.59 87.83,126.42 v6(87.83,126.18) ; v5(77.7,124.15) 78.1,124.56 78.37,124.56 78.55,124.74 80.07,124.74 v6(80.14,124.81)
M_A_CA_1_9: length 15
  IN4 w0.06: v5(78.71,120.52) 78.71,120.88 78.88,121.04 78.88,121.04 79.04,121.04 79.14,120.94 79.4,120.94 79.46,121 79.72,121
  IN4 w0.061: v5(89.39,125.29) 89.39,125.18 89.13,124.92 89.13,122.05 88.85,121.77 88.24,121.77 87.35,120.89 83.71,120.89 83.55,121.04 82.47,121.04 82.38,121.12 81.97,121.12 81.76,120.91 81.3,120.91 81.15,121.06 79.79,121.06 79.72,121
M_A_CK_DDR0_DN: length 13.8
  IN3 w0.06: 80.3,121.85 80.29,121.85 80.28,121.84 80.2,121.84 80.01,122.02 79.79,122.02 79.68,121.91 79.02,121.91 78.83,121.73 78.79,121.73 v10(78.71,121.81) ; v10(78.71,121.81) 78.71,121.81 v10(78.71,121.81)
  IN3 w0.091: v10(88.39,124.79) 88.39,124.79 88.17,124.57 88.06,124.57 87.99,124.5 87.91,124.41 87.9,124.41 87.9,124.41 87.8,124.41 87.68,124.53 87.57,124.53 87.47,124.42 87.47,124.31 87.59,124.19 87.59,124.09 87.43,123.94 87.43,123.31 86.16,122.04 83.04,122.04 82.53,122.55 82.53,122.8 82.3,123.03 81.97,123.03 81.56,122.63 80.96,122.63 80.8,122.79 80.53,122.79 80.34,122.6 80.34,122.28 80.43,122.19 80.6,122.03 80.6,121.99 80.6,121.93 80.58,121.9 80.52,121.85 80.3,121.85
M_A_CK_DDR0_DP: length 13.9
  IN3 w0.06: 80.3,121.7 80.29,121.71 80.15,121.71 79.96,121.9 79.84,121.9 79.73,121.79 79.07,121.79 78.88,121.61 78.82,121.61 78.8,121.59 78.62,121.59 78.49,121.72 78.41,121.81 v10(78.22,121.81)
  IN3 w0.091: v10(88.39,124.29) 88.27,124.41 88.13,124.41 87.59,123.87 87.59,123.25 86.22,121.89 82.98,121.89 82.37,122.49 82.37,122.74 82.23,122.88 82.03,122.88 81.63,122.47 80.89,122.47 80.73,122.63 80.59,122.63 80.5,122.54 80.5,122.34 80.54,122.3 80.75,122.09 80.75,121.99 80.75,121.99 80.75,121.86 80.64,121.75 80.64,121.75 80.59,121.7 80.3,121.7
M_A_CK_DDR1_DN: length 20.9
  IN3 w0.091: v6(81.59,121.63) 81.6,121.63 81.82,121.41 82.06,121.41 82.35,121.12 86.5,121.12 87.28,121.9 87.52,121.9 87.76,121.65 87.92,121.65 89.38,123.12 89.38,126.13 88.62,126.89 88.62,127.04 87.98,127.68 87.87,127.68 87.75,127.56 87.75,127.47 v6(87.79,127.43)
  IN4 w0.06: 80.07,121.54 79.11,121.54 78.93,121.36 78.63,121.36 78.49,121.23 78.43,121.16 v5(78.22,121.16)
  IN4 w0.069: v6(87.79,127.43) 87.55,127.43 87.15,127.04 85.82,127.04 85.57,127.29 v5(85.39,127.29)
  IN4 w0.076: 80.07,121.54 80.4,121.54 80.48,121.45 81.42,121.45 v6(81.59,121.63)
M_A_CK_DDR1_DP: length 20.9
  IN3 w0.091: v6(87.43,127.8) 87.78,127.8 87.81,127.83 88.04,127.83 88.78,127.1 88.78,126.96 89.54,126.2 89.54,123.18 89.54,123.18 89.54,123.05 87.99,121.5 87.69,121.5 87.45,121.74 87.35,121.74 86.57,120.96 82.29,120.96 82,121.25 81.76,121.25 81.76,121.26 81.73,121.26 v6(81.59,121.12)
  IN4 w0.06: v5(78.71,121.16) 78.78,121.23 78.98,121.23 79.15,121.39 80.05,121.39 80.07,121.38
  IN4 w0.069: v5(85.89,127.29) 86.01,127.17 86.19,127.17 86.25,127.23 86.25,127.48 86.33,127.55 86.48,127.55 86.55,127.48 86.55,127.26 86.65,127.17 87.1,127.17 87.43,127.5 v6(87.43,127.8)
  IN4 w0.076: v6(81.59,121.12) 81.42,121.29 80.42,121.29 80.33,121.38 80.07,121.38
M_A_CKE0: length 23.4
  IN3 w0.06: v10(77.48,121.48) 77.8,121.48 77.88,121.41 77.88,121.24 77.94,121.18 78.06,121.18 78.12,121.24 78.12,121.41 78.18,121.47 78.29,121.47 78.35,121.41 78.35,121.14 78.41,121.08 78.53,121.08 78.59,121.14 78.59,121.41 78.65,121.47 78.76,121.47 78.82,121.41 78.82,120.96 78.88,120.9 79,120.9 79.06,120.96 79.06,120.97 79.12,121.03 79.33,121.03 79.4,121.1 79.4,121.2 79.33,121.27 79.12,121.27 79.06,121.33 79.06,121.41 79.12,121.47 79.25,121.47 79.25,121.47 79.31,121.47
  IN3 w0.076: v10(87.89,124.79) 88.07,124.79 88.29,125.01 88.3,125.02 88.39,125.02 88.48,125.1 88.48,125.31 88.05,125.74 88.05,125.81 88.16,125.92 88.24,125.92 88.67,125.5 88.67,123.38 88.2,122.91 88.07,122.91 87.99,123 87.99,123.13 88.34,123.48 88.34,123.99 88.26,124.07 88.03,124.07 87.88,123.92 87.77,123.81 87.77,123.7 87.88,123.59 87.88,123.46 87.76,123.33 87.76,123.18 86.27,121.69 82.86,121.69 82.08,122.47 81.94,122.47 81.67,122.19 81.27,122.19 81.18,122.29 80.97,122.29 80.9,122.22 80.9,122.16 80.95,122.11 80.95,121.56 80.86,121.47 80.19,121.47 80.07,121.58 79.93,121.58 79.88,121.53 79.88,121.33 79.81,121.25 79.65,121.25 79.58,121.33 79.58,121.49 79.5,121.57 79.4,121.57 79.31,121.47
M_A_CKE1: length 23.8
  IN3 w0.06: 80.07,122.83 79.52,122.26 78.81,122.26 78.79,122.25 78.63,122.25 78.54,122.34 78.37,122.34 78.37,122.33 78.36,122.33 78.27,122.25 78.27,122.21 78.27,122.21 78.27,122.12 78.14,122 78.13,122 77.94,121.81 v10(77.73,121.81)
  IN3 w0.076: 80.07,122.83 80.48,123.25 80.65,123.25 80.83,123.43 82.38,123.43 83.39,122.42 85.59,122.42 85.75,122.57 85.75,123.53 86.16,123.95 86.16,124.73 86.17,124.75 86.17,124.93 86.16,124.95 86.16,125.09 86.08,125.17 85.88,125.17 85.48,124.76 84.93,124.76 84.33,124.16 84.33,124.02 84.51,123.85 84.51,123.74 84.43,123.66 84.33,123.66 83.9,124.1 83.9,124.18 84.38,124.66 84.48,124.66 84.55,124.73 84.55,124.84 84.44,124.95 84.34,124.95 83.94,124.55 83.83,124.55 83.77,124.61 83.77,124.73 84.3,125.26 84.56,125.26 84.63,125.19 84.63,125.01 84.71,124.94 84.86,124.94 84.94,125.01 84.94,125.19 85.01,125.26 85.02,125.26 85.02,125.26 85.12,125.26 85.2,125.19 85.2,125.04 85.27,124.96 85.43,124.96 85.5,125.04 85.5,125.19 85.58,125.26 85.71,125.26 85.84,125.39 86.18,125.39 86.25,125.32 86.25,125.27 86.33,125.19 86.48,125.19 86.56,125.27 86.56,125.44 86.63,125.52 86.74,125.52 87.09,125.18 87.22,125.18 87.34,125.29 87.53,125.29 87.64,125.18 87.78,125.18 v10(87.89,125.29)
M_A_CKE2: length 24.6
  IN3 w0.076: v6(87.83,122.32) 87.78,122.26 87.78,122.12 87.88,122.02 88.02,122.02 88.11,122.11 88.12,122.11 89.18,123.17 89.18,126.05 89.13,126.11 88.98,126.11 88.93,126.05 88.8,126.05 88.63,126.23 88.63,126.42 88.01,127.04 87.6,127.04 87.1,127.54 85.29,127.54 85.03,127.79 85.03,127.93 85.16,128.06 85.24,128.06 85.51,127.79 v10(85.89,127.79)
  IN4 w0.06: 80.92,122.51 80.92,122.51 79.77,122.51 79.55,122.29 79.08,122.29 79.04,122.33 78.88,122.33 78.8,122.25 78.8,122.25 78.63,122.25 78.58,122.3 78.58,122.3 78.55,122.33 78.22,122.33 78.14,122.41 77.92,122.41 77.78,122.27 v5(77.65,122.27)
  IN4 w0.061: 80.92,122.51 81.42,122.51 81.8,122.14 83.34,122.14 83.51,121.96 83.51,121.95 84.09,121.37 86.28,121.37 86.83,121.91 87.49,121.91 87.58,122 87.58,123.14 87.67,123.23 87.84,123.23 87.91,123.16 87.91,122.55 87.83,122.47 v6(87.83,122.32)
M_A_CKE3: length 22.2
  IN3 w0.076: v6(88.87,126.32) 88.87,126.38 88.81,126.44 88.81,126.45 88.07,127.2 87.71,127.2 87.11,127.79 v10(86.39,127.79)
  IN4 w0.06: 86.51,121.37 86.89,121.76 87.74,121.76 ; 79.31,121.93 79.13,121.93 78.8,121.6 78.63,121.6 78.55,121.68 78.38,121.68 78.27,121.57 78.27,121.49 78.02,121.24 78.02,121.08 78.26,120.84 v5(78.47,120.84) ; 80.92,122.38 80.32,122.38
  IN4 w0.061: 79.31,121.93 79.69,121.93 79.74,121.88 79.86,121.88 79.94,121.96 79.94,122.06 79.9,122.1 79.9,122.2 79.97,122.27 80.21,122.27 80.32,122.38 ; 87.74,121.76 88.11,122.13 88.11,123.23 88.17,123.29 88.34,123.29 88.41,123.36 88.41,123.46 88.34,123.54 88.17,123.54 87.77,123.94 87.77,124.01 87.83,124.07 88.56,124.07 88.64,124.14 88.64,124.91 88.76,125.02 88.97,125.02 89.14,125.19 89.14,125.39 89,125.53 88.77,125.53 88.67,125.63 88.67,125.94 88.74,126.01 88.91,126.01 88.99,126.09 88.99,126.24 88.91,126.32 v6(88.87,126.32) ; 80.92,122.38 81.37,122.38 81.83,121.91 82.19,121.91 82.77,121.33 83.73,121.33 83.88,121.18 86.31,121.18 86.51,121.37
M_A_CS0_N: length 25.1
  IN4 w0.061: v5(78.96,120.84) 79.04,120.75 79.76,120.75 79.89,120.88 81.03,120.88 81.13,120.77 81.87,120.77 82.07,120.97 82.35,120.97 82.41,120.9 83.49,120.9 83.64,120.75 87.41,120.75 88.28,121.62 89.02,121.62 89.3,121.9 89.3,122.74 90.14,123.57 90.14,126.28 89.24,127.17 88.69,127.17 88.63,127.23 88.4,127.23 88.36,127.27 ; v5(86.39,128.29) 86.62,128.06 87.08,128.06 87.16,128.14 87.16,128.29 87.24,128.37 87.39,128.37 87.47,128.29 87.47,128.16 87.58,128.05 87.69,128.05 87.76,128.13 87.87,128.13 87.98,128.02 87.98,127.91 87.88,127.81 87.88,127.7 87.99,127.59 88.09,127.59 88.19,127.69 88.3,127.69 88.41,127.59 88.41,127.48 88.33,127.4 88.33,127.3 88.36,127.27 ; 88.36,127.27 88.36,127.23 88.16,127.03 87.47,127.03 86.97,126.53 86.82,126.53 86.8,126.52 86.8,126.52 86.67,126.38 86.67,126.16 87.39,125.44 v5(87.39,125.29)
M_A_CS1_N: length 25.4
  IN3 w0.076: v6(86.26,125.79) 86.7,126.23 v6(87.35,126.23)
  IN4 w0.06: v5(77.65,123.26) 77.82,123.43 77.82,123.51 77.82,123.58 77.94,123.7 78.11,123.7 78.29,123.88 78.46,123.88 78.58,124 78.58,124.14 78.6,124.17 78.6,124.17 78.72,124.29 78.72,124.29 78.74,124.3 78.89,124.3 78.95,124.25 79.05,124.25 ; 82.91,125.26 82.37,124.73
  IN4 w0.061: 82.37,124.73 82.37,124.73 82.37,124.27 82.27,124.17 82.12,124.17 82.02,124.27 82.02,124.48 81.94,124.55 80.8,124.55 80.49,124.25 79.05,124.25 ; v5(85.39,127.79) 85.05,127.79 84.96,127.7 84.96,127.57 84.9,127.51 84.9,127.42 85.19,127.13 85.78,126.54 86.04,126.54 86.14,126.43 86.14,126.14 86.03,126.03 85.93,126.03 85.85,125.95 85.85,125.75 85.94,125.66 86.05,125.66 86.17,125.79 v6(86.26,125.79) 86.26,125.52 86.19,125.45 86.19,125.4 86.17,125.38 86.17,125.2 86.26,125.1 86.26,124.71 86.17,124.62 86.17,124.21 86.01,124.05 85.29,124.05 85.13,124.21 85.13,124.91 84.98,125.06 84.81,125.06 84.81,125.07 84.73,125.07 84.54,125.25 84.54,125.98 84.47,126.05 84.31,126.05 84.24,125.98 84.24,125.25 84.16,125.18 84.01,125.18 83.93,125.25 83.93,125.98 83.86,126.05 83.7,126.05 83.63,125.98 83.63,125.25 83.55,125.18 83.4,125.18 83.32,125.25 83.32,126.13 83.25,126.21 83.09,126.21 82.95,126.06 82.95,125.3 82.91,125.26 ; v6(87.35,126.23) 87.35,126.03 87.71,125.66 87.9,125.66 88.15,125.42 88.15,124.54 v5(87.89,124.29)
M_A_DQ_0: length 29.6
  IN4 w0.06: 79.43,117.12 79.09,117.12 79.04,117.17 78.88,117.17 78.76,117.06 78.76,117.06 78.68,116.97 v5(78.47,116.97)
  IN4 w0.061: 79.43,117.12 79.48,117.12 79.59,117.02 81.15,117.02 81.48,117.34 84.64,117.34 85.3,118 90.4,118 92.39,119.99 94,119.99 95.58,121.57 95.58,128.56 95.17,128.97 93.12,128.97 92.94,128.79 v5(92.39,128.79)
M_A_DQ_1: length 29.2
  IN4 w0.06: 79.46,117.42 79.04,117.42 78.87,117.42 78.79,117.5 78.79,117.5 78.79,117.5 78.63,117.5 78.49,117.36 78.43,117.3 v5(78.22,117.3)
  IN4 w0.061: 79.46,117.42 79.68,117.42 79.73,117.37 80.83,117.37 81.15,117.69 84.53,117.69 85.11,118.27 90.29,118.27 92.28,120.26 93.88,120.26 95.28,121.66 95.28,128.18 95.05,128.41 93.14,128.41 92.76,128.03 92.28,128.03 92.02,128.29 v5(91.89,128.29)
M_A_DQ_2: length 26.5
  IN4 w0.06: v5(78.71,117.94) 79.22,117.94 79.28,117.88 79.75,117.88
  IN4 w0.061: 79.75,117.88 80.54,117.88 80.83,118.16 84.38,118.16 84.9,118.69 90.12,118.69 91.31,119.88 91.31,120.46 91.58,120.73 93.67,120.73 94.85,121.91 94.85,126.39 94.53,126.71 93.86,126.71 93.56,127.01 v5(93.56,128.06)
  BOTTOM w0.076: U35.J16 92.64,128.04 93.01,128.04 93.26,128.04
  BOTTOM w0.119: 93.26,128.04 93.54,128.04 v5(93.56,128.06)
M_A_DQ_3: length 26.8
  IN4 w0.06: 79.93,118 79.34,118 79.28,118.06 79.04,118.06 78.88,118.06 78.8,118.14 78.73,118.14 78.63,118.14 78.55,118.06 78.43,117.94 v5(78.22,117.94)
  IN4 w0.061: v5(93.33,127.65) 93.36,127.62 93.36,126.95 93.75,126.56 94.33,126.56 94.72,126.18 94.72,122.01 94.06,121.35 92.01,121.35 91.18,120.52 91.18,119.94 90.06,118.82 84.84,118.82 84.35,118.33 80.7,118.33 80.43,118.06 79.99,118.06 79.93,118
  BOTTOM w0.076: U35.J15 92.13,127.55 92.79,127.55 92.79,127.55 93.11,127.55
  BOTTOM w0.119: v5(93.33,127.65) 93.21,127.65 93.11,127.55
M_A_DQ_4: length 28.6
  IN4 w0.06: 79.46,117.29 78.71,117.29 v5(78.71,117.3)
  IN4 w0.061: 79.46,117.29 79.56,117.29 79.66,117.19 80.91,117.19 81.2,117.49 84.58,117.49 85.23,118.14 90.35,118.14 92.34,120.13 93.94,120.13 95.43,121.61 95.43,128.31 95.07,128.67 93.14,128.67 92.96,128.49 92.59,128.49 v5(92.39,128.29)
M_A_DQ_5: length 30.2
  IN4 w0.06: 79.48,116.86 79.37,116.97 78.96,116.97 v5(78.96,116.97)
  IN4 w0.061: 79.48,116.86 81.36,116.86 81.66,117.16 84.66,117.16 85.34,117.85 90.44,117.85 92.45,119.85 94.06,119.85 95.72,121.51 95.72,121.63 95.72,121.63 95.72,128.81 95.26,129.27 93.19,129.27 92.96,129.04 92.14,129.04 v5(91.89,128.79)
M_A_DQ_6: length 26.3
  IN4 w0.06: 94.44,123.71 94.44,124.81 ; 80.06,118.41 79.94,118.41 79.77,118.24 79.45,118.24 79.23,118.46 78.88,118.46 78.68,118.26 v5(78.47,118.26)
  IN4 w0.061: 80.06,118.41 80.07,118.41 80.34,118.68 84.32,118.68 84.73,119.1 89.95,119.1 90.9,120.05 90.9,120.63 91.89,121.63 93.85,121.63 94.44,122.22 94.44,123.71 ; 94.44,124.81 94.44,125.81 94.01,126.24 93.61,126.24 91.98,127.88 91.63,127.88 91.48,128.03 91.15,128.03 v5(90.89,128.29)
M_A_DQ_7: length 26
  IN4 w0.06: 94.58,123.84 94.58,124.67 ; 79.95,118.22 79.85,118.12 79.4,118.12 79.26,118.26 v5(78.96,118.26)
  IN4 w0.061: 94.58,123.84 94.58,122.09 93.98,121.49 91.95,121.49 91.04,120.58 91.04,119.99 90,118.96 84.79,118.96 84.33,118.51 80.52,118.51 80.24,118.22 79.95,118.22 ; v5(91.39,128.29) 91.44,128.34 91.52,128.34 91.66,128.19 91.66,128.15 91.78,128.03 92.05,128.03 92.56,127.52 93.06,127.52 93.13,127.45 93.13,126.95 93.67,126.42 94.02,126.42 94.58,125.87 94.58,124.67
M_A_DQ_8: length 21.5
  IN4 w0.06: 80.12,118.94 79.97,118.79 79.25,118.79 79.17,118.71 79.04,118.71 78.88,118.71 78.8,118.78 78.79,118.78 78.63,118.78 78.43,118.59 v5(78.22,118.59)
  IN4 w0.061: 80.12,118.94 80.19,119.01 84.1,119.01 84.52,119.43 88.99,119.43 89,119.43 89.11,119.43 90.74,121.06 90.74,121.06 91.66,121.99 93.29,121.99 93.46,122.15 93.46,124.69 93.57,124.8 93.77,124.8 93.85,124.88 93.85,125 v5(93.79,125.06)
  BOTTOM w0.076: 93.26,125.06 92.66,125.06 U35.C16
  BOTTOM w0.119: 93.26,125.06 v5(93.79,125.06)
M_A_DQ_9: length 20.1
  IN4 w0.061: v5(78.71,118.59) 79.36,118.59 79.43,118.52 79.43,118.47 79.51,118.39 79.53,118.39 79.71,118.39 79.96,118.64 80.07,118.64 80.3,118.87 84.2,118.87 84.62,119.29 88.94,119.29 89.17,119.29 90.8,120.93 91.71,121.83 93.59,121.83 93.72,121.97 v5(93.72,123.99)
  BOTTOM w0.076: 93.26,124.04 92.64,124.04 U35.B16
  BOTTOM w0.119: 93.26,124.04 93.67,124.04 v5(93.72,123.99)
M_A_DQ_10: length 16.7
  IN4 w0.061: v5(78.22,119.87) 78.43,119.87 78.8,120.25 79.62,120.25 79.68,120.31 79.68,120.5 79.76,120.58 80.24,120.58 80.29,120.63 81.95,120.63 82.06,120.75 82.36,120.75 82.81,120.3 83.46,120.3 83.62,120.45 83.62,120.55 83.68,120.61 87.47,120.61 88.28,121.43 89.36,121.43 90.7,122.77 90.7,123.52 90.63,123.59 90.63,124.86 90.7,124.93 90.79,124.93 90.89,124.83 v5(90.89,124.79)
M_A_DQ_11: length 17.1
  IN4 w0.06: 79.08,119.97 78.98,119.87 78.91,119.8 78.91,119.79 78.79,119.67 78.79,119.67 78.66,119.55 v5(78.47,119.55)
  IN4 w0.061: v5(91.39,124.79) 91.39,124.89 91.3,124.98 91.21,124.98 91.14,124.91 91.14,124.14 90.99,123.99 90.99,123.5 91.08,123.41 91.08,122.67 88.67,120.26 84.05,120.26 83.76,119.97 82.64,119.97 82.26,120.35 80.5,120.35 80.45,120.3 80.04,120.3 79.98,120.25 79.98,120.06 79.91,119.98 79.09,119.98 79.08,119.97
M_A_DQ_12: length 18.9
  IN4 w0.06: v5(78.47,118.91) 78.26,118.91 78.14,119.03 78.14,119.03 78.02,119.15 78.02,119.31 78.14,119.43 78.3,119.43 78.32,119.41 78.33,119.41 78.38,119.35 78.55,119.35 78.57,119.37 78.57,119.37 78.63,119.43 78.8,119.43 78.85,119.37 78.85,119.37 78.88,119.35 79.1,119.35 79.25,119.5
  IN4 w0.061: 79.25,119.5 79.46,119.71 80.8,119.71 80.87,119.78 80.87,119.98 80.95,120.06 81.1,120.06 81.18,119.98 81.18,119.78 81.25,119.71 81.49,119.71 81.79,120 82.1,120 82.46,119.65 83.87,119.65 84.2,119.98 86.27,119.98 88.83,119.98 91.39,122.55 91.39,123.46 91.65,123.72 91.65,124.71 91.73,124.79 v5(91.89,124.79)
M_A_DQ_13: length 21.8
  IN4 w0.06: 80.07,119.13 79.91,118.98 79.03,118.98 v5(78.96,118.91)
  IN4 w0.061: 80.07,119.13 80.13,119.19 84.05,119.19 84.42,119.57 85.94,119.57 89.05,119.57 91.87,122.38 91.87,122.89 92.06,123.08 92.58,123.08 92.63,123.03 92.63,122.82 92.74,122.72 92.86,122.72 92.97,122.83 92.97,124.93 92.62,125.28 92.62,125.46 92.54,125.53 91.7,125.53 91.62,125.45 91.62,125.11 91.67,125.06 91.95,125.06 92.13,124.88 92.13,124.53 v5(91.89,124.29)
M_A_DQ_14: length 16.2
  IN4 w0.061: v5(91.39,124.29) 91.39,124.13 91.15,123.89 91.15,123.59 91.26,123.49 91.26,122.62 91.15,122.51 88.97,120.33 88.76,120.12 84.11,120.12 83.79,119.8 82.54,119.8 82.13,120.21 80.82,120.21 80.72,120.11 80.72,119.93 80.64,119.85 80.52,119.85 80.44,119.93 80.44,120.06 80.37,120.13 80.21,120.13 80.14,120.06 80.14,119.93 80.06,119.85 79.26,119.85 v5(78.96,119.55)
M_A_DQ_15: length 15.9
  IN4 w0.061: v5(78.71,119.87) 78.94,120.11 79.74,120.11 79.86,120.22 79.86,120.35 79.93,120.42 80.36,120.42 80.42,120.49 82.04,120.49 82.1,120.56 82.33,120.56 82.75,120.13 83.73,120.13 84.04,120.45 87.51,120.45 87.93,120.87 88.37,120.87 88.44,120.94 88.44,120.95 88.44,120.96 88.44,121.17 88.54,121.27 88.69,121.27 88.78,121.17 88.78,121.12 88.96,120.94 89.1,120.94 90.95,122.79 90.95,123.34 90.84,123.45 90.84,124.24 v5(90.89,124.29)
M_A_DQ_16: length 21.3
  IN3 w0.06: v10(77.23,119.87) 77.44,119.87 77.53,119.79 77.53,119.79 77.64,119.67 77.81,119.67 77.84,119.7 79.67,119.7
  IN3 w0.076: v10(91.39,126.29) 91.39,126.25 91.44,126.2 91.59,126.2 91.68,126.29 91.68,126.66 91.61,126.74 91.39,126.74 91.2,126.55 90.79,126.55 90.39,126.15 90.39,125.11 90.86,124.65 90.98,124.65 91.21,124.42 91.21,124.12 91.01,123.92 90.93,123.92 90.8,123.79 90.8,123.71 91.01,123.51 91.01,123.21 87.8,120 81.71,120 81.49,119.78 79.75,119.78 79.67,119.7
M_A_DQ_17: length 19.8
  IN3 w0.06: 79.86,119.45 79.85,119.43 77.81,119.43 77.81,119.43 77.64,119.43 77.57,119.35 77.56,119.35 77.4,119.35 77.39,119.35 77.32,119.43 77.31,119.43 77.19,119.55 v10(76.99,119.55)
  IN3 w0.076: 79.86,119.45 81.64,119.45 81.84,119.65 87.99,119.65 91.58,123.24 91.58,123.91 91.8,124.12 92.13,124.12 92.28,124.27 92.28,124.53 92.15,124.65 91.53,124.65 v10(90.89,125.29)
M_A_DQ_18: length 21.3
  IN3 w0.06: v10(77.48,118.91) 80.13,118.91
  IN3 w0.076: v10(90.89,125.79) 91.8,124.88 92.61,124.88 92.81,124.68 92.81,122.64 91.95,121.78 90.88,121.78 88.19,119.09 82.09,119.09 81.91,118.91 80.13,118.91
M_A_DQ_19: length 22
  IN3 w0.06: v10(76.99,118.91) 77.2,118.91 77.28,118.83 77.28,118.82 77.4,118.71 77.56,118.71 77.57,118.71 77.64,118.79 77.83,118.79 77.87,118.74 80.08,118.74
  IN3 w0.076: 80.08,118.74 82.05,118.74 82.22,118.91 88.26,118.91 90.87,121.52 91.98,121.52 93.01,122.55 93.01,124.75 92.66,125.11 92.07,125.11 v10(91.39,125.79)
M_A_DQ_20: length 21.2
  IN3 w0.06: 79.8,119.61 79.76,119.56 77.87,119.56 77.86,119.55 77.59,119.55 77.58,119.56 77.49,119.56 v10(77.48,119.55)
  IN3 w0.076: 79.8,119.61 81.54,119.61 81.76,119.83 87.88,119.83 91.39,123.34 91.39,123.51 91.22,123.68 91.22,123.85 91.49,124.12 91.49,124.4 91.06,124.83 90.93,124.83 90.65,125.11 90.65,125.9 90.56,125.99 90.56,126.04 90.72,126.2 90.83,126.2 91.06,125.96 91.21,125.96 91.24,126 92.05,126 92.18,126.13 92.18,126.3 92.08,126.4 92,126.4 v10(91.89,126.29)
M_A_DQ_21: length 22.5
  IN3 w0.06: v10(77.73,119.87) 79.61,119.87
  IN3 w0.076: 79.61,119.87 79.68,119.94 81.39,119.94 81.64,120.18 87.77,120.18 90.83,123.25 90.83,123.46 90.65,123.64 90.65,123.97 90.78,124.09 90.91,124.09 91.03,124.22 91.03,124.37 90.93,124.48 90.8,124.48 90.22,125.06 90.22,126.22 90.42,126.43 90.42,126.98 90.5,127.06 90.68,127.06 90.95,126.79 91.11,126.79 91.36,127.03 91.68,127.03 92.02,126.69 92.69,126.69 92.81,126.57 92.81,126.41 92.7,126.29 v10(92.39,126.29)
M_A_DQ_22: length 21.3
  IN3 w0.06: v10(77.73,118.59) 80.16,118.59
  IN3 w0.076: v10(91.89,125.79) 92,125.79 92.28,125.52 92.71,125.52 93.22,125.01 93.22,122.49 92.08,121.35 90.93,121.35 88.32,118.73 82.32,118.73 82.17,118.59 80.16,118.59
M_A_DQ_23: length 22
  IN3 w0.06: v10(77.23,118.59) 77.44,118.59 77.53,118.5 77.65,118.38 77.81,118.38 77.85,118.42 80.22,118.42
  IN3 w0.076: 80.22,118.42 82.23,118.42 82.4,118.58 88.38,118.58 90.95,121.15 92.13,121.15 93.42,122.44 93.42,125.26 92.89,125.79 v10(92.39,125.79)
M_A_DQ_24: length 28.8
  IN3 w0.06: 79.88,118.1 77.85,118.1 77.81,118.14 77.64,118.14 77.56,118.06 77.4,118.06 77.39,118.06 77.19,118.26 v10(76.99,118.26)
  IN3 w0.076: v10(90.89,129.29) 91.9,128.28 94.06,128.28 94.4,127.94 94.4,126.64 94.55,126.48 94.55,122.97 92.32,120.74 91.06,120.74 88.59,118.28 82.63,118.28 82.45,118.1 79.89,118.1 79.88,118.1
M_A_DQ_25: length 27.5
  IN3 w0.06: v10(77.48,118.26) 80.55,118.26
  IN3 w0.076: 80.55,118.26 82.33,118.26 82.5,118.43 88.52,118.43 91.03,120.94 92.25,120.94 94.4,123.1 94.4,126.42 94.25,126.57 94.25,127.88 94.03,128.1 91.83,128.1 91.14,128.79 v10(90.89,128.79)
M_A_DQ_26: length 29.5
  IN3 w0.06: 79.44,117.27 79.41,117.31 77.74,117.31 v10(77.73,117.3)
  IN3 w0.076: v10(92.39,129.79) 94.05,129.79 95.18,128.66 95.18,126.97 95.4,126.75 95.4,122.43 92.72,119.75 91.34,119.75 89,117.41 83.18,117.41 82.98,117.21 79.5,117.21 79.44,117.27
M_A_DQ_27: length 31.3
  IN3 w0.06: v10(77.23,117.3) 77.44,117.3 77.53,117.21 77.64,117.1 77.81,117.1 77.9,117.19 79.22,117.19 79.32,117.08
  IN3 w0.076: v10(91.89,129.79) 92.14,130.04 94.06,130.04 95.33,128.76 95.33,127.03 95.55,126.81 95.55,122.29 92.79,119.52 91.36,119.52 89.08,117.24 83.28,117.24 83.1,117.06 79.34,117.06 79.32,117.08
M_A_DQ_28: length 28
  IN3 w0.06: 80.07,117.96 77.74,117.96 v10(77.73,117.94)
  IN3 w0.076: v10(91.39,129.29) 91.39,129.16 92.09,128.46 94.1,128.46 94.55,128.01 94.55,126.7 94.7,126.54 94.7,122.84 92.4,120.54 91.11,120.54 88.7,118.13 82.78,118.13 82.58,117.92 80.34,117.92 80.3,117.96 80.07,117.96
M_A_DQ_29: length 29.5
  IN3 w0.06: v10(77.23,117.94) 77.44,117.94 77.53,117.86 77.64,117.74 77.81,117.74 77.82,117.75 77.87,117.8 78.98,117.8 78.99,117.81 80.09,117.81
  IN3 w0.076: 80.09,117.81 80.18,117.81 80.24,117.74 82.65,117.74 82.87,117.96 88.81,117.96 91.19,120.34 92.5,120.34 94.87,122.7 94.87,126.6 94.7,126.76 94.7,128.07 94.11,128.66 92.18,128.66 91.65,129.19 91.65,129.51 91.39,129.77 v10(91.39,129.79)
M_A_DQ_30: length 32.9
  IN3 w0.06: v10(76.99,116.97) 77.22,116.75 80.67,116.75
  IN3 w0.076: v10(91.89,130.29) 92.15,130.55 94.33,130.55 95.64,129.23 95.64,127.16 95.91,126.88 95.91,122.04 93.01,119.14 91.49,119.14 89.28,116.93 83.46,116.93 83.28,116.75 80.67,116.75
M_A_DQ_31: length 31
  IN3 w0.06: 79.19,116.96 77.49,116.96 v10(77.48,116.97)
  IN3 w0.076: v10(92.39,130.29) 94.23,130.29 95.49,129.04 95.49,127.09 95.73,126.85 95.73,122.19 93,119.46 92.88,119.34 91.47,119.34 89.2,117.08 83.36,117.08 83.18,116.91 79.25,116.91 79.19,116.96
M_A_DQ_32: length 16.6
  IN3 w0.06: 80.19,126.71 78.81,125.34 78.81,124.37 77.41,122.97 77.41,122.68 v10(77.01,122.27)
  IN3 w0.076: v10(86.89,130.79) 86.89,130.95 86.65,131.19 86.65,131.36 86.5,131.52 85.42,131.52 85.34,131.44 85.34,131.28 85.42,131.21 85.65,131.21 85.75,131.11 85.75,130.7 85.64,130.59 84.22,130.59 83.77,130.13 83.77,129.81 83.77,129.8 83.77,129.25 83.46,128.95 82.83,128.95 82.35,128.47 81.94,128.47 80.19,126.71
M_A_DQ_33: length 15.5
  IN3 w0.06: 79.98,125.92 79.11,125.05 79.11,124.18 77.68,122.76 77.67,122.76 77.67,122.49 77.01,121.82 v10(77.01,121.78)
  IN3 w0.076: 79.98,125.92 82.17,128.11 82.45,128.11 82.93,128.59 83.64,128.59 84.28,129.23 85.02,129.23 85.17,129.38 85.17,129.71 85.24,129.78 85.39,129.78 85.47,129.71 85.47,129.31 85.55,129.23 85.75,129.23 85.83,129.31 85.83,129.68 85.9,129.76 86.05,129.76 86.13,129.68 86.13,129.31 86.21,129.23 86.39,129.23 86.46,129.31 86.46,129.72 v10(86.39,129.79)
M_A_DQ_34: length 18.1
  IN3 w0.06: v10(76.36,122.77) 76.44,122.85 76.44,123.14 78.08,124.78 78.08,125.8
  IN3 w0.076: v10(87.39,131.29) 87.39,131.49 86.76,132.13 84.92,132.13 84.72,131.93 84.72,131.19 84.66,131.13 84.48,131.13 84.4,131.21 84.4,131.92 84.33,131.99 84.18,131.99 84.1,131.92 84.1,131.74 84,131.64 83.37,131.64 81.79,130.06 81.79,129.71 78.08,126.01 78.08,125.8
M_A_DQ_35: length 18.7
  IN3 w0.06: v10(76.36,122.27) 76.44,122.35 76.44,122.56 76.56,122.68 76.56,123.04 78.22,124.7 78.22,125.86 79.24,126.89
  IN3 w0.076: 79.24,126.89 81.97,129.61 82.4,129.61 82.54,129.75 82.54,130.13 82.37,130.29 82.37,130.42 83.39,131.44 84.12,131.44 84.2,131.36 84.2,131.05 84.28,130.98 84.86,130.98 84.94,131.05 84.94,131.85 85.01,131.92 86.7,131.92 87.13,131.49 87.13,130.77 87.21,130.7 87.32,130.7 87.39,130.77 v10(87.39,130.79)
M_A_DQ_36: length 18.1
  IN3 w0.06: v10(76.36,121.78) 76.56,121.58 76.92,121.58 77.09,121.58 77.21,121.7 77.21,121.84 77.79,122.43 77.79,122.64 79.25,124.1 79.25,124.98 80.12,125.86 80.15,125.86
  IN3 w0.076: v10(86.89,129.79) 87.05,129.63 88.34,129.63 88.47,129.5 88.47,129.11 88.39,129.03 84.36,129.03 83.74,128.41 82.96,128.41 82.49,127.93 82.22,127.93 80.15,125.86
M_A_DQ_37: length 16.1
  IN3 w0.06: v10(77.01,122.77) 77.29,123.05 77.29,123.11 78.67,124.49 78.67,125.5 80.06,126.89
  IN3 w0.076: v10(86.89,131.29) 86.89,131.4 86.57,131.72 85.22,131.72 85.14,131.64 85.14,131.13 85.22,131.05 85.43,131.05 85.51,130.98 85.51,130.83 85.43,130.75 84.12,130.75 83.59,130.22 83.59,129.33 83.36,129.1 82.7,129.1 82.26,128.66 81.82,128.66 80.06,126.89
M_A_DQ_38: length 16.7
  IN3 w0.06: v10(76.04,122.03) 76.04,122.03 76.4,122.03 76.59,121.83 76.59,121.83 76.6,121.83 76.77,121.83 76.77,121.83 77.01,122.07 77.08,122.07 77.21,122.19 77.21,122.27 77.55,122.61 77.55,122.88 78.97,124.3 78.97,125.19 79.76,125.98
  IN3 w0.076: 79.76,125.98 82.07,128.29 82.4,128.29 82.88,128.77 83.54,128.77 84.17,129.4 84.84,129.4 84.91,129.48 84.91,129.66 84.84,129.73 84.61,129.73 84.53,129.81 84.53,129.96 84.61,130.03 86.42,130.03 86.51,130.12 86.51,130.5 86.59,130.57 86.82,130.57 86.89,130.5 86.89,130.29 v10(86.89,130.29)
M_A_DQ_39: length 20.2
  IN3 w0.06: v10(76.04,122.52) 76.12,122.6 76.12,122.8 76.16,122.84 76.16,122.85 76.28,122.97 76.29,122.97 76.32,123 76.32,123.21 76.55,123.44 76.55,123.44 76.71,123.61 76.71,123.64 77.93,124.86 77.93,125.64
  IN3 w0.076: v10(87.39,130.29) 87.39,130.45 87.65,130.71 87.65,131.47 87.25,131.87 87.25,131.99 87.32,132.07 87.4,132.07 87.48,132.15 87.48,132.25 87.4,132.33 84.01,132.33 83.92,132.23 83.92,131.87 83.85,131.79 83.3,131.79 81.46,129.95 81.46,129.66 81.31,129.51 81.2,129.51 81.17,129.55 81.06,129.55 80.95,129.44 80.95,129.33 80.99,129.3 80.99,129.19 80.88,129.08 80.77,129.08 80.74,129.12 80.63,129.12 80.52,129.01 80.52,128.9 80.56,128.87 80.56,128.76 80.45,128.65 80.34,128.65 80.31,128.69 80.2,128.69 80.09,128.58 80.09,128.47 80.13,128.44 80.13,128.33 80.02,128.22 79.91,128.22 79.87,128.26 79.77,128.26 79.66,128.15 79.66,128.04 79.69,128 79.69,127.9 77.93,126.13 77.93,125.64
M_A_DQ_40: length 23.3
  IN3 w0.06: 77.67,125.59 77.67,125.17 76.54,124.03 76.54,123.62 76.04,123.13 v6(76.04,123.02)
  IN3 w0.076: v10(89.89,129.79) 89.89,129.61 89.74,129.45 89.53,129.45 89.2,129.78 89.2,131.41 88.82,131.79 88.82,132.06 88.38,132.51 87.1,132.51 86.97,132.64 86.33,132.64 86.25,132.55 86.17,132.55 86.08,132.64 86,132.64 85.92,132.55 85.84,132.55 85.75,132.64 85.67,132.64 85.59,132.55 85.51,132.55 85.42,132.64 85.34,132.64 85.26,132.55 85.18,132.55 85.09,132.64 85.01,132.64 84.93,132.55 83.77,132.55 79.02,127.8 79.02,127.53 77.67,126.18 77.67,125.59
  IN4 w0.06: v6(76.04,123.02) 75.97,122.95 75.97,122.73 75.84,122.6 75.84,122.43 75.92,122.35 75.92,122.19 75.72,121.99 v4(75.72,121.78)
M_A_DQ_41: length 23.2
  IN3 w0.06: v10(75.72,122.27) 75.82,122.37 75.82,122.58 75.92,122.68 75.92,122.85 75.9,122.87 75.85,122.92 75.85,122.93 75.84,122.94 75.84,123.11 75.85,123.12 75.85,123.12 76.37,123.65 76.37,124.09 77.47,125.19 77.47,125.48
  IN3 w0.076: v10(90.39,129.79) 90.45,129.73 90.45,129.61 90.37,129.53 90.18,129.53 90.1,129.61 90.1,129.96 89.99,130.07 89.86,130.07 89.8,130.12 89.8,130.18 89.38,130.6 89.38,131.46 89.15,131.69 89.15,131.99 88.43,132.72 87.17,132.72 87.04,132.84 83.8,132.84 78.64,127.68 78.64,127.4 77.48,126.24 77.48,125.49 77.47,125.48
M_A_DQ_42: length 27.5
  IN3 w0.06: v10(75.07,121.78) UC1.BC49 75.07,121.99 74.87,122.19 74.87,122.36 74.88,122.36 74.88,122.37 74.95,122.44 74.95,122.6 74.86,122.7 74.86,122.98 74.75,123.09 74.75,123.46 75.26,123.97 75.26,124.81 76.25,125.8 76.25,126.15
  IN3 w0.076: 76.25,126.15 76.25,126.89 77.87,128.51 78.49,129.13 83.18,133.83 84.12,134.76 84.25,134.76 84.35,134.66 84.35,134.61 84.43,134.53 84.56,134.53 84.63,134.61 84.63,134.68 84.71,134.76 84.85,134.76 84.92,134.68 84.92,134.56 85,134.48 85.15,134.48 85.23,134.56 85.23,134.68 85.3,134.76 85.45,134.76 85.53,134.68 85.53,134.56 85.61,134.48 85.76,134.48 85.84,134.56 85.84,134.62 85.97,134.76 88.41,134.76 90.81,132.36 90.81,131.74 91.15,131.39 91.15,131.13 90.89,130.87 v10(90.89,130.79)
M_A_DQ_43: length 25.5
  IN3 w0.06: v10(75.07,122.27) 75.07,122.18 75.2,122.06 75.2,121.94 75.31,121.83 75.48,121.83 75.62,121.96 75.62,122.09 75.59,122.11 75.59,122.11 75.51,122.19 75.51,122.36 75.59,122.44 75.59,122.6 75.51,122.68 75.51,123.13 76.04,123.66 76.04,124.25 77.06,125.26 77.06,125.59
  IN3 w0.076: 77.06,125.59 77.06,126.33 78.23,127.5 78.23,127.78 78.49,128.04 82.45,132 83.7,133.25 87.23,133.25 87.35,133.13 88.55,133.13 89.84,131.85 89.84,130.89 90.17,130.56 91.21,130.56 91.29,130.48 91.29,130.37 91.21,130.29 v10(90.89,130.29)
M_A_DQ_44: length 22.9
  IN3 w0.06: 77.27,125.59 77.27,125.24 76.22,124.2 76.22,123.67 75.73,123.17 75.73,123.16 75.72,123.16 v10(75.72,122.77)
  IN3 w0.076: 77.27,125.59 77.27,126.28 78.47,127.49 78.47,127.74 82.11,131.38 82.45,131.72 83.77,133.04 87.14,133.04 87.28,132.91 88.51,132.91 89.32,132.1 89.32,131.83 89.39,131.76 89.48,131.76 89.56,131.68 89.56,130.75 90.27,130.04 90.58,130.04 90.65,130.11 90.65,130.27 90.58,130.34 90.44,130.34 v10(90.39,130.29)
M_A_DQ_45: length 25.1
  IN3 w0.06: 76.45,126.15 76.45,125.82 75.52,124.88 75.52,123.98 74.87,123.34 74.87,123.18 75.07,122.98 UC1.BG49 v10(75.07,122.77)
  IN3 w0.076: 76.45,126.15 76.45,126.82 78.15,128.51 78.49,128.85 83.18,133.55 83.94,134.31 85.98,134.31 86.22,134.55 86.43,134.55 86.57,134.41 86.74,134.41 86.88,134.55 87.03,134.55 87.11,134.47 87.11,134.33 87.19,134.25 87.34,134.25 87.42,134.33 87.42,134.47 87.49,134.55 87.64,134.55 87.72,134.47 87.72,134.33 87.8,134.25 87.95,134.25 88.03,134.33 88.03,134.47 88.1,134.55 88.34,134.55 90.6,132.29 90.6,131.58 v10(90.89,131.29)
M_A_DQ_46: length 26.7
  IN3 w0.06: 76.05,126.15 76.05,125.83 75.11,124.89 75.11,124.06 74.62,123.57 74.62,123 74.72,122.9 74.72,122.55 v10(74.75,122.52)
  IN3 w0.076: v10(91.39,131.29) 91.39,131.42 91.01,131.81 91.01,132.44 90.63,132.82 90.63,132.98 90.64,132.99 90.64,133.1 90.54,133.21 90.43,133.21 90.39,133.17 90.28,133.17 90.17,133.28 90.17,133.38 90.26,133.47 90.26,133.58 90.15,133.69 90.04,133.69 89.96,133.6 89.85,133.6 89.74,133.71 89.74,133.82 89.83,133.9 89.83,134.01 89.72,134.12 89.61,134.12 89.52,134.03 89.42,134.03 88.48,134.97 84.05,134.97 76.05,126.97 76.05,126.15
M_A_DQ_47: length 28.4
  IN3 w0.06: 75.85,126.38 75.85,125.83 74.98,124.97 74.98,124.17 74.48,123.67 74.48,122.79 74.55,122.72 74.55,122.4 74.75,122.2 74.75,122.03 v10(74.75,122.03)
  IN3 w0.076: v10(91.39,130.79) 91.39,130.73 91.47,130.66 91.57,130.66 91.65,130.73 91.65,131.41 91.21,131.85 91.21,132.91 89.63,134.49 89.52,134.49 89.43,134.41 89.33,134.41 89.22,134.52 89.22,134.63 89.3,134.71 89.3,134.82 88.95,135.17 83.99,135.17 83.06,134.23 78.49,129.67 75.85,127.02 75.85,126.38
M_A_DQ_48: length 12.3
  IN4 w0.06: 78.1,124.84 77.5,124.24 77.5,124.11 77.5,124.11 77.5,123.72 77.12,123.34 77.11,123.34 77.03,123.26 v5(77.01,123.26)
  IN4 w0.061: 78.1,124.84 78.1,124.87 78.49,125.26 78.77,125.26 78.92,125.11 78.92,124.98 78.97,124.93 79.81,124.93 79.88,125.01 80.41,125.01 81.29,125.9 82.04,125.9 83.4,127.26 83.4,128.13 84.86,129.58 85.18,129.58 v5(85.39,129.79)
M_A_DQ_49: length 12.2
  IN4 w0.06: 77.83,125.04 77.83,124.9 77.26,124.34 77.26,124.21 77.24,124.2 77.24,124.03 77.09,123.88 77.09,123.87 77.01,123.79 v5(77.01,123.75)
  IN4 w0.061: 77.83,125.04 78.4,125.61 79.1,125.61 79.15,125.57 79.15,125.36 79.2,125.31 80.21,125.31 81.1,126.2 81.86,126.2 83.08,127.42 83.08,128.26 84.87,130.05 84.98,130.05 85.13,130.19 85.3,130.19 v5(85.39,130.29)
M_A_DQ_50: length 13.6
  IN4 w0.06: 77.98,124.98 77.98,124.93 77.98,124.89 77.38,124.29 77.38,124.16 77.38,124.16 77.38,124 77.21,123.83 77.21,123.67 77,123.46 77,123.46 76.92,123.46 76.72,123.26 v5(76.36,123.26)
  IN4 w0.061: v5(85.89,130.29) 85.89,130.06 85.84,130.01 85.21,130.01 85,129.81 84.86,129.81 84.46,129.42 83.45,128.4 83.24,128.19 83.24,127.32 81.97,126.05 81.18,126.05 80.29,125.16 79.12,125.16 78.87,125.41 78.41,125.41 77.98,124.98
M_A_DQ_51: length 13.9
  IN4 w0.06: 77.1,124.87 76.91,124.68 76.8,124.68 76.56,124.45 76.56,124.16 76.36,123.96 v5(76.36,123.75)
  IN4 w0.061: 77.1,124.87 77.24,125.01 77.24,125.52 77.9,126.18 80.06,126.18 81.74,127.85 81.74,129.03 82.04,129.33 82.71,129.33 83.5,130.12 83.82,130.12 84.15,130.45 84.38,130.45 84.67,130.73 84.67,131.19 84.73,131.26 84.89,131.26 84.96,131.18 84.96,131.06 85.24,130.79 v5(85.39,130.79)
M_A_DQ_52: length 12.8
  IN4 w0.06: 81.67,126.36 81.04,126.36 ; 77.67,125.11 77.67,124.93 77.01,124.26 v5(77.01,124.24)
  IN4 w0.061: v5(85.89,130.79) 85.64,130.54 84.76,130.54 84.56,130.34 84.56,129.96 82.91,128.31 82.91,127.5 82.63,127.22 81.91,127.22 81.74,127.04 81.74,126.43 81.67,126.36 ; 77.67,125.11 77.96,125.41 78.3,125.74 80.36,125.74 80.98,126.36 81.04,126.36
M_A_DQ_53: length 14.6
  IN4 w0.06: 76.74,124.82 76.36,124.44 v5(76.36,124.24)
  IN4 w0.061: 76.74,124.82 76.75,124.83 76.75,125.1 77.01,125.36 77.01,125.49 77.85,126.33 79.98,126.33 81.58,127.93 81.58,129.13 81.97,129.51 82.63,129.51 83.41,130.29 83.76,130.29 84.08,130.61 84.15,130.61 84.29,130.61 84.51,130.84 84.51,131.39 84.64,131.52 85.03,131.52 85.15,131.4 85.15,131.21 85.31,131.04 85.51,131.04 85.59,131.12 85.59,131.33 85.67,131.41 85.8,131.41 85.89,131.32 v5(85.89,131.29)
M_A_DQ_54: length 17.2
  IN4 w0.06: 76.71,125.61 76.71,125.42 76.48,125.19 76.48,124.99 76.04,124.55 76.04,124.11 v5(76.04,124)
  IN4 w0.061: v5(85.89,129.79) 85.95,129.73 86.03,129.73 86.14,129.84 86.14,131.8 86.08,131.86 85.2,131.86 85.19,131.86 84.54,131.86 84.49,131.86 84.2,131.57 84.2,131.05 84.08,130.93 83.97,130.93 83.71,130.66 83.25,130.66 82.45,129.86 81.81,129.86 81.28,129.33 81.28,128.08 79.85,126.65 77.75,126.65 76.71,125.61
M_A_DQ_55: length 15.1
  IN4 w0.06: v5(76.04,123.5) 76.04,123.71 76.24,123.91 76.24,124.08 76.18,124.14 76.18,124.14 76.16,124.16 76.16,124.48 76.62,124.94 76.62,125.13 76.89,125.4 76.89,125.57
  IN4 w0.061: v5(85.39,131.29) 85.39,131.38 85.55,131.54 85.55,131.64 85.48,131.71 84.6,131.71 84.36,131.47 84.36,130.91 84.21,130.76 84.02,130.76 83.73,130.48 83.29,130.48 82.5,129.69 81.89,129.69 81.43,129.23 81.43,128.04 79.89,126.5 77.81,126.5 76.89,125.57
M_A_DQ_56: length 23
  IN4 w0.06: v5(75.72,123.75) 75.62,123.65 75.62,123.44 75.47,123.29 75.32,123.29 75.27,123.34 75.27,123.34 75.23,123.39 75.22,123.39 75.2,123.42 75.2,123.59 75.21,123.61 75.21,123.61 75.27,123.67 75.27,123.83 75.26,123.85 75.26,123.85 75.2,123.91 75.2,124.08 75.21,124.1 75.21,124.1 75.27,124.16 75.27,124.33 75.27,125.48 76.62,126.83 76.62,126.86
  IN4 w0.061: v5(89.39,131.29) 89.39,131.64 87.58,133.45 83.95,133.45 82.28,131.78 81.93,131.78 80.26,130.11 80.26,128.56 80,128.3 79.35,128.3 79.29,128.24 79.29,128.03 79.22,127.96 79.12,127.96 79.05,128.03 79.05,128.24 78.99,128.3 78.06,128.3 76.62,126.86
M_A_DQ_57: length 20.6
  IN4 w0.06: 75.92,125.29 75.92,124.16 75.84,124.08 75.84,123.91 75.92,123.83 75.92,123.76 75.92,123.67 75.84,123.59 75.84,123.58 75.82,123.57 75.82,123.36 v5(75.72,123.26)
  IN4 w0.061: v5(88.89,131.29) 88.89,131.14 88.8,131.04 88.53,131.04 87.67,131.9 87.61,131.9 87.49,132.02 87.28,132.02 86.59,132.71 84.25,132.71 83.15,131.61 83.15,131.53 83.25,131.43 83.25,131.33 83.18,131.25 83.08,131.25 82.98,131.35 82.9,131.35 82.81,131.27 82.81,131.18 82.85,131.14 82.85,131.05 82.77,130.97 82.68,130.97 82.64,131.01 82.55,131.01 82.52,130.98 82.24,130.98 80.92,129.66 80.92,128.23 79.71,127.02 77.65,127.02 75.92,125.29
M_A_DQ_58: length 23.1
  IN4 w0.06: 77.56,128.29 77.56,128.3 77.71,128.45 ; 76.2,126.93 76.2,126.81 74.98,125.6 74.98,125.26 75.02,125.22 75.02,124.47 74.87,124.33 74.87,124.16 74.95,124.08 74.95,124.08 75.07,123.96 v5(75.07,123.75)
  IN4 w0.061: v5(89.89,131.29) 89.89,131.7 87.78,133.82 83.81,133.82 83.18,133.19 82.13,132.14 81.75,132.14 79.93,130.32 79.93,128.96 79.88,128.9 78.82,128.9 78.76,128.84 78.76,128.7 78.69,128.64 78.57,128.64 78.51,128.7 78.51,128.89 78.44,128.97 78.31,128.97 78.23,128.89 78.23,128.68 78.19,128.64 77.9,128.64 77.71,128.45 ; 76.2,126.93 77.56,128.29
M_A_DQ_59: length 21
  IN3 w0.06: v6(76.36,125.37) 76.36,125.13 75.64,124.4 75.64,123.91 75.07,123.35 v10(75.07,123.26)
  IN4 w0.06: 76.36,125.5 v6(76.36,125.37)
  IN4 w0.061: 76.36,125.5 77.72,126.86 79.76,126.86 81.08,128.18 81.08,129.58 82.3,130.8 82.96,130.8 83.42,131.26 83.42,131.62 84.32,132.52 86.52,132.52 87.03,132.01 87.03,131.77 87.28,131.52 87.51,131.52 87.66,131.36 87.66,131.17 87.8,131.03 87.98,131.03 88.12,130.89 88.12,130.77 88.34,130.55 89.03,130.55 89.08,130.6 89.08,130.75 89.04,130.79 v5(88.89,130.79)
M_A_DQ_60: length 22.4
  IN4 w0.06: 76.38,126.93 76.38,126.8 75.13,125.56 75.13,125.34 75.14,125.33 75.14,124.31 v5(75.07,124.24)
  IN4 w0.061: 76.38,126.93 77.95,128.49 78.87,128.49 78.93,128.56 78.93,128.57 79.01,128.64 79.11,128.64 79.18,128.57 79.18,128.56 79.24,128.49 79.36,128.49 79.42,128.56 79.42,128.68 79.48,128.74 79.6,128.74 79.67,128.68 79.67,128.56 79.73,128.49 79.91,128.49 80.09,128.67 80.09,130.19 81.88,131.99 82.23,131.99 83.87,133.62 87.7,133.62 89.65,131.68 89.65,131.04 v5(89.89,130.79)
M_A_DQ_61: length 20.4
  IN4 w0.061: v5(75.72,124.24) 75.8,124.33 75.8,125.24 75.8,125.24 75.8,125.34 77.63,127.17 79.6,127.17 80.75,128.31 80.75,129.76 82.25,131.26 82.55,131.26 84.2,132.91 86.61,132.91 86.74,132.79 86.83,132.79 86.96,132.92 87.06,132.92 87.13,132.85 87.13,132.75 87,132.62 87,132.53 87.08,132.44 87.23,132.44 87.62,132.05 87.77,132.05 88.44,131.38 88.7,131.38 88.84,131.52 89.02,131.52 89.13,131.42 89.13,131.05 v5(89.39,130.79)
M_A_DQ_62: length 27.3
  IN4 w0.06: v5(74.75,123.5) 74.75,123.5 74.75,123.72 74.67,123.8 74.67,123.8 74.55,123.91 74.55,123.91 74.55,124.08 74.55,124.08 74.55,124.34 74.78,124.57 74.78,125.04 74.67,125.15 74.67,125.67 74.71,125.71 75.84,126.84
  IN4 w0.061: v5(89.39,129.79) 89.63,130.03 90.03,130.03 90.14,130.14 90.14,130.39 90.28,130.53 90.5,130.53 90.63,130.66 90.63,131.87 90.48,132.02 90.12,132.02 87.96,134.18 83.73,134.18 82.08,132.53 81.69,132.53 79.2,130.05 79.2,129.38 79.12,129.3 78.93,129.3 78.87,129.36 78.87,129.81 78.8,129.88 78.7,129.88 78.63,129.81 78.63,129.36 78.57,129.3 78.17,129.3 75.84,126.98 75.84,126.84
M_A_DQ_63: length 24.9
  IN4 w0.06: v5(74.75,124) 74.75,124.37 74.9,124.52 74.9,125.16 74.83,125.23 74.83,125.45 74.83,125.64 74.84,125.65 76.02,126.83 76.02,126.96 76.38,127.32
  IN4 w0.061: v5(89.39,130.29) 89.64,130.54 89.98,130.54 90.15,130.7 90.15,131.74 87.89,134 83.76,134 83.18,133.42 82.11,132.34 81.71,132.34 79.78,130.41 79.78,130.02 79.72,129.96 79.42,129.96 79.35,129.89 79.35,129.79 79.42,129.72 79.72,129.72 79.78,129.66 79.78,129.28 79.67,129.16 78.23,129.16 76.38,127.32
M_A_DQS_DN_0: length 28.5
  IN3 w0.091: v6(93.81,127.08) 93.79,127.09 92.8,127.09 92.31,127.58 91.81,127.58 91.52,127.3 91.24,127.3 91.09,127.45 91.09,127.65 90.94,127.79 v10(90.89,127.79)
  IN4 w0.06: 79.93,117.7 79.93,117.7 79.21,117.7 79.09,117.82 78.88,117.82 78.78,117.72 78.57,117.72 v5(78.47,117.62)
  IN4 w0.069: v6(93.81,127.08) 93.86,127.08 94.02,126.91 94.31,126.91 94.44,127.04 94.76,127.04 94.99,126.81 94.99,121.85 93.73,120.59 91.82,120.59 91.56,120.34 91.56,119.93 90.18,118.54 84.96,118.54 84.42,118 81.11,118 81,118 80.7,117.7 79.93,117.7
M_A_DQS_DN_1: length 19.8
  IN4 w0.06: 80.13,119.52 80.08,119.57 79.63,119.57 79.51,119.45 79.51,119.27 79.47,119.23 78.81,119.23 78.81,119.23 v5(78.71,119.23)
  IN4 w0.069: v5(91.89,125.29) 92.1,125.29 92.26,125.13 92.26,125.05 92.41,124.9 92.59,124.9 92.67,124.82 92.67,124.44 92.57,124.34 92.33,124.34 92.25,124.26 92.25,124.11 92.33,124.03 92.56,124.03 92.67,123.92 92.67,123.59 92.47,123.39 92.26,123.39 92.16,123.48 91.74,123.48 91.58,123.32 91.58,122.52 88.9,119.84 84.28,119.84 83.94,119.5 82.3,119.5 82.22,119.58 82.22,119.69 82.05,119.86 81.87,119.86 81.73,119.72 81.73,119.58 81.68,119.52 80.13,119.52
M_A_DQS_DN_2: length 25.2
  IN3 w0.06: v10(77.23,119.23) 77.44,119.23 77.53,119.15 77.64,119.03 77.81,119.03 77.85,119.07 79.65,119.07 79.65,119.08
  IN3 w0.091: v6(92.15,122.41) 92.04,122.53 91.9,122.53 91.69,122.74 91.58,122.74 91.48,122.63 91.48,122.48 91.59,122.37 91.59,122.13 91.43,121.96 90.8,121.96 88.14,119.29 82,119.29 81.79,119.08 79.65,119.08
  IN4 w0.069: v5(90.89,126.79) 91.06,126.79 91.31,127.04 92.48,127.04 92.68,126.84 92.68,126.72 92.81,126.59 92.99,126.59 93.3,126.29 93.3,126.29 93.59,126 93.59,125.23 93.27,124.91 93.27,122.93 93.27,122.93 93.27,122.73 92.94,122.39 92.61,122.39 92.43,122.57 92.31,122.57 92.16,122.41 v6(92.15,122.41)
M_A_DQS_DN_3: length 29.3
  IN3 w0.06: 77.92,117.64 77.91,117.64 77.9,117.63 77.86,117.63 77.85,117.62 77.48,117.62 v10(77.48,117.62)
  IN3 w0.091: 77.92,117.64 79.79,117.64 79.87,117.57 82.82,117.57 83.02,117.77 88.87,117.77 91.26,120.16 91.69,120.16 92.65,120.16 95.05,122.56 95.05,126.66 94.87,126.84 94.87,128.16 93.87,129.15 93.41,129.15 93.31,129.05 93.31,128.98 93.23,128.9 93.08,128.9 93,128.98 93,129.05 92.93,129.13 92.82,129.13 92.68,128.99 92.68,128.96 92.61,128.88 92.46,128.88 92.38,128.96 92.38,128.99 92.3,129.07 92.11,129.07 v10(91.89,129.29)
M_A_DQS_DN_4: length 21
  IN3 w0.06: 79.76,126.89 78.51,125.64 78.51,124.56 78.38,124.43 76.8,122.85 76.8,122.69 76.85,122.64 76.85,122.63 76.88,122.6 76.88,122.44 76.85,122.41 76.85,122.4 76.68,122.23 v10(76.68,122.03)
  IN3 w0.091: 79.76,126.89 81.77,128.89 82.13,128.89 82.3,129.06 82.3,129.23 82.35,129.28 83.22,129.28 83.41,129.46 83.41,129.72 83.24,129.89 82.93,129.89 82.85,129.96 82.85,130.29 82.93,130.37 83.03,130.37 83.12,130.28 83.39,130.28 83.54,130.43 83.54,130.85 v6(83.65,130.96)
  IN4 w0.069: v5(87.89,129.79) 88.12,130.02 88.12,130.4 87.98,130.54 87.29,130.54 87.29,130.54 87.27,130.56 87.15,130.68 87.15,131.36 86.8,131.71 86.8,131.89 86.42,132.27 84.39,132.27 83.96,131.83 83.7,131.57 83.7,131.24 83.74,131.19 83.74,131.06 v6(83.65,130.96)
