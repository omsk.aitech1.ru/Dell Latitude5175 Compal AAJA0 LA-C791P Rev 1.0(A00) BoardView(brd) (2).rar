# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3RN1_RP_C: length 1.8
  TOP w0.119: R236.2 38.2,58.08 38.37,58.25 38.37,58.87 38.25,58.99 U27.8
USB3RN2: length 218
  TOP w0.119: R6.1 203.69,141.82 ML1.1 204.32,141.82 204.59,141.55 204.76,141.55 204.76,141.55 v13(204.87,141.66)
  IN3 w0.06: 62.08,105.7 62.2,105.83 62.2,105.89 63.75,107.44 63.75,107.87 64.17,108.3 64.17,108.45 64.07,108.54 63.89,108.54 v3(63.79,108.45)
  IN3 w0.084: 62.08,105.7 62.08,104.64 62.08,104.31 61.76,103.99 61.43,103.99 61,103.56 61,103.25 60.85,103.09 60.85,102.96 60.85,102.96 60.85,99.38 62.06,98.18 62.19,98.18 65.39,98.18 67.97,95.6 77.82,95.6 79.54,97.33 81.11,97.33 82.19,98.41 93.61,98.41 94.01,98.8 101.86,98.8 103.5,97.16 113.73,97.16 114,96.89 114.43,96.89 115.2,97.67 129.5,97.67 130.54,96.63 132.19,96.63 134.58,94.24 174.31,94.24 176.35,96.27 196.82,96.27 198.63,98.08 205.47,98.08 213.75,106.37 213.75,112.54 212.78,113.52 211.2,113.52 208.9,115.82 208.9,127.33 209.49,127.92 209.49,129.55 207.72,131.32 207.72,133.75 207.97,134 207.97,134.08 207.97,137.54 205.45,140.06 205.45,141.23 205.21,141.47 205.06,141.47 v13(204.87,141.66)
  IN4 w0.06: v3(63.79,108.45) 64.06,108.72 64.06,108.82 64.06,108.82 64.06,109.55 64.06,109.55 64.06,109.64 v5(64.12,109.71)
USB3RN2_CON: length 3.6
  TOP w0.119: v13(201.31,141.71) 201.53,141.49 201.73,141.49 202.05,141.82 ML1.2 202.38,141.93 R6.2
  BOTTOM w0.119: JNGFF1.21 202.26,141.21 202.14,141.09 202.09,141.09 201.66,141.53 201.49,141.53 v13(201.31,141.71)
USB3RN3: length 80.2
  IN3 w0.06: 61.46,105.72 61.47,105.73 61.5,105.73 62.43,106.66 62.43,107.21 62.64,107.42 62.81,107.42 62.82,107.42 62.91,107.42 63.06,107.28 v3(63.22,107.28)
  IN3 w0.084: v7(121.53,95.93) 121.64,96.04 121.64,96.16 121.56,96.24 113.78,96.24 113.41,96.61 103.24,96.61 101.99,97.86 82.45,97.86 81.33,96.74 79.77,96.74 78.06,95.03 67.73,95.03 65.1,97.65 61.85,97.65 60.29,99.21 60.29,99.35 60.29,99.35 60.29,103.41 60.39,103.51 60.39,104.65 60.44,104.7 61.26,105.52 61.46,105.72
  IN4 w0.06: v3(63.22,107.28) 63.22,107.17 63.47,106.92 63.63,106.92 64.04,107.34 64.04,107.81 65.01,108.78 65.01,109.02 64.89,109.13 64.89,109.52 65.09,109.73 v5(65.09,109.95)
  BOTTOM w0.119: JIO4.98 121.52,95.64 121.61,95.74 121.61,95.84 v7(121.53,95.93)
USB3RN4: length 68.4
  TOP w0.119: R96.1 96.95,127 v1(96.56,127)
  IN1 w0.109: v2(96.37,127.37) 96.56,127.18 v1(96.56,127)
  IN2 w0.079: v2(64.9,108.73) 64.9,108.83 65.04,108.97 65.28,108.97 65.71,109.4 65.71,110.86 64.08,112.49 59.41,112.49 57.87,114.03 57.87,115.14 55.99,117.02 55.99,117.63 56.34,117.98 56.34,118.57 55.91,119 55.91,120.4 57.65,122.14 58.59,122.14 58.95,121.78 60.21,121.78 60.52,122.09 60.52,122.54 61.8,123.81 64.64,123.81 66.12,125.29 77.6,125.29 80.08,127.77 82.79,127.77 84.02,126.54 91.1,126.54 91.69,127.13 94.36,127.13 95.52,128.29 96.3,128.29 96.6,128 96.6,127.57 96.47,127.45 96.43,127.45 96.39,127.41 96.39,127.4 v2(96.37,127.37)
  IN3 w0.06: v2(64.9,108.73) 64.74,108.88 64.64,108.88 64.54,108.78 v3(64.54,108.73)
  IN4 w0.06: v5(64.77,109.71) 64.77,109.7 64.77,109.03 64.84,108.96 64.84,108.8 64.69,108.65 64.62,108.65 v3(64.54,108.73)
USB3RN4_CON: length 14.7
  TOP w0.119: v13(102.15,127.4) 102.34,127.4 102.39,127.45 102.39,127.65 102.21,127.83 101.4,127.83 101.06,127.49 MD1.1 100.58,127.49 100.44,127.63 100.33,127.63 100.19,127.49 MD1.9 99.62,127.49 99.53,127.57 99.49,127.62 99.38,127.62 99.13,127.36 98.9,127.36 98.53,127 ML4.2 98.23,126.96 R96.2
  IN3 w0.084: v13(102.15,127.4) 102.3,127.4 102.39,127.48 102.39,127.66 102.25,127.8 102.03,127.8 101.46,128.37 101.46,128.51 101.46,130.48 101.84,130.87 101.84,133.48 101.5,133.82 101.22,133.82 101.05,133.66 101.05,133.58 v7(101.12,133.52)
  BOTTOM w0.119: JCAM3.2 101.4,133.58 101.29,133.68 101.19,133.68 101.12,133.61 v7(101.12,133.52)
USB3RN5: length 116.4
  IN2 w0.079: v2(65.25,99.94) 65.07,100.12 65.01,100.12 64.85,99.96 64.3,99.96 63.97,100.28 63.36,100.28 62.57,101.07 60.72,101.07 60.32,100.67 55.65,100.67 54.41,101.91 51.36,101.91 51.1,102.17 48.95,102.17 47.86,103.26 47.64,103.26 47.39,103.51 47,103.51 46.68,103.83 39.87,103.83 35.48,99.44 33.99,99.44 18.12,83.58 18.12,43.39 17.9,43.16 17.9,39.99 18.22,39.68 18.79,39.68 18.94,39.83 18.94,39.97 v2(18.79,40.13)
  IN3 w0.084: v2(65.25,99.94) 65.39,100.08 65.57,100.08 65.71,99.95 v3(65.71,99.91) ; v7(18.68,40.51) 18.85,40.51 18.93,40.44 18.93,40.26 18.8,40.13 v2(18.79,40.13)
  IN4 w0.06: v5(65.73,109.95) 65.99,109.69 65.99,109.22 65.86,109.09 65.86,108.5 64.84,107.48 64.84,106.42 64.75,106.33 64.75,105.83
  IN4 w0.089: 64.75,105.83 64.75,105.38 65.01,105.13 65.22,105.13 65.54,104.81 65.54,103.01 65.12,102.59 65.12,101.42 66.01,100.53 66.01,100.24 65.71,99.93 v3(65.71,99.91)
  BOTTOM w0.119: R475.1 18.57,40.41 v7(18.68,40.51)
USB3RN5_CON: length 14.6
  IN3 w0.084: v7(18.36,33.45) 18.28,33.53 17.95,33.53 16.04,31.63 15.31,31.63 14.43,30.75 13.27,30.75 13.08,30.56 JUSB1.5
  BOTTOM w0.119: R475.2 18.57,38.92 ML12.3 18.68,38.31 18.94,38.05 18.94,37.57 18.81,37.44 MD2.1 18.81,35.69 18.88,35.61 18.88,35.12 18.68,34.91 18.23,34.91 17.7,34.38 17.7,33.79 18.02,33.47 18.34,33.47 v7(18.36,33.45)
USB3RP1: length 87.4
  IN1 w0.109: v1(38.76,65.97) 38.64,65.97 38.51,66.1 38.51,66.18 38.73,66.41 v2(38.73,66.41)
  IN2 w0.079: v2(52.5,96.38) 52.7,96.58 52.7,96.69 52.44,96.94 52.25,96.94 51.97,96.66 49.38,96.66 49.1,96.94 47.66,96.94 47.19,96.47 42.79,96.47 42.53,96.73 41.45,96.73 40.94,96.22 40.3,96.22 37.33,93.25 36.83,93.25 29.32,85.74 29.32,85.27 24.1,80.05 24.1,70.12 24.89,69.33 27.01,69.33 28.41,67.93 28.88,67.46 38.07,67.46 38.56,66.96 38.56,66.58 v2(38.73,66.41)
  IN3 w0.084: v3(58.8,97.47) 58.95,97.32 58.95,97.19 58.77,97 58.11,97 57.91,97.2 52.96,97.2 52.64,96.88 52.64,96.53 v2(52.5,96.38)
  IN4 w0.06: v5(64.44,109.43) 64.33,109.43 64.3,109.4 64.3,108.37 63.89,107.97 63.22,107.97 62.39,107.14 62.39,104.06 62.5,103.95 62.5,103.74 62.6,103.65
  IN4 w0.089: v3(58.8,97.47) 58.8,97.46 59.07,97.19 59.99,97.19 60.59,97.79 60.59,98.48 62.01,99.9 62.01,100.96 62.6,101.55 62.6,103.65
USB3RP1_C: length 1.9
  TOP w0.119: U27.22 38.75,64.16 38.63,64.28 38.63,64.96 38.76,65.09 C193.1
USB3RP1_RP: length 33.9
  TOP w0.119: v1(21.63,38.61) 21.63,38.61 U31.28
  IN1 w0.109: v1(38.77,57.19) 38.77,57.78 38.51,58.05 37.64,58.05 36.19,56.6 34.83,56.6 31.53,53.3 31.53,51.58 28.43,48.47 28.43,44.7 27.42,43.69 21.58,43.69 20.7,42.81 20.7,41.17 20.79,41.08 20.79,39.21 21.23,38.77 21.46,38.77 v1(21.63,38.61)
USB3RP1_RP_C: length 1.8
  TOP w0.119: U27.9 38.75,58.99 38.63,58.87 38.63,58.21 38.77,58.07 R237.2
USB3RP2: length 218
  TOP w0.119: v13(204.87,141.07) 204.87,141.16 204.74,141.29 204.6,141.29 204.32,141.02 ML1.4 203.69,141.02 R8.1
  IN3 w0.06: 62.32,105.72 62.32,105.84 63.86,107.39 63.86,107.82 64.29,108.25 64.29,108.5 64.12,108.66 63.83,108.66 63.75,108.74 v3(63.75,108.83)
  IN3 w0.084: v13(204.87,141.07) 204.87,141.18 204.99,141.3 205.14,141.3 205.28,141.16 205.28,139.99 207.81,137.47 207.81,134.15 207.81,134.06 207.56,133.82 207.56,131.25 209.33,129.48 209.33,127.99 208.74,127.4 208.74,115.75 211.13,113.35 212.71,113.35 213.59,112.47 213.59,106.43 205.4,98.24 198.56,98.24 196.76,96.44 176.28,96.44 174.25,94.4 134.65,94.4 132.26,96.79 130.61,96.79 129.57,97.83 115.14,97.83 114.36,97.05 114.07,97.05 113.8,97.32 103.57,97.32 101.93,98.96 93.94,98.96 93.55,98.57 82.12,98.57 81.04,97.49 79.47,97.49 77.75,95.76 68.03,95.76 65.46,98.34 62.12,98.34 61.01,99.45 61.01,103.03 61.16,103.18 61.16,103.49 61.49,103.83 61.82,103.83 62.24,104.24 62.24,104.71 62.24,105.64 62.32,105.72
  IN4 w0.06: v3(63.75,108.83) 63.8,108.78 63.87,108.78 63.94,108.85 63.94,109.55 63.92,109.56 63.92,109.62 63.92,109.62 63.92,109.79 63.92,109.79 64.2,110.06 64.2,110.12 v5(64.12,110.2)
USB3RP2_CON: length 3.5
  TOP w0.119: v13(201.3,141.13) 201.4,141.23 201.73,141.23 201.94,141.02 ML1.3 202.38,140.91 R8.2
  BOTTOM w0.119: JNGFF1.23 202.3,140.71 202.18,140.83 201.98,140.83 201.55,141.26 201.44,141.26 v13(201.3,141.13)
USB3RP3: length 80.2
  IN3 w0.06: v3(62.84,106.97) 62.92,106.97 62.99,107.05 62.99,107.18 62.86,107.3 62.69,107.3 62.55,107.17 62.55,106.61 61.58,105.64 61.58,105.61 61.57,105.6
  IN3 w0.084: v7(121.92,95.93) 121.8,96.04 121.8,96.23 121.62,96.41 113.85,96.41 113.48,96.77 103.31,96.77 102.06,98.02 82.38,98.02 81.27,96.9 79.7,96.9 77.99,95.19 67.79,95.19 65.17,97.82 61.92,97.82 60.45,99.28 60.45,103.34 60.55,103.44 60.55,104.58 61.37,105.4 61.57,105.6
  IN4 w0.06: v3(62.84,106.97) 62.84,107.15 62.9,107.22 62.98,107.22 63.13,107.06 63.16,107.06 63.42,106.8 63.68,106.8 64.16,107.29 64.16,107.76 65.13,108.73 65.13,109.06 65.01,109.18 65.01,109.35 v5(65.09,109.43)
  BOTTOM w0.119: v7(121.92,95.93) 121.88,95.88 121.88,95.74 121.92,95.69 JIO4.96
USB3RP4: length 68.5
  TOP w0.119: v1(96.56,127.8) 96.95,127.8 R86.1
  IN1 w0.109: v2(96.9,127.37) 96.9,127.45 v1(96.56,127.8)
  IN2 w0.079: v2(96.9,127.37) 96.93,127.4 96.93,127.45 96.78,127.59 96.78,127.92 96.78,127.92 96.78,128.07 96.38,128.48 96.23,128.48 95.44,128.48 94.29,127.32 91.62,127.32 91.02,126.72 84.1,126.72 82.86,127.96 80,127.96 77.53,125.48 66.04,125.48 64.56,124 61.72,124 60.33,122.61 60.33,122.17 60.13,121.97 59.03,121.97 58.67,122.33 57.57,122.33 55.73,120.48 55.73,118.92 56.15,118.5 56.15,118.06 55.8,117.71 55.8,116.94 57.68,115.07 57.68,113.95 59.33,112.31 64,112.31 65.52,110.78 65.52,109.48 65.2,109.16 64.95,109.16 v2(64.85,109.26)
  IN3 w0.06: v3(64.54,109.08) 64.67,109.08 v2(64.85,109.26)
  IN4 w0.06: v5(64.77,110.2) 64.77,109.99 64.57,109.79 64.57,109.62 64.65,109.54 64.65,109.19 v3(64.54,109.08)
USB3RP4_CON: length 14.7
  TOP w0.119: R86.2 98.23,127.83 ML4.3 98.48,127.8 98.65,127.62 99.02,127.62 99.27,127.88 99.56,127.88 99.66,127.99 MD1.8 100.22,127.99 100.32,127.89 100.49,127.89 100.59,127.99 MD1.2 101.19,127.99 101.29,128.09 102.33,128.09 102.7,127.71 102.7,127.52 v13(102.83,127.4)
  IN3 w0.084: v13(102.83,127.4) 102.64,127.59 102.64,127.78 102.46,127.96 102.1,127.96 101.63,128.44 101.63,130.42 102.01,130.8 102.01,130.93 102.01,133.54 101.56,133.99 101.43,133.99 101.43,133.99 101.21,133.99 v7(101.12,134.08)
  BOTTOM w0.119: v7(101.12,134.08) 101.22,133.98 JCAM3.3
USB3RP5: length 116.4
  IN2 w0.079: v2(19.35,40.11) 19.23,40.11 19.13,40 19.13,39.75 18.87,39.49 18.14,39.49 17.72,39.92 17.72,43.24 17.94,43.46 17.94,83.65 33.91,99.63 35.41,99.63 39.79,104.01 46.76,104.01 47.08,103.69 47.46,103.69 47.71,103.44 47.94,103.44 49.03,102.35 51.18,102.35 51.44,102.1 54.49,102.1 55.73,100.86 60.25,100.86 60.65,101.26 62.65,101.26 63.44,100.47 64.05,100.47 64.37,100.14 64.77,100.14 64.93,100.3 65.08,100.3 65.25,100.47 v2(65.25,100.47)
  IN3 w0.084: v2(19.35,40.11) 19.29,40.11 19.1,40.29 19.1,40.44 19.18,40.51 v7(19.48,40.51) ; v3(65.71,100.45) 65.71,100.35 65.61,100.25 65.44,100.25 65.25,100.44 v2(65.25,100.47)
  IN4 w0.06: v5(65.73,109.43) 65.78,109.43 65.87,109.34 65.87,109.27 65.74,109.14 65.74,108.55 64.72,107.53 64.72,106.47 64.63,106.38 64.63,105.9 64.62,105.89 64.62,105.85 64.6,105.84 64.6,105.83
  IN4 w0.089: 64.6,105.83 64.6,105.32 64.95,104.98 65.16,104.98 65.33,104.81 65.33,103.1 64.9,102.68 64.9,101.33 65.63,100.6 65.63,100.58 65.71,100.51 v3(65.71,100.45)
  BOTTOM w0.119: v7(19.48,40.51) 19.46,40.5 R474.1
USB3RP5_CON: length 14.4
  IN3 w0.084: JUSB1.6 13.08,30.96 13.13,30.91 14.36,30.91 15.24,31.79 15.97,31.79 17.88,33.7 18.22,33.7 v7(18.36,33.83)
  BOTTOM w0.119: R474.2 19.46,38.83 ML12.2 19.48,38.24 19.2,37.97 19.2,37.66 19.46,37.4 MD2.2 19.46,35.77 19.15,35.45 19.15,35.01 18.79,34.65 18.34,34.65 17.96,34.27 17.96,33.9 18.13,33.73 18.26,33.73 v7(18.36,33.83)
USB3TN1: length 96.4
  IN1 w0.109: v1(39.73,65.97) 39.89,65.97 39.99,65.87 39.99,65.8 39.7,65.5 v2(39.7,65.5)
  IN2 w0.079: v2(60.65,95.99) 60.79,96.13 60.79,96.27 60.7,96.37 60.15,96.37 60.08,96.44 53.79,96.44 52.72,97.51 51.98,97.51 51.71,97.25 49.62,97.25 49.35,97.51 47.42,97.51 46.95,97.04 43.04,97.04 42.79,97.3 41.16,97.3 40.68,96.82 40.01,96.82 37.05,93.86 36.62,93.86 28.67,85.91 28.67,85.43 23.54,80.29 23.54,69.62 24.57,68.59 26.79,68.59 28.61,66.77 37.04,66.77 37.44,66.37 37.44,65.73 38.25,64.92 39.64,64.92 39.91,65.19 39.91,65.37 39.79,65.5 v2(39.7,65.5)
  IN3 w0.06: 60.78,108.9 60.78,108.91 60.97,109.1 60.97,109.1 61.14,109.27 61.14,109.27 61.19,109.32 63.2,109.32 64.44,110.56 v10(64.44,110.94)
  IN3 w0.084: 60.78,108.9 60.78,107.71 59.69,106.62 59.69,106.08 58.85,105.25 58.85,103.7 59.41,103.14 59.41,98.85 61.24,97.02 61.24,96.79 61.05,96.6 61.05,96.59 60.85,96.39 60.74,96.39 60.61,96.26 60.61,96.03 v2(60.65,95.99)
USB3TN1_C: length 1.9
  TOP w0.119: U27.20 39.75,64.16 39.87,64.28 39.87,64.94 39.73,65.08 C194.2
USB3TN1_RP: length 27.4
  IN1 w0.109: v1(39.73,57.2) 39.95,57.2 40,57.15 40,57.01 38.67,55.67 36.6,55.67 32.81,51.89 32.44,51.52 32.27,51.35 32.22,51.35 29.08,48.21 29.08,44.39 27.71,43.03 26.44,43.03 23.25,39.84 22.72,39.84 v1(22.46,40.11)
USB3TN1_RP_C: length 1.8
  TOP w0.119: U27.11 39.75,58.87 39.87,58.75 39.87,58.28 39.73,58.13 C196.1
USB3TN2: length 224.5
  TOP w0.119: v13(205.88,140.91) 205.61,140.91 205.49,140.79 205.49,140.66 205.65,140.49 206.08,140.49 206.19,140.38 206.19,139.62 206.09,139.52 205.95,139.52 C14.1
  IN3 w0.06: v10(64.12,110.69) 64.12,110.94 64.07,110.99 64.01,110.99 62.73,109.71 60.99,109.71 60.27,108.99 60.27,108.76 59.87,108.35 59.87,108.18 59.71,108.02 59.71,107.62 59.73,107.59 59.73,107.48 59.69,107.43
  IN3 w0.084: v13(205.88,140.91) 205.88,140.86 205.93,140.81 206.06,140.81 206.11,140.76 206.11,140.21 208.39,137.93 208.39,133.8 208.21,133.62 208.21,131.48 209.88,129.81 209.88,127.66 209.35,127.13 209.35,116.12 210.96,114.51 212.35,114.51 214.19,112.68 214.19,106.2 205.59,97.6 198.7,97.6 196.98,95.88 176.51,95.88 174.43,93.8 133.17,93.8 133.16,93.79 125.26,93.79 124.62,94.43 119.18,94.43 118.36,95.25 112.94,95.25 112.52,95.67 102.81,95.67 101.64,96.84 83.18,96.84 81.08,94.73 79.22,94.73 78.56,94.07 62.56,94.07 61.99,94.64 61.3,94.64 60.74,95.21 60.39,95.21 59.77,95.83 59.77,95.86 59.77,97.7 58.84,98.63 58.84,102.61 58.84,102.61 58.84,102.74 58.35,103.23 58.35,105.36 59.19,106.2 59.19,106.94 59.69,107.43
USB3TN2_CON: length 3
  TOP w0.119: v13(201.45,139.78) 201.66,139.56 201.78,139.56 202.05,139.84 ML2.2 202.61,139.84 R11.2
  BOTTOM w0.119: JNGFF1.27 202.03,139.71 201.91,139.59 201.64,139.59 v13(201.45,139.78)
USB3TN2_R: length 1.8
  TOP w0.119: C14.2 205.04,139.54 204.5,139.54 204.2,139.84 ML2.1 203.59,139.84 R11.1
USB3TN3: length 84.9
  IN3 w0.06: 63.22,108.34 63.22,108.73 63.77,109.27 64.28,109.27 64.52,109.52 64.68,109.52 64.84,109.69 65.02,109.69 65.29,109.96 65.29,110.14 65.29,110.14 65.29,110.24 65.09,110.44 65.09,110.65 65.13,110.68 65.38,110.68 65.46,110.76 65.46,111.18 65.38,111.25 65.19,111.25 65.09,111.15 v10(65.09,110.94)
  IN3 w0.084: 63.22,108.34 62.15,107.26 61.12,107.26 60.12,106.26 60.12,104.5 59.92,104.3 59.92,99.05 62.1,96.87 62.1,96.18 62.38,95.9 62.38,95.19 62.94,94.63 78.29,94.63 80.01,96.34 81.51,96.34 82.56,97.4 101.88,97.4 103.06,96.22 112.92,96.22 113.31,95.84 121.08,95.84 121.3,95.62 122.7,95.62 122.82,95.74 122.82,95.79 v7(122.71,95.9)
  BOTTOM w0.119: v7(122.71,95.9) 122.72,95.9 122.76,95.86 122.76,95.6 122.72,95.56 JIO4.92
USB3TN4: length 60.1
  IN1 w0.109: v1(90.79,127.6) 90.79,127.61 91.25,128.07 v2(91.25,128.2)
  IN2 w0.079: v2(64.82,110.1) 64.49,110.1 64.26,110.33 64.26,110.72 63.44,111.54 61.5,111.54 61.17,111.87 58.88,111.87 57.45,113.3 57.45,114.73 55.25,116.94 55.25,120.58 57.41,122.75 59.87,122.75 61.5,124.38 64.41,124.38 66.05,126.02 77.49,126.02 79.84,128.38 82.99,128.38 84.26,127.11 90.83,127.11 91.03,127.31 91.03,127.89 90.97,127.95 90.97,128.09 91.07,128.2 v2(91.25,128.2)
  IN3 w0.06: v2(64.82,110.1) 64.82,110.02 64.69,109.89 64.61,109.89 64.39,110.1 64.39,110.15 64.69,110.45 64.69,110.61 v10(64.77,110.69)
USB3TN4_C: length 1.9
  TOP w0.119: C84.2 91.66,127.6 91.91,127.35 92.01,127.35 92.39,126.97 ML5.1 92.93,126.97 R97.1
USB3TN4_CON: length 19.1
  TOP w0.119: R97.2 93.9,126.97 ML5.2 94.62,126.97 94.85,127.2 95.12,127.2 95.36,127.44 95.36,127.85 96.66,129.15 99.33,129.15 99.49,128.99 MD1.7 100.23,128.99 100.34,129.1 100.51,129.1 100.62,128.99 MD1.4 101.16,128.99 101.29,129.12 101.59,129.12 101.92,129.45 102.17,129.45 102.36,129.25 102.36,129.06 102.26,128.96 v13(102.03,128.96)
  IN3 w0.084: v7(101.1,134.74) 101.1,134.79 101.27,134.96 101.74,134.96 102.63,134.06 102.63,130.27 102.46,130.1 102.46,129.22 102.37,129.13 102.37,129.06 102.28,128.96 v13(102.03,128.96)
  BOTTOM w0.119: JCAM3.5 101.39,134.78 101.3,134.87 101.17,134.87 101.1,134.8 v7(101.1,134.74)
USB3TN5: length 110.7
  IN2 w0.079: v2(19.63,42.53) 19.63,42.48 19.93,42.19 20.06,42.19 20.21,42.33 20.21,42.86 18.52,44.56 18.52,82.26 22.7,86.44 22.7,87.59 34.11,98.99 35.58,98.99 39.71,103.12 47.22,103.12 48.6,101.75 50.9,101.75 51.14,101.51 54.27,101.51 55.52,100.27 61.74,100.27 61.87,100.4 61.87,100.63 v2(61.82,100.68)
  IN3 w0.06: 62.91,105.83 62.93,105.85 62.96,105.85 63.34,106.23 63.34,106.48 64.45,107.58 64.45,107.86 65.29,108.7 65.29,109.55 65.48,109.75 65.48,110.22 66.07,110.81 66.07,111.12 65.99,111.2 65.79,111.2 65.73,111.14 v10(65.73,110.94)
  IN3 w0.084: v2(61.82,100.68) 62.01,100.86 62.01,101.28 62.43,101.7 62.43,103.26 62.48,103.3 62.48,104.8 62.47,105.39 62.64,105.56 62.64,105.58 62.82,105.77 62.85,105.77 62.91,105.83 ; v7(20.47,42.4) 20.56,42.48 20.64,42.48 20.79,42.33 20.79,42.08 20.61,41.9 20.35,41.9 20.04,42.21 19.86,42.21 19.83,42.25 19.78,42.25 19.63,42.4 v2(19.63,42.53)
USB3TN5_C: length 1.9
  BOTTOM w0.119: C347.2 20.66,41.63 20.66,41.09 20.45,40.89 ML11.4 20.42,40.48 R473.1
USB3TN5_CON: length 12.3
  IN3 w0.084: JUSB1.8 13.08,37.53 13.23,37.68 14.33,37.68 14.68,37.33 20.09,37.33 20.33,37.08 20.33,36.78 v7(20.11,36.56)
  BOTTOM w0.119: R473.2 20.45,39.18 ML11.3 20.45,38.31 20.7,38.06 20.7,37.98 20.29,37.56 20.29,37.4 20.11,37.22 v7(20.11,36.56)
USB3TP1: length 96.4
  IN1 w0.109: v2(40.23,65.52) 40.23,65.92 v1(40.28,65.97)
  IN2 w0.079: v2(40.23,65.52) 40.09,65.38 40.09,65.11 39.72,64.73 39.56,64.73 38.17,64.73 37.25,65.66 37.25,66.29 36.96,66.58 28.53,66.58 26.71,68.4 24.49,68.4 23.35,69.54 23.35,80.37 28.49,85.51 28.49,85.99 36.54,94.05 36.97,94.05 39.93,97 40.6,97 41.08,97.48 42.86,97.48 43.12,97.23 46.87,97.23 47.34,97.7 49.43,97.7 49.69,97.43 51.64,97.43 51.9,97.7 52.79,97.7 53.87,96.62 60.16,96.62 60.23,96.55 60.52,96.55 v2(60.7,96.73)
  IN3 w0.06: v10(64.44,111.43) 64.44,111.22 64.24,111.02 64.24,110.85 64.32,110.77 64.32,110.61 63.15,109.44 61.14,109.44 61.09,109.39 61.09,109.39 60.85,109.15 60.85,109.15 60.65,108.95 60.65,108.92 60.64,108.9 60.64,108.9
  IN3 w0.084: v2(60.7,96.73) 60.94,96.73 61.08,96.87 61.08,96.95 59.25,98.78 59.25,99.02 59.25,103.07 58.69,103.63 58.69,103.77 58.69,105.31 59.52,106.15 59.52,106.68 60.64,107.8 60.64,108.9
USB3TP1_C: length 1.9
  TOP w0.119: C195.2 40.28,65.04 40.13,64.89 40.13,64.28 40.25,64.16 U27.19
USB3TP1_RP: length 27.5
  IN1 w0.109: v1(22.46,39.61) 23.35,39.61 26.54,42.8 27.81,42.8 29.31,44.3 29.31,48.11 32.32,51.12 32.37,51.12 32.61,51.35 32.79,51.54 33.05,51.79 33.05,51.79 36.7,55.44 38.76,55.44 40.24,56.92 40.24,57.16 v1(40.28,57.2)
USB3TP1_RP_C: length 1.8
  TOP w0.119: U27.12 40.25,58.87 40.13,58.75 40.13,58.31 40.28,58.16 C197.1
USB3TP2: length 224.6
  TOP w0.119: C18.1 205.78,139.13 205.91,139.26 206.2,139.26 206.45,139.51 206.45,140.49 206.36,140.58 206.36,140.81 v13(206.46,140.91)
  IN3 w0.06: v10(64.12,111.18) 64.05,111.11 63.96,111.11 62.68,109.83 60.95,109.83 60.15,109.04 60.15,108.81 59.75,108.4 59.75,108.23 59.59,108.07 59.59,107.53
  IN3 w0.084: 59.59,107.53 59.03,106.98 59.03,106.26 58.19,105.43 58.19,103.16 58.68,102.67 58.68,98.69 58.68,98.56 59.61,97.63 59.61,95.79 59.61,95.76 60.33,95.04 60.67,95.04 61.24,94.48 61.92,94.48 62.49,93.91 78.63,93.91 79.29,94.57 81.14,94.57 83.25,96.68 101.57,96.68 102.74,95.51 112.45,95.51 112.87,95.09 118.29,95.09 119.11,94.26 124.56,94.26 125.19,93.63 133.23,93.63 133.24,93.64 174.5,93.64 176.58,95.72 197.05,95.72 198.77,97.44 205.66,97.44 214.35,106.13 214.35,112.74 212.42,114.67 211.02,114.67 209.51,116.18 209.51,127.06 210.04,127.6 210.04,129.88 208.37,131.54 208.37,133.56 208.55,133.73 208.55,138 206.27,140.28 206.27,140.73 206.45,140.91 v13(206.46,140.91)
USB3TP2_CON: length 3
  TOP w0.119: R13.2 202.58,139.04 ML2.3 202.04,139.04 201.78,139.3 201.59,139.3 v13(201.45,139.16)
  BOTTOM w0.119: JNGFF1.29 202.03,139.21 201.91,139.33 201.62,139.33 v13(201.45,139.16)
USB3TP2_R: length 1.8
  TOP w0.119: C18.2 205.05,139.28 204.5,139.28 204.26,139.04 ML2.4 203.61,139.04 R13.1
USB3TP3: length 84.9
  IN3 w0.06: v10(65.09,111.43) 65.09,111.33 64.97,111.21 64.97,111.1 64.87,111 64.87,110.87 64.97,110.77 64.97,110.39 65.17,110.19 65.17,110.01 64.97,109.81 64.79,109.81 64.63,109.64 64.47,109.64 64.23,109.39 63.72,109.39 63.1,108.78 63.1,108.42 63.04,108.36
  IN3 w0.084: v7(123.12,95.88) 122.98,95.75 122.98,95.67 122.77,95.46 121.23,95.46 121.01,95.67 113.24,95.67 112.86,96.06 102.99,96.06 101.81,97.24 82.63,97.24 81.58,96.18 80.08,96.18 78.36,94.47 62.87,94.47 62.22,95.12 62.22,95.84 61.94,96.11 61.94,96.8 59.76,98.98 59.76,104.37 59.96,104.57 59.96,106.33 61.04,107.41 62.08,107.41 62.2,107.52 62.2,107.52 63.04,108.36
  BOTTOM w0.119: v7(123.12,95.88) 123.02,95.79 123.02,95.67 123.12,95.57 JIO4.90
USB3TP4: length 60
  IN1 w0.109: v2(90.35,127.73) 90.36,127.73 v1(90.79,128.16)
  IN2 w0.079: v2(64.21,109.87) 64.21,110.12 64.08,110.25 64.08,110.51 64.08,110.64 63.37,111.36 62.13,111.36 61.38,111.36 61.05,111.69 58.8,111.69 57.26,113.23 57.26,114.66 55.06,116.86 55.06,120.66 57.33,122.93 59.79,122.93 61.43,124.57 64.33,124.57 65.97,126.21 77.41,126.21 79.77,128.56 83.07,128.56 84.34,127.29 90.76,127.29 90.85,127.38 90.85,127.81 90.68,127.98 90.6,127.98 v2(90.35,127.73)
  IN3 w0.06: v2(64.21,109.87) 64.27,109.93 64.27,110.2 64.57,110.5 64.57,110.77 64.72,110.93 64.72,111.14 v10(64.77,111.18)
USB3TP4_C: length 1.9
  TOP w0.119: R88.1 92.93,127.77 ML5.4 92.3,127.77 92.11,127.57 92,127.57 91.41,128.16 C80.2
USB3TP4_CON: length 19.2
  TOP w0.119: R88.2 93.9,127.77 ML5.3 94.54,127.77 94.84,127.46 95.01,127.46 95.1,127.55 95.1,127.96 96.55,129.41 99.42,129.41 99.5,129.49 MD1.6 100.19,129.49 100.32,129.36 100.46,129.36 100.59,129.49 MD1.5 101.12,129.49 101.22,129.39 101.49,129.39 101.81,129.71 102.28,129.71 102.62,129.36 102.62,129.14 102.62,129.09 v13(102.74,128.97)
  IN3 w0.084: v7(101.08,135.17) 101.1,135.14 101.78,135.14 102.79,134.13 102.79,130.2 102.63,130.04 102.63,129.15 102.6,129.13 102.6,129.11 v13(102.74,128.97)
  BOTTOM w0.119: JCAM3.6 101.41,135.18 101.36,135.13 101.12,135.13 v7(101.08,135.17)
USB3TP5: length 110.7
  IN2 w0.079: v2(62.36,100.62) 61.81,100.08 55.44,100.08 54.19,101.33 51.06,101.33 50.83,101.56 48.52,101.56 47.15,102.94 39.79,102.94 35.66,98.81 34.18,98.81 22.89,87.51 22.89,86.36 18.7,82.18 18.7,44.64 20.4,42.94 20.4,42.26 20.14,42 19.79,42 v2(19.68,41.9)
  IN3 w0.06: 63,105.72 63.01,105.73 63.01,105.73 63.46,106.18 63.46,106.43 64.57,107.53 64.57,107.81 65.41,108.65 65.41,109.5 65.6,109.7 65.6,110.17 66.19,110.76 66.19,111.17 66.04,111.31 65.85,111.31 v10(65.73,111.43)
  IN3 w0.084: v7(21.06,42.4) 20.95,42.29 20.95,42.14 20.95,42.14 20.95,42.01 20.68,41.74 20.55,41.74 20.28,41.74 20.17,41.85 20.17,41.85 19.96,42.05 19.84,42.05 v2(19.68,41.9) ; v2(62.36,100.62) 62.27,100.62 62.17,100.73 62.17,101.21 62.59,101.63 62.59,101.76 62.59,101.76 62.59,103.19 62.64,103.24 62.64,104.87 62.64,105.32 62.8,105.49 62.8,105.51 63,105.72
USB3TP5_C: length 1.9
  BOTTOM w0.119: C346.2 20.92,41.67 20.92,41.18 21.25,40.84 ML11.1 21.28,40.48 R472.1
USB3TP5_CON: length 12.3
  IN3 w0.084: v7(20.76,36.56) 20.5,36.82 20.5,37.15 20.16,37.49 14.75,37.49 14.4,37.85 13.14,37.85 13.08,37.9 JUSB1.9
  BOTTOM w0.119: R472.2 21.25,39.18 ML11.2 21.25,38.31 20.96,38.02 20.96,37.87 20.55,37.45 20.55,37.4 20.76,37.19 v7(20.76,36.56)
USB20_N1: length 129.9
  TOP w0.119: v1(30.54,45.66) 30.53,45.65 R270.1
  IN1 w0.109: v1(30.54,45.66) 30.3,45.42 30.3,45.27 v2(30.44,45.13)
  IN3 w0.084: v2(30.44,45.13) 30.33,45.02 30.33,44.07 30.12,43.86 19.54,43.86 17.43,45.97 17.43,53.26 18.8,54.63 18.8,64.26 18.33,64.73 18.33,66.93 18.8,67.39 18.8,103.32 18.71,103.4 18.71,105.62 20.27,107.19 25.37,107.19 28.63,110.45 30.84,110.45 30.95,110.57 34.6,110.57 36.52,108.65 39.8,108.65 v6(39.93,108.78)
  IN4 w0.06: v5(61.87,117.62) 61.83,117.62 61.51,117.94 57.85,117.94 57.79,117.87 57.64,117.87 57.57,117.81 57.39,117.81 56.67,117.09 56.06,117.09 55.93,117.21 55.76,117.21 55.75,117.23 55.71,117.23 55.7,117.24 55.69,117.24
  IN4 w0.089: 55.69,117.24 53.58,117.24 53.42,117.4 53.23,117.4 53.16,117.47 52.24,117.47 51.92,117.15 48.82,117.15 47.06,115.38 45.34,115.38 44.55,114.59 44.55,111.32 44.75,111.12 44.75,110.12 43.35,108.71 39.99,108.71 v6(39.93,108.78)
USB20_N1_R: length 7
  TOP w0.119: v1(30.54,43.96) 30.54,44.35 R270.2
  IN1 w0.109: v1(35.19,40.67) 35.11,40.67 34.55,41.23 34.17,41.23 34.11,41.29 33.18,41.29 31.51,42.97 30.84,42.97 30.3,43.5 30.3,43.72 v1(30.54,43.96)
USB20_N2: length 33.8
  TOP w0.119: v1(53.26,132.93) 53.27,132.93 R39.1
  IN1 w0.109: v2(53.49,132.48) 53.49,132.7 v1(53.26,132.93)
  IN2 w0.079: v2(48.81,119.29) 48.74,119.29 48.62,119.41 48.62,119.45 48.56,119.5 48.56,119.7 48.75,119.88 48.75,121.67 49.22,122.14 49.22,126.52 49.22,126.71 50.3,127.79 50.3,127.94 50.3,129.75 50.19,129.87 50.19,130.6 52.43,132.85 53.62,132.85 53.72,132.74 53.72,132.66 53.54,132.48 v2(53.49,132.48)
  IN3 w0.06: v10(61.13,118.58) 61.13,118.75 61.24,118.86 61.34,118.86 61.39,118.81 61.39,118.45 61.32,118.38 60.3,118.38 60.11,118.57 59.09,118.57 58.88,118.78 57.37,118.78 56.9,119.26 56.9,119.35 56.67,119.58 56.63,119.58 56.62,119.59 56.61,119.59
  IN3 w0.084: v2(48.81,119.29) 48.69,119.29 48.62,119.22 48.62,119.01 49.3,118.33 51.88,118.33 52.97,119.42 53.02,119.42 53.19,119.6 54.37,119.6 54.51,119.46 54.64,119.46 54.89,119.21 55.18,119.21 55.43,119.46 55.72,119.46 55.85,119.59 56.61,119.59
USB20_N2_R: length 4
  TOP w0.119: v1(54.96,132.93) 54.58,132.93 R39.2
  IN1 w0.109: v1(54.96,132.93) 54.96,132.74 v2(54.76,132.54)
  IN3 w0.084: v2(54.76,132.54) 54.97,132.74 54.97,133.47 54.24,134.19 54.24,134.52 54.42,134.7 54.67,134.7 54.76,134.78 v7(54.76,134.89)
USB20_N3: length 240.4
  IN2 w0.079: v2(177.75,94.73) 177.58,94.9 177.58,95.58 179.52,97.52 181.76,97.52 182.94,98.7 189.73,98.7 192.03,101 196.85,101 197.18,100.66 203.07,100.66 203.87,101.46 209.73,101.46 213.56,105.29 213.56,111.96 213.56,111.96 213.56,112.75 212.73,113.57 211.94,113.57 210.67,114.84 210.67,117.31 210.9,117.53 211.29,117.53 v2(211.43,117.39)
  IN3 w0.084: v3(53.95,117.74) 54.05,117.64 54.05,117.54 53.85,117.34 52.48,117.34 51.91,116.76 49.84,116.76 49.35,116.27 48.49,116.27 47.92,115.7 46.45,115.7 46.02,115.27 46.02,114.01 46.02,114.01 46.02,113.94 45.9,113.83 45.9,112.44 45.1,111.64 45.1,109.1 45.05,109.05 45.05,108.08 44.07,107.1 44.07,103.16 45.46,101.78 45.46,94.8 46.27,93.99 46.27,93.39 48.52,91.15 62.22,91.15 62.91,91.84 81,91.84 82.81,93.64 84.51,93.64 85.78,94.9 97.48,94.9 98.76,93.63 107.72,93.63 107.76,93.67 111.15,93.67 112.72,92.09 125.02,92.09 125.34,92.41 175.99,92.41 177.58,94 177.58,94.56 v2(177.75,94.73) ; v7(210.74,117.47) 210.82,117.55 211.26,117.55 v2(211.43,117.39)
  IN4 w0.06: v5(61.87,118.26) 61.66,118.26 61.46,118.46 61.29,118.46 61.21,118.38 60.99,118.38 60.97,118.41 58.25,118.41 58.16,118.49 56.94,118.49 56.52,118.07 55.99,118.07 55.93,118.13 55.83,118.13 55.83,118.12 54.33,118.12 54.24,118.03 54.17,118.03 54.06,117.92 54.06,117.85 54,117.8
  IN4 w0.089: 54,117.8 v3(53.95,117.74)
  BOTTOM w0.119: R394.1 209.55,119.4 L22.1 208.89,119.4 208.6,119.1 208.44,119.1 208.05,118.71 208.05,118.03 208.54,117.55 208.54,117.27 208.75,117.06 210.12,117.06 210.56,117.5 210.72,117.5 v7(210.74,117.47)
USB20_N3_CONN: length 34.2
  IN3 w0.084: v7(202.96,146.21) 202.96,146.33 203.03,146.41 204.3,146.41 208.62,142.09 209.41,142.09 212.27,139.23 212.27,135.81 211.34,134.88 211.34,127.44 211.29,127.39 211.29,119.17 211.04,118.93 210.96,118.93 210.89,118.99 v7(210.89,119.4)
  BOTTOM w0.119: v7(210.89,119.4) 210.51,119.4 R394.2
USB20_N5: length 121.9
  IN3 w0.06: v3(59.41,117.49) 59.38,117.52 59.31,117.52 59.16,117.36 59.16,117.26 59.1,117.21 59.1,116.88 58.35,116.13 56.69,116.13 56.22,116.6 56.18,116.6
  IN3 w0.084: 56.18,116.6 54.73,116.6 54.3,116.17 52.93,116.17 52.05,115.29 50.85,115.29 50.34,114.78 49.77,114.78 49.34,114.35 48.04,114.35 47.63,113.94 47.63,113.93 47.62,113.91 47.62,112.55 47.3,112.24 47.3,111.89 46.4,110.98 46.4,109.46 47.23,108.63 47.23,107.7 46.8,107.27 46.07,107.27 45.34,106.54 45.34,103.74 47.37,101.71 47.37,99.43 46.73,98.79 46.73,95.48 47.34,94.87 48.48,94.87 50.92,92.43 61.09,92.43 61.1,92.43 61.64,92.43 62.69,93.47 78.78,93.47 79.48,94.18 81.35,94.18 82.16,94.99 84.01,94.99 85.31,96.28 101.41,96.28 102.8,94.89 107.06,94.89 107.11,94.95 112.46,94.95 112.73,94.68 118.14,94.68 119.41,93.41 123.86,93.41 124.04,93.59 124.04,93.62 v7(123.91,93.75)
  IN4 w0.06: v3(59.41,117.49) 59.28,117.49 59.17,117.38 59.17,117.32 59.31,117.19 59.61,117.19 59.82,117.4 60.57,117.4 60.68,117.5 61.21,117.5 61.41,117.3 v5(61.62,117.3)
  BOTTOM w0.119: v7(123.91,93.75) 123.99,93.83 123.99,94.63 123.92,94.7 JIO4.86
USB20_N7: length 202.2
  IN3 w0.06: 56.18,117.31 56.31,117.44 57.38,117.44 57.9,116.92 57.99,116.92 58.29,116.62 v3(58.29,116.6)
  IN3 w0.084: 56.18,117.31 56.06,117.19 54.38,117.19 54.03,116.83 52.63,116.83 52.11,116.32 51.02,116.32 50.19,115.48 49.32,115.48 48.82,114.98 47.9,114.98 47.73,115.15 46.98,115.15 46.59,114.75 46.59,113.73 46.45,113.6 46.45,112.09 45.68,111.32 45.68,108.9 45.61,108.82 45.61,107.83 44.62,106.84 44.62,103.45 46.66,101.41 46.66,99.73 46.02,99.09 46.02,95.17 46.5,94.69 46.82,94.37 46.82,94.04 46.82,93.64 48.75,91.72 61.39,91.72 61.39,91.72 62,91.72 62.69,92.41 80.76,92.41 82.58,94.22 84.32,94.22 85.55,95.46 97.72,95.46 99,94.18 107.46,94.18 107.5,94.22 111.39,94.22 111.85,93.76 118.03,93.76 119.1,92.69 124.76,92.69 125.14,93.07 174.71,93.07 176.81,95.17 198.08,95.17 198.65,95.74 198.65,96.16 198.82,96.33 199.09,96.33 v7(199.14,96.27)
  IN4 w0.06: v3(58.29,116.6) 58.53,116.37 59.92,116.37 60.35,116.8 60.99,116.8 61.04,116.85 61.21,116.85 61.41,116.65 v5(61.62,116.65)
  BOTTOM w0.119: JUSH1.8 199.93,99.2 199.87,99.14 199.87,97.07 199.78,96.98 199.78,96.56 199.54,96.32 199.19,96.32 v7(199.14,96.27)
USB20_N9: length 103
  IN1 w0.109: v1(29.17,63.15) 27.27,63.15 24.63,65.79 22.54,65.79 21.93,65.18 v2(19.52,65.18)
  IN3 w0.084: v2(19.52,65.18) 19.35,65.34 19.14,65.34 18.88,65.6 18.88,66.54 19.38,67.03 19.38,103.61 19.27,103.72 19.27,105.39 20.5,106.62 25.58,106.62 28.86,109.9 31.12,109.9 31.24,110.02 34.37,110.02 36.68,107.71 39.67,107.71 v6(39.75,107.79)
  IN4 w0.06: v5(61.87,116.97) 61.66,116.97 61.46,117.17 61.29,117.17 61.21,117.09 59.86,117.09 59.71,116.95 59.21,116.95 58.55,117.61 58.23,117.61 58.15,117.53 57.45,117.53 56.57,116.66 55.76,116.66 55.51,116.9 55.48,116.9
  IN4 w0.089: 55.48,116.9 54.02,116.9 53.47,116.35 52.51,116.35 52.32,116.16 51.95,115.79 50.97,114.81 50.88,114.81 50.03,113.96 49.29,113.96 48.29,112.96 47.54,112.96 46.67,112.09 46.02,112.09 45.39,111.46 45.39,109.9 43.28,107.79 v6(39.75,107.79)
USB20_N9_CONN: length 15.4
  IN3 w0.084: v7(19.74,34.97) 19.88,34.82 19.88,34.73 19.61,34.46 14.78,34.46 13.99,35.26 12.91,35.26 11.91,34.25 11.84,34.25 11.78,34.31 JUSB1.2
  BOTTOM w0.119: R477.2 19.98,30.6 ML13.2 20,30.86 20.29,31.15 20.29,31.26 20.11,31.44 MD2.6 20.11,33.05 20.29,33.23 20.29,33.59 19.85,34.02 19.85,34.85 v7(19.74,34.97)
USB20_N9_PS: length 12.7
  TOP w0.119: v1(21.93,60.95) 22.63,60.25 24.65,60.25 25.08,60.68 25.08,61.7 25.08,61.78 25.29,61.98 25.29,62.97 25.47,63.15 US1.11
  IN1 w0.084: v1(24.05,65.15) 23.91,65.01 23.35,65.01 21.42,63.08 21.42,62.94 21.42,61.63 21.93,61.12 v1(21.93,60.95)
USB20_N9_SW: length 54.9
  TOP w0.119: v1(21.93,61.86) 21.93,62.52 21.36,63.1 21.36,64.41 21.6,64.65 21.66,64.65 21.88,64.65 21.88,64.65 U29.7
  IN1 w0.109: v2(23.33,62.88) 23.54,62.67 23.54,62.57 23.43,62.46 22.51,62.46 22.26,62.22 22.26,62.02 22.11,61.86 v1(21.93,61.86)
  IN3 w0.084: v2(23.33,62.88) 23.58,62.63 23.58,61.96 23.84,61.7 23.84,57.95 24.54,57.25 24.54,50.08 25.49,49.13 30.66,49.13 31.76,48.02 31.76,44.75 31.77,44.75 31.77,44.26 30.97,43.47 26.85,43.47 22.95,39.57 22.95,37.43 21.15,35.63 21.15,34.13 20.11,33.08 20.11,29.93 20.33,29.7 20.33,29 20.24,28.91 v7(20,28.91)
  BOTTOM w0.119: R477.1 19.98,28.92 v7(20,28.91)
USB20_P1: length 129.9
  TOP w0.119: v1(29.69,45.66) 29.67,45.64 R269.1
  IN1 w0.109: v2(29.75,45.14) 29.83,45.14 30.07,45.38 30.07,45.46 29.87,45.66 v1(29.69,45.66)
  IN3 w0.084: v2(29.75,45.14) 29.94,45.14 30.16,44.92 30.16,44.14 30.05,44.02 19.61,44.02 17.59,46.03 17.59,53.2 18.96,54.56 18.96,64.33 18.5,64.79 18.5,66.86 18.96,67.32 18.96,103.38 18.87,103.47 18.87,105.56 20.34,107.03 25.43,107.03 28.7,110.29 30.9,110.29 31.02,110.41 34.53,110.41 36.45,108.49 39.79,108.49 v6(39.93,108.35)
  IN4 w0.06: 55.69,117.09 55.88,117.09 56.01,116.97 56.72,116.97 57.44,117.69 57.62,117.69 57.69,117.75 57.84,117.75 57.9,117.82 61.46,117.82 61.62,117.66 61.62,117.54 61.57,117.49 61.43,117.49 61.37,117.55 v5(61.37,117.62)
  IN4 w0.089: 55.69,117.09 53.52,117.09 53.36,117.26 52.33,117.26 52.01,116.93 48.91,116.93 47.15,115.17 45.43,115.17 44.77,114.5 44.77,111.41 44.97,111.21 44.97,110.03 43.43,108.5 39.97,108.5 39.93,108.46 v6(39.93,108.35)
USB20_P1_R: length 7
  TOP w0.119: v1(29.69,43.96) 29.69,44.34 R269.2
  IN1 w0.109: v1(29.69,43.96) 29.77,43.96 30.07,43.65 30.07,43.4 30.74,42.74 31.41,42.74 33.09,41.06 34.02,41.06 34.08,41 34.45,41 34.69,40.76 v1(34.69,40.67)
USB20_P2: length 34.4
  TOP w0.119: v1(53.26,132.08) 53.27,132.07 R46.1
  IN1 w0.109: v2(54.05,132.5) 53.63,132.08 v1(53.26,132.08)
  IN2 w0.079: v2(48.28,119.3) 48.38,119.4 48.38,119.62 48.38,119.78 48.56,119.96 48.56,121.74 49.04,122.22 49.04,126.44 49.04,126.44 49.04,126.63 49.04,126.79 50.12,127.87 50.12,129.67 50,129.79 50,130.68 52.35,133.03 53.69,133.03 53.91,132.82 53.91,132.65 v2(54.05,132.5)
  IN3 w0.06: v10(61.62,118.58) 61.51,118.48 61.51,118.4 61.37,118.26 61.21,118.26 61.21,118.26 60.25,118.26 60.06,118.45 59.04,118.45 58.83,118.66 57.32,118.66 56.78,119.21 56.78,119.3 56.63,119.45 56.61,119.45
  IN3 w0.084: 56.61,119.45 56.2,119.45 56.18,119.43 55.92,119.43 55.79,119.3 55.5,119.3 55.25,119.05 54.83,119.05 54.58,119.3 54.44,119.3 54.31,119.43 53.26,119.43 53.09,119.26 53.04,119.26 51.94,118.16 49.24,118.16 48.45,118.95 48.45,119.13 v2(48.28,119.3)
USB20_P2_R: length 3.7
  TOP w0.119: R46.2 54.58,132.08 v1(54.96,132.08)
  IN1 w0.109: v1(54.96,132.08) 54.96,132.18 55.3,132.51 v2(55.3,132.57)
  IN3 w0.084: v7(54.76,134.39) 54.61,134.54 54.49,134.54 54.4,134.45 54.4,134.26 55.13,133.53 55.13,132.73 v2(55.3,132.57)
USB20_P3: length 240.4
  IN2 w0.079: v2(177.01,94.71) 177.01,94.53 177.13,94.41 177.32,94.41 177.39,94.49 177.39,95.66 179.44,97.7 181.69,97.7 182.86,98.88 189.65,98.88 191.95,101.18 196.93,101.18 197.26,100.85 203,100.85 203.79,101.64 209.65,101.64 213.37,105.36 213.37,111.88 213.37,112.67 212.65,113.39 211.87,113.39 210.49,114.76 210.49,117.38 210.82,117.71 211.31,117.71 211.43,117.83 v2(211.43,117.92)
  IN3 w0.084: v2(211.43,117.92) 211.43,117.83 211.32,117.72 210.88,117.72 v7(210.74,117.85) ; v2(177.01,94.71) 177.32,94.71 177.42,94.6 177.42,94.07 175.92,92.57 125.27,92.57 124.95,92.26 112.79,92.26 111.22,93.83 107.69,93.83 107.65,93.79 98.82,93.79 97.55,95.07 85.71,95.07 84.44,93.8 82.74,93.8 80.94,92 62.84,92 62.15,91.31 48.58,91.31 46.43,93.46 46.43,94.06 45.62,94.87 45.62,101.84 44.23,103.23 44.23,107.04 45.21,108.02 45.21,108.98 45.26,109.03 45.26,111.57 46.07,112.38 46.07,113.76 46.18,113.87 46.18,114.08 46.18,115.21 46.52,115.54 47.99,115.54 48.55,116.11 49.42,116.11 49.91,116.6 51.97,116.6 52.54,117.17 53.91,117.17 54.21,117.47 54.21,117.68 54.3,117.77 54.46,117.77 v3(54.51,117.72)
  IN4 w0.06: v3(54.51,117.72) 54.41,117.62 54.28,117.62 54.18,117.72 54.18,117.87 54.22,117.91 54.29,117.91 54.38,118 55.88,118 55.88,118.01 55.94,117.95 56.57,117.95 56.99,118.37 58.11,118.37 58.2,118.29 60.92,118.29 60.94,118.26 61.37,118.26 v5(61.37,118.26)
  BOTTOM w0.119: v7(210.74,117.85) 210.65,117.76 210.45,117.76 210.01,117.32 208.86,117.32 208.8,117.38 208.8,117.65 208.31,118.14 208.31,118.6 208.55,118.84 208.63,118.84 208.93,118.55 L22.4 209.21,118.53 R398.1
USB20_P3_CONN: length 34.3
  IN3 w0.084: v7(210.89,118.55) 211.45,119.11 211.45,127.32 211.51,127.37 211.51,134.81 212.43,135.74 212.43,139.3 209.48,142.25 208.69,142.25 204.37,146.57 203.09,146.57 v7(202.96,146.71)
  BOTTOM w0.119: R398.2 210.5,118.55 v7(210.89,118.55)
USB20_P5: length 121.8
  IN3 w0.06: 56.18,116.77 56.22,116.77 56.74,116.25 58.3,116.25 58.98,116.93 58.98,117.16 58.98,117.26 59.04,117.31 59.04,117.46 v3(58.99,117.51)
  IN3 w0.084: v7(124.31,93.75) 124.2,93.65 124.2,93.52 123.93,93.25 119.34,93.25 118.07,94.52 112.66,94.52 112.39,94.78 107.18,94.78 107.13,94.73 102.73,94.73 101.34,96.12 85.37,96.12 84.08,94.82 82.22,94.82 81.42,94.02 79.55,94.02 78.84,93.31 62.75,93.31 61.71,92.27 61.16,92.27 50.85,92.27 48.41,94.71 47.27,94.71 46.57,95.41 46.57,98.86 47.21,99.5 47.21,101.64 45.18,103.68 45.18,106.61 46,107.43 46.73,107.43 47.07,107.76 47.07,108.56 46.24,109.39 46.24,111.05 47.14,111.95 47.14,112.31 47.45,112.62 47.45,113.99 47.97,114.51 49.27,114.51 49.7,114.94 50.27,114.94 50.78,115.45 51.98,115.45 52.86,116.33 54.23,116.33 54.66,116.77 56.18,116.77
  IN4 w0.06: v3(58.99,117.51) 59.05,117.44 59.05,117.27 59.26,117.07 59.66,117.07 59.87,117.28 60.62,117.28 60.73,117.38 61.05,117.38 v5(61.13,117.3)
  BOTTOM w0.119: v7(124.31,93.75) 124.25,93.81 124.25,94.63 124.32,94.7 JIO4.84
USB20_P7: length 202.1
  IN3 w0.06: 56.3,117.2 56.3,117.21 56.3,117.25 56.37,117.32 57.33,117.32 57.85,116.8 57.94,116.8 58.06,116.68 58.06,116.46 58.03,116.42 57.94,116.42 v3(57.84,116.53)
  IN3 w0.084: 56.3,117.2 56.13,117.03 54.45,117.03 54.09,116.67 52.69,116.67 52.18,116.15 51.09,116.15 50.25,115.32 49.39,115.32 48.89,114.82 47.83,114.82 47.67,114.98 47.05,114.98 46.75,114.68 46.75,113.8 46.75,113.66 46.62,113.53 46.62,112.02 45.85,111.25 45.85,108.83 45.77,108.75 45.77,107.76 44.78,106.77 44.78,103.52 46.82,101.48 46.82,99.66 46.18,99.02 46.18,95.24 46.62,94.8 46.98,94.43 46.98,93.98 46.98,93.98 46.98,93.71 48.82,91.88 61.32,91.88 61.32,91.88 61.93,91.88 62.62,92.57 80.69,92.57 82.51,94.39 84.25,94.39 85.48,95.62 97.79,95.62 99.07,94.34 107.39,94.34 107.43,94.39 111.45,94.39 111.92,93.92 118.1,93.92 119.16,92.85 124.69,92.85 125.07,93.23 174.64,93.23 176.74,95.33 198.01,95.33 198.49,95.81 198.49,96.23 198.75,96.49 198.98,96.49 v7(199.16,96.67)
  IN4 w0.06: v3(57.84,116.53) 57.8,116.56 57.8,116.77 57.87,116.84 58.03,116.84 58.06,116.8 58.06,116.5 58.19,116.37 58.35,116.37 58.48,116.25 59.97,116.25 60.4,116.68 61.1,116.68 v5(61.13,116.65)
  BOTTOM w0.119: JUSH1.9 199.43,99.29 199.49,99.23 199.57,99.23 199.61,99.18 199.61,97.18 199.52,97.09 199.52,96.67 199.43,96.58 199.25,96.58 v7(199.16,96.67)
USB20_P9: length 103
  IN1 w0.109: v1(29.17,63.65) 29.17,63.55 29.01,63.38 27.36,63.38 24.73,66.02 22.44,66.02 21.83,65.41 19.8,65.41 19.52,65.68 v2(19.52,65.84)
  IN3 w0.084: v2(19.52,65.84) 19.52,65.56 19.48,65.52 19.43,65.52 19.42,65.51 19.21,65.51 19.05,65.67 19.05,66.47 19.54,66.97 19.54,103.67 19.43,103.78 19.43,105.32 20.57,106.46 25.65,106.46 28.93,109.74 31.19,109.74 31.31,109.86 34.3,109.86 36.61,107.55 39.64,107.55 39.75,107.44 v6(39.75,107.25)
  IN4 w0.06: v5(61.37,116.97) 61.37,116.97 59.91,116.97 59.76,116.83 59.16,116.83 58.5,117.49 58.28,117.49 58.2,117.41 57.5,117.41 56.62,116.54 55.71,116.54 55.49,116.75 55.47,116.75
  IN4 w0.089: v6(39.75,107.25) 39.75,107.43 39.89,107.57 43.37,107.57 45.61,109.81 45.61,111.37 46.11,111.88 46.76,111.88 47.63,112.75 48.38,112.75 49.38,113.74 49.94,113.74 50.12,113.74 50.97,114.59 51.06,114.59 52.6,116.14 53.47,116.14 54.08,116.75 55.47,116.75
USB20_P9_CONN: length 15.5
  IN3 w0.084: v7(20.12,34.97) 20.04,34.89 20.04,34.66 19.68,34.3 14.72,34.3 13.92,35.09 12.98,35.09 11.98,34.09 11.9,34.09 11.78,33.97 JUSB1.3
  BOTTOM w0.119: R476.2 20.87,30.58 ML13.3 20.85,30.86 20.55,31.16 20.55,31.26 20.76,31.47 MD2.5 20.76,33.01 20.55,33.22 20.55,33.7 20.11,34.13 20.11,34.96 20.11,34.96 v7(20.12,34.97)
USB20_P9_PS: length 12.8
  TOP w0.119: v1(22.82,60.95) 22.82,60.61 22.95,60.48 24.57,60.48 24.85,60.77 24.85,61.86 25.06,62.07 25.06,63.12 25.36,63.41 25.49,63.41 25.55,63.48 25.55,63.53 25.68,63.65 US1.10
  IN1 w0.084: v1(22.82,60.95) 22.82,60.75 22.76,60.68 22.63,60.68 21.61,61.7 21.61,63.01 23.43,64.82 24.02,64.82 24.05,64.79 v1(24.05,64.65)
USB20_P9_SW: length 54.9
  TOP w0.119: U29.8 21.97,64.15 21.91,64.21 21.91,64.34 21.86,64.39 21.71,64.39 21.62,64.3 21.62,63.21 22.19,62.63 22.19,62.49 v1(22.82,61.86)
  IN1 w0.109: v1(22.82,61.86) 22.64,61.86 22.49,62.02 22.49,62.12 22.6,62.23 23.53,62.23 23.77,62.48 23.77,62.67 v2(23.99,62.88)
  IN3 w0.084: v7(20.85,28.91) 20.65,28.91 20.5,29.06 20.5,29.77 20.27,29.99 20.27,33.01 21.32,34.06 21.32,35.57 23.11,37.36 23.11,39.5 26.91,43.3 31.04,43.3 31.93,44.19 31.93,44.82 31.93,48.08 30.72,49.29 25.56,49.29 24.7,50.15 24.7,57.32 24,58.02 24,61.77 23.74,62.03 23.74,62.63 v2(23.99,62.88)
  BOTTOM w0.119: R476.1 20.87,28.93 v7(20.85,28.91)
USB_DET#: length 360.8
  IN1 w0.084: v2(206.91,97.53) 199.01,97.53 198.69,97.21 181.09,97.21 179.18,95.3 176.76,95.3 175.71,94.26 169.58,94.26 169.51,94.18 118.24,94.18 117.81,94.61 102.84,94.61 101.55,95.9 86.66,95.9 84.24,93.48 83.21,93.48 81.73,92.01 46.04,92.01 45.48,92.57 43.89,92.57 43.56,92.24 39.98,92.24 37.77,90.04 37.77,89.01 38.17,88.61 38.75,88.61 v2(39.26,88.1) ; v1(192.85,137.07) 192.85,137.24 v2(192.99,137.38)
  IN2 w0.079: v2(192.99,137.38) 192.82,137.54 192.82,140.97 198.01,146.16 207.57,146.16 210.65,143.08 212.53,143.08 220.7,134.91 220.7,119.55 221.24,119.01 221.24,117.52 221.97,116.79 221.97,104.14 215.55,97.72 211.34,97.72 211.31,97.75 209.06,97.75 208.64,97.32 207.12,97.32 v2(206.91,97.53)
  IN3 w0.084: v2(192.99,137.38) 192.85,137.24 v10(192.32,137.24) ; v2(39.26,88.1) v3(39.83,88.1)
  IN4 w0.089: v4(26.86,22.83) 28.71,22.83 31.36,25.48 36.74,25.48 37.85,26.58 37.85,28.72 41.14,32.01 41.14,86.81 39.85,88.1 v3(39.83,88.1)
  BOTTOM w0.119: JUSB1.10 12.51,28.82 v14(16.79,28.82) 17.58,28.03 20.68,28.03 20.9,28.26 22.22,28.26 26.86,23.62 v4(26.86,22.83)
USB_ILIM_SEL1: length 1.6
  TOP w0.119: US1.4 29.72,64.15 R243.2
USB_OC0#: length 90
  IN1 w0.084: v2(35.82,49.98) v1(35.82,49.61)
  IN3 w0.06: v10(63.35,112.47) 63.14,112.47 62.94,112.27 62.77,112.27 62.69,112.34 62.52,112.34 62.37,112.19 62.03,112.19 61.9,112.32 61.39,112.32 60.39,111.32 59.76,111.32 58.78,110.35 58.65,110.35
  IN3 w0.084: 58.65,110.35 57.27,110.35 54.96,108.04 54.96,107.8 54.72,107.56 52.34,107.56 51.26,106.47 v7(51.26,105.2) ; v3(36.15,50) 36.12,49.98 v2(35.82,49.98)
  IN4 w0.089: v7(51.26,105.2) 50.68,104.62 50.68,101.61 50.86,101.43 50.86,100.28 50.03,99.45 48.99,99.45 48.8,99.64 46.89,99.64 45.87,98.62 43.13,98.62 41.06,98.62 40.47,98.03 38.63,98.03 36.75,96.15 36.75,95.06 36.01,94.32 36.01,88.54 39.24,85.31 39.24,77.19 36.58,74.53 36.58,72.89 36.06,72.37 36.06,65.12 35.73,64.79 34.7,64.79 34.45,64.54 34.45,51.21 35.66,50 v3(36.15,50)
  BOTTOM w0.119: RH122.1 51.22,105.16 v7(51.26,105.2)
USB_OC1#: length 81.9
  IN1 w0.084: v1(26.87,61.85) 27.3,62.28 29.44,62.28 30.19,63.03 34.84,63.03 35.74,63.92 35.74,64.3 36.32,64.89 36.32,65.53 v2(36.49,65.7)
  IN3 w0.06: 58.66,109.85 58.79,109.85 59.9,110.96 61.09,110.96 61.54,111.42 61.57,111.42 61.57,111.43 62.25,111.43 62.56,111.74 62.56,111.81 62.87,112.12 63.08,112.12 v10(63.1,112.14)
  IN3 w0.084: v3(36.33,66.08) 36.49,65.93 v2(36.49,65.7) ; 58.66,109.85 57.7,109.85 55.64,107.79 55.64,107.38 54.9,106.64 54.86,106.64 54.86,106.64 53.68,106.64 53.44,106.4 53.44,105.93 53.1,105.59 52.68,105.59 52.44,105.35 52.44,105.12 51.47,104.15 51.47,104.15 51.42,104.1 v7(51.13,104.1)
  IN4 w0.089: v3(36.33,66.08) 36.25,66.16 36.25,72.28 36.77,72.8 36.77,74.46 39.43,77.11 39.43,85.41 36.2,88.64 36.2,94.24 36.94,94.98 36.94,96.07 38.71,97.84 40.55,97.84 41.14,98.43 45.94,98.43 46.97,99.45 48.72,99.45 48.91,99.26 50.11,99.26 51.13,100.28 51.13,101.43 50.87,101.69 50.87,103.85 v7(51.13,104.1)
  BOTTOM w0.119: RH126.1 51.08,104.05 v7(51.13,104.1)
USB_OC2#: length 6.1
  IN4 w0.06: v4(60.98,109.07) 60.98,109.21 61.57,109.79 61.57,109.9 61.73,110.07 61.96,110.07 62.12,110.22 62.12,110.41 62.33,110.62 v5(62.33,110.72)
  BOTTOM w0.119: v4(60.98,109.07) 60.98,108.13 59.56,106.71 T30.1 59.98,106.44 RH110.1
USB_PWR_SHR_EN#: length 284.1
  TOP w0.119: v1(202.95,108.19) 202.95,107.4 204.06,106.29 204.06,104.46 205.51,103.01 205.51,101.51 207.02,100 v1(207.02,99.84)
  IN1 w0.084: v1(202.95,108.19) 202.87,108.19 v2(202.64,108.42) ; v2(34.54,63.74) 34.11,64.18 28.65,64.18 v1(27.87,64.95) ; v2(38.73,88.09) 38.4,88.42 38.1,88.42 37.59,88.93 37.59,90.12 39.9,92.43 42.73,92.43 43.62,93.32 45.06,93.32 46.19,92.2 81.66,92.2 83.13,93.67 84.16,93.67 86.58,96.09 101.62,96.09 102.92,94.79 118.21,94.79 118.87,95.46 120.24,95.46 120.88,96.09 124.14,96.09 124.14,96.09 124.44,96.09 132.12,96.09 133.85,94.36 169.43,94.36 169.5,94.44 175.64,94.44 176.68,95.48 179.1,95.48 181.01,97.4 198.61,97.4 198.98,97.76 205.33,97.76 207.02,99.46 v1(207.02,99.84)
  IN3 w0.084: v3(202.36,108.59) 202.53,108.42 v2(202.64,108.42) ; v3(38.86,87.72) 38.86,87.97 v2(38.73,88.09) ; v2(34.54,63.74) 34.59,63.79 v3(34.98,63.79)
  IN4 w0.089: v3(34.98,63.79) 35.8,63.79 37.26,65.26 37.26,72.16 37.61,72.51 37.61,74.1 40.2,76.7 40.2,86.37 v3(38.86,87.72) ; v10(192.32,136.24) 192.56,136.48 192.87,136.48 193.06,136.68 193.06,136.78 193.25,136.97 194.48,136.97 194.49,136.95 196.33,136.95 197.08,137.71 197.84,137.71 198.53,138.39 198.53,139.42 198.82,139.72 199.88,139.72 200.48,140.31 200.48,142.15 201.24,142.91 202.1,142.91 202.61,142.4 203.09,142.4 203.98,143.29 208.01,143.29 208.65,142.65 208.65,137.56 206.82,135.73 206.82,120.03 203.69,116.91 203.69,113.64 202.7,112.65 202.7,108.93 v3(202.36,108.59)
USB_PWR_SHR_VBUS_EN: length 283.8
  TOP w0.119: v1(202.17,108.26) 202.17,107.87 203.84,106.2 203.84,104.37 205.29,102.92 205.29,101.42 206.65,100.05 v1(206.65,99.85) ; US1.5 28.37,65.51 28.69,65.83 v1(28.69,66.25)
  IN1 w0.084: v2(34.52,64.28) 32.55,66.25 v1(28.69,66.25) ; v2(38.21,88.04) 37.4,88.85 37.4,90.2 39.81,92.61 42.65,92.61 43.55,93.51 45.39,93.51 46.52,92.38 60.54,92.38 60.73,92.57 81.77,92.57 83.05,93.86 84.08,93.86 86.5,96.27 101.7,96.27 103,94.98 118.13,94.98 118.79,95.64 120.17,95.64 120.8,96.28 124.06,96.28 132.19,96.28 133.92,94.55 169.35,94.55 169.43,94.63 175.56,94.63 176.6,95.67 179.03,95.67 180.94,97.58 198.53,97.58 198.9,97.95 205.25,97.95 206.65,99.35 v1(206.65,99.85) ; v2(201.92,108.5) 202.16,108.26 v1(202.17,108.26)
  IN3 w0.084: v3(38.47,87.66) 38.21,87.91 v2(38.21,88.04) ; v2(201.92,108.5) v3(201.92,108.87) ; v2(34.52,64.28) v3(34.92,64.28)
  IN4 w0.089: v3(201.92,108.87) 202.27,108.87 202.51,109.11 202.51,112.73 203.5,113.72 203.5,116.99 206.2,119.69 206.2,122.81 206.47,123.08 206.47,135.66 208.46,137.64 208.46,142.57 207.93,143.1 204.06,143.1 203.17,142.21 202.53,142.21 202.02,142.72 201.31,142.72 200.67,142.07 200.67,140.23 199.95,139.51 198.89,139.51 198.73,139.35 198.73,138.12 197.08,136.47 193.19,136.47 192.96,136.24 v10(192.82,136.24) ; v3(38.47,87.66) 40.01,86.11 40.01,76.78 37.42,74.18 37.42,72.6 37.06,72.24 37.06,65.35 35.9,64.19 35.01,64.19 v3(34.92,64.28)
USBC_AMSEL: length 18.2
  TOP w0.119: U31.8 26.51,37.06 26.63,36.94 v1(26.63,36.93) ; R295.1 R285.2 21.49,34.71 21.49,36.37 21.65,36.52 21.65,36.81 21.81,36.97 v1(21.81,37.25)
  IN1 w0.084: v1(32.26,40.86) 31.2,40.86 31.06,41 28.89,41 26.95,39.06 26.95,37.25 v1(26.63,36.93) 26.5,37.06 25.37,37.06 25.18,37.25 v1(21.81,37.25)
USBC_BOT_N: length 18.7
  IN1 w0.109: v1(23.32,30.99) 23.52,31.19 23.52,31.36 23.79,31.63 24.42,31.63 25.12,30.93 28.73,30.93 32.64,34.84 32.64,36.98 32.28,37.33 32.28,38.69 32.82,39.23 34.67,39.23 34.77,39.33 34.77,39.58 v1(34.69,39.66)
USBC_BOT_N_R: length 25.7
  TOP w0.119: v1(23.24,29.77) 23.35,29.77 23.51,29.92 23.51,30.22 R306.1
  IN1 w0.109: v1(23.24,29.77) 23.47,29.77 23.56,29.68 23.56,29.32 22.91,28.67 22.91,27.17 19.91,24.17 19.14,24.17 10.3,15.32 9.19,15.32 8.38,16.13 6.85,16.13 6.78,16.2 JUSBC1.B7
USBC_BOT_P: length 18.7
  IN1 w0.109: v1(23.88,30.99) 23.75,31.11 23.75,31.26 23.88,31.4 24.32,31.4 25.02,30.7 28.83,30.7 29.19,31.06 32.87,34.74 32.87,37.07 32.51,37.43 32.51,38.6 32.91,39 34.72,39 35,39.28 35,39.49 35.18,39.66 v1(35.19,39.66)
USBC_BOT_P_R: length 25.7
  TOP w0.119: v1(24.08,29.77) 23.77,30.08 23.77,30.3 R307.1
  IN1 w0.109: v1(24.08,29.77) 23.93,29.77 23.79,29.63 23.79,29.23 23.14,28.58 23.14,27.07 20.01,23.94 19.24,23.94 10.39,15.09 9.09,15.09 8.29,15.9 7.03,15.9 JUSBC1.B6
USBC_CC1: length 45.4
  TOP w0.203: C219.1 33.24,38.9 33.52,38.9 33.79,38.62 34.65,38.62 U32.L9 U32.K9
  TOP w0.254: v13(9.91,16.79) 9.72,16.98 v14(9.42,16.98) 8.79,16.98 8.61,16.8 JUSBC1.A5
  TOP w0.381: v1(33.5,38.22) 33.5,38.37 33.22,38.65 C219.1
  IN1 w0.381: v2(18.31,20.23) 22.17,20.23 30.64,28.7 30.64,30.55 34.24,34.15 34.24,37.68 33.71,38.22 v1(33.5,38.22)
  IN3 w0.381: v7(17.42,22.18) 17.42,21.91 18.31,21.02 v2(18.31,20.23)
  IN4 w0.254: 17.42,21.91 v7(17.42,22.18)
  IN4 w0.381: v13(9.91,16.79) 11.49,18.38 15.11,18.38 17.42,20.69 17.42,21.91
USBC_CC2: length 53.4
  TOP w0.119: v13(9.64,20.08) v14(10.06,19.66)
  TOP w0.203: U32.K10 U32.L10 34.64,38.16 34.09,37.61 v1(33.55,37.61) 33.52,37.61 33.07,38.06 C221.1
  IN1 w0.381: v2(17.68,20.21) 17.68,20.54 18.09,20.95 21.97,20.95 30.1,29.08 30.1,30.7 33.76,34.35 33.76,37.4 v1(33.55,37.61)
  IN1 w0.508: JUSBC1.B5 4.5,16.83 4.5,21.2 5.02,21.72 6.95,21.72 8.2,20.46 9.26,20.46 v13(9.64,20.08)
  IN3 w0.381: v7(15.24,22.18) 15.24,20.92 15.95,20.21 v2(17.68,20.21)
  IN4 w0.254: v7(15.24,22.18) 15.24,21.81
  IN4 w0.381: 15.24,21.81 15.24,21.02 14.3,20.08 v13(9.64,20.08)
USBC_DIS#: length 251.1
  IN1 w0.084: v1(30.91,59.29) 30.97,59.22 v2(31.71,59.22)
  IN2 w0.079: v2(31.71,59.22) 31.93,59.44 31.93,59.95 35.27,63.29 39.17,63.29 41.58,65.7 41.58,88.62 40.75,89.45 40.75,90.26 42.56,92.06 43.59,92.06 44.28,92.75 44.28,93.06 44.7,93.48 45.64,93.48 47.02,92.11 79.45,92.11 81.51,94.16 81.51,96.78 85.43,100.7 87.57,100.7 88.17,101.31 93.71,101.31 94.28,100.74 95.5,100.74 96.38,99.86 v2(98.98,99.86)
  IN3 w0.084: v7(99.56,99.93) 99.53,99.95 99.07,99.95 v2(98.98,99.86) ; v7(128.68,102.68) 128.75,102.61 129.54,102.61 130.27,103.33 132.43,103.33 132.51,103.25 134.19,103.25 134.98,102.47 136.12,102.47 136.81,103.16 149.83,103.16 149.99,103.01 v3(149.99,102.5)
  IN4 w0.089: v4(190.82,132.24) 190.44,131.85 190.04,131.85 189.33,131.15 189.33,131.15 188.95,130.77 188.95,130.43 188.66,130.15 188.66,129.7 190.87,127.5 192.44,127.5 193.52,126.42 194.42,126.42 197.83,123.02 197.83,118.12 198.04,117.91 198.04,115.16 196.18,113.3 196.18,111.23 195.39,110.44 195.39,108.17 194.1,106.87 190.05,106.87 188.81,105.63 183.05,105.63 181.08,103.66 178.72,103.66 178.49,103.43 175.35,103.43 174.94,103.84 173.33,103.84 173.06,103.57 167.65,103.57 165.32,101.23 155.49,101.23 154.96,101.76 150.91,101.76 150.17,102.5 v3(149.99,102.5)
  BOTTOM w0.119: v7(128.68,102.68) 127.11,102.68 126.08,101.65 120.28,101.65 116.44,97.81 116.44,94.1 115.31,92.97 100.04,92.97 99.47,93.53 99.47,99.73 99.56,99.81 v7(99.56,99.93)
