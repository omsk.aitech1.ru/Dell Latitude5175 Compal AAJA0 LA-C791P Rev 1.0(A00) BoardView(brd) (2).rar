# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN3 (solid shape): 131.06,127.23 131.06,126.69 130.18,125.81 130.18,122.06 128.36,120.23 128.36,116.86 128.94,116.27 128.94,115.53 129.22,115.25 129.52,115.25 130.19,114.59 130.19,112.46 129.24,111.52 129.24,109.2 128.68,108.63 128.68,107.91 128.18,107.42 121.23,107.42 120.45,106.63 120.45,106.63 120.19,106.36 111.64,106.36 110.29,105.01 110.12,105.01 110.08,105.05 110.08,105.38 110.14,105.44 110.45,105.44 111.59,106.58 120.14,106.58 121.14,107.58 128.1,107.58 128.5,107.97 128.5,108.7 129.07,109.28 129.07,111.59 130.02,112.54 130.02,114.55 129.47,115.1 129.13,115.1 128.76,115.47 128.76,116.19 128.17,116.77 128.17,120.33 129.99,122.15 129.99,125.89 130.87,126.77 130.87,127.14 128.56,129.45 126.94,129.45 126.9,129.49 126.9,129.6 126.96,129.65 128.64,129.65
GND on IN3 (solid shape): 43.18,120.08 43.21,120.07 43.29,119.99 43.29,117.15 43.23,117.06 43.12,117.08 42.55,117.65 42.55,119.24 42.6,119.33 42.7,119.32 43.1,119.38 43.09,119.79 43.08,119.82 43.09,119.85 43.12,119.93 43.13,120.05 43.14,120.07
GND on IN3 (solid shape): 47.68,120.46 47.78,120.4 47.76,120.28 47.09,119.62 47.09,119.29 47.45,118.93 47.81,119.29 47.81,119.33 47.9,119.42 47.93,119.43 47.97,119.42 47.98,119.41 47.98,119.38 47.98,119.37 48.02,119.14 48.22,119 48.24,119 48.26,118.97 48.26,118.87 48.93,118.2 48.93,117.96 48.91,117.92 48.88,117.91 48.82,117.91 48.04,118.68 46.22,118.68 46.18,118.64 46.15,118.62 46.11,118.64 46.1,118.65 46.08,118.72 46.06,118.77 46.04,118.84 46.08,118.9 46.15,118.99 46.19,119.1 46.22,119.17 46.29,119.19 46.36,119.19 47.63,120.46
GND on IN3 (solid shape): 12.68,166.7 13.24,166.46 13.48,165.9 13.48,163.1 13.53,161.29 13.7,159.75 13.99,158.37 14.4,157.25 14.38,157.15 14.3,157.11 13.51,157.11 12.62,158.01 12.62,161.09 10.5,163.21 10.5,163.35 10.64,163.73 10.27,163.91 10.18,163.92 10.14,164.01 10.14,164.29 9.99,164.87 9.85,164.29 9.85,163.19 12.09,160.95 12.09,157.42 12.22,157.28 12.25,157.17 12.15,157.11 5.13,157.11 4.96,157.27 5.55,158 7.06,160.71 7.58,163.77 7.58,165.9 7.82,166.46 8.38,166.7
GND on IN3 (solid shape): outline of 142 points within 148.23,98.15 164.77,102.17
GND on IN3 (solid shape): outline of 505 points within 162.48,96.43 203.54,104.15
GND on IN3 (solid shape): outline of 787 points within 196.98,106.15 211.52,143.15
GND on IN3 (solid shape): outline of 1232 points within 4.79,128.04 181.06,166.7
GND on IN3 (solid shape): outline of 1343 points within 96.68,89.85 222.87,152.9
GND on IN4 (solid shape): 70.23,119.62 70.23,116.79 70.14,116.71 69.94,116.71 69.89,116.76 69.89,119.64 69.92,119.67 70.18,119.67
GND on IN4 (solid shape): 70.23,115.68 70.23,112.84 70.16,112.78 69.94,112.78 69.89,112.83 69.89,115.7 69.95,115.76 70.15,115.76
GND on IN4 (solid shape): 72.13,115.71 72.13,112.8 72.09,112.77 71.85,112.77 71.79,112.82 71.79,115.66 71.9,115.76 72.08,115.76
GND on IN4 (solid shape): 72.14,119.61 72.14,116.74 72.11,116.71 71.86,116.71 71.79,116.78 71.79,119.63 71.84,119.67 72.07,119.67
GND on IN4 (solid shape): 198.23,139.92 197.47,139.15 195.39,139.15 194.35,138.12 194.32,138.12 194.19,138.25 194.19,141.29 194.79,141.89 198.23,141.89
GND on IN4 (solid shape): 37.19,63.25 37.19,51.79 36.88,51.48 35.11,51.48 34.8,51.79 34.8,63.19 35.02,63.42 37.02,63.42
GND on IN4 (solid shape): 84.86,116.8 84.86,116.68 84.81,116.63 82.17,116.63 81.99,116.45 81.81,116.45 81.76,116.5 81.76,116.68 81.97,116.88 84.78,116.88
GND on IN4 (solid shape): 40.89,66.6 40.89,33.05 39.45,31.6 35.03,31.6 34.19,32.43 34.19,33.31 38.02,37.14 38.02,37.28 38.2,37.47 38.2,66.83 38.41,67.03 40.47,67.03
GND on IN4 (solid shape): 94.54,119.55 94.06,119.07 92.28,119.07 92.05,118.84 91.95,118.84 91.87,118.91 91.87,119.01 92.2,119.34 93.88,119.34 94.36,119.83 94.54,119.83
GND on IN4 (solid shape): 191.44,96.39 191.44,95.49 191.18,95.22 178.58,95.22 178.47,95.34 178.47,95.51 179.41,96.45 184.32,96.45 184.35,96.47 184.46,96.47 184.98,96.99 190.84,96.99
GND on IN4 (solid shape): 55.83,129.84 55.83,128.55 55.71,128.43 52.25,128.43 52.15,128.54 52.15,128.81 52.14,128.82 52.14,129.37 52.31,129.54 52.31,129.86 52.43,129.97 55.69,129.97
GND on IN4 (solid shape): 194.49,121.53 194.49,116.5 194.14,116.16 194.14,115.6 189.11,110.56 187.15,110.56 186.92,110.8 186.92,111.83 187.55,112.46 187.55,112.81 187.32,113.04 186.72,113.04 186.49,112.81 185.63,112.81 185.14,113.3 185.14,123.21 185.85,123.92 192.1,123.92
GND on IN4 (solid shape): 182.73,129.32 182.73,127.44 182.67,127.37 182.67,127.02 182.92,126.77 183.13,126.77 183.35,126.55 183.35,126.54 183.4,126.47 183.47,126.42 183.48,126.42 184.24,125.65 184.24,124.53 183.87,124.16 183.32,124.16 179.53,127.95 179.53,129.21 180.03,129.71 182.35,129.71
GND on IN4 (solid shape): 67.18,119.12 67.18,117.29 66.7,116.8 66.7,116.67 66.31,116.28 66.31,115.57 66.21,115.47 63.87,115.47 63.83,115.51 63.83,115.94 63.87,115.98 65.65,115.98 65.84,116.17 65.84,116.86 65.91,116.93 66.27,116.93 66.34,117.01 66.34,117.46 66.42,117.54 66.83,117.54 66.88,117.59 66.88,119.12 66.93,119.17 67.13,119.17
GND on IN4 (solid shape): 98.13,108.78 98.7,108.78 99.61,107.87 102.73,107.87 103.67,106.93 107.36,106.93 107.5,106.79 107.5,106.01 107.62,105.9 109.32,105.9 109.47,105.74 109.47,105.32 109.27,105.11 98.97,105.11 98.28,104.42 96.26,104.42 96.1,104.58 96.1,105.32 96.44,105.66 96.44,106.27 96.34,106.37 95.02,106.37 94.88,106.5 94.88,108 95.27,108.38 95.27,108.93 95.43,109.08 96.6,109.08 96.68,109.17 97.73,109.17
GND on IN4 (solid shape): 65.3,119.75 65.3,119.34 65.38,119.27 66.12,119.27 66.26,119.13 66.26,118.26 66.19,118.2 65.89,118.2 65.84,118.25 65.84,118.73 65.79,118.79 64.8,118.79 64.76,118.75 64.76,116.61 64.72,116.58 64.6,116.58 64.59,116.56 64.48,116.56 64.41,116.63 64.41,117.71 64.35,117.77 63.97,117.77 63.91,117.83 63.91,118.02 63.98,118.1 64.25,118.1 64.3,118.15 64.3,119.32 64.72,119.32 64.78,119.38 64.78,119.74 64.87,119.83 65.23,119.83
GND on IN4 (solid shape): 53.52,110.39 53.73,110.24 53.95,110.39 56.39,110.39 56.39,109.59 56.05,109.26 56.05,108.01 56.05,108.01 56.05,106.71 55.86,106.53 55.85,106.53 55.72,106.39 53.13,106.39 53.12,106.42 53.06,106.5 52.97,106.55 52.9,106.6 52.9,106.68 52.86,106.93 52.62,106.99 52.53,107 52.48,107.09 52.48,109.97 52.9,110.39
GND on IN4 (solid shape): 132.24,117.41 132.24,112.14 132.71,111.67 132.71,109.08 132.17,108.54 130.9,108.54 130.53,108.17 130.35,108.17 130.3,108.22 130.3,110.35 131.4,110.35 131.4,109.36 131.4,109.33 131.4,109.27 131.42,109.21 131.44,109.16 131.47,109.11 131.51,109.06 131.55,109.02 131.6,108.98 131.65,108.95 131.71,108.93 131.76,108.91 131.82,108.91 131.88,108.91 131.94,108.91 132,108.93 132.06,108.95 132.11,108.98 132.16,109.02 132.2,109.06 132.23,109.11 132.26,109.16 132.29,109.21 132.3,109.27 132.31,109.33 132.31,109.36 132.31,110.35 132.31,110.38 132.3,110.44 132.29,110.5 132.26,110.56 132.23,110.61 132.2,110.65 132.16,110.7 132.11,110.73 132.06,110.76 132,110.79 131.94,110.8 131.88,110.81 131.82,110.81 131.76,110.8 131.71,110.79 131.65,110.76 131.6,110.73 131.55,110.7 131.51,110.65 131.47,110.61 131.44,110.56 131.42,110.5 131.4,110.44 131.4,110.38 131.4,110.35 130.3,110.35 130.3,117.22 130.58,117.5 132.16,117.5
GND on IN4 (solid shape): 201.1,102.71 201.1,96.81 200.43,96.14 199.5,96.14 199.42,96.17 199.4,96.25 199.39,96.35 199.34,96.43 199.33,96.47 199.34,96.5 199.16,96.93 198.96,96.51 198.97,96.48 198.96,96.45 198.9,96.36 198.89,96.25 198.86,96.17 198.79,96.14 193.76,96.14 193.07,96.83 193.07,97.35 193.23,97.51 197.68,97.51 199.94,99.77 199.94,102.7 200.08,102.83 200.97,102.83
GND on IN4 (solid shape): outline of 116 points within 45.77,127.55 57.38,139.82
GND on IN4 (solid shape): outline of 160 points within 29.09,108.82 30.99,111.5
GND on IN4 (solid shape): 54.74,103.34 54.78,103.34 54.96,103.31 55.11,103.4 55.19,103.44 55.47,103.3 55.75,103.44 56.03,103.3 56.31,103.44 56.39,103.4 56.6,103.3 56.8,103.41 56.88,103.45 56.96,103.42 57.16,103.33 57.35,103.43 57.43,103.46 57.51,103.43 57.64,103.34 57.8,103.35 57.89,103.33 57.94,103.25 57.94,102.28 57.61,101.95 57.61,100.93 56.41,99.74 53.16,99.74 52.96,99.94 52.96,100.32 52.5,100.78 52.5,102.92 52.48,102.94 52.48,103.22 52.52,103.3 52.61,103.31 52.76,103.32 52.88,103.4 52.96,103.44 53.04,103.4 53.25,103.3 53.45,103.41 53.52,103.46 53.6,103.43 53.7,103.33 53.89,103.33 54.03,103.46 54.03,103.47 54.1,103.55 54.53,103.55
GND on IN4 (solid shape): outline of 166 points within 199.54,133.87 206.32,142.46
GND on IN4 (solid shape): outline of 110 points within 69.46,121.48 75.54,123.39
GND on IN4 (solid shape): outline of 128 points within 0.2,0.2 87.78,90.51
GND on IN4 (solid shape): outline of 398 points within 50.61,94.99 59.05,97.94
GND on IN4 (solid shape): outline of 650 points within 210.21,109.14 218.25,139.58
GND on IN4 (solid shape): outline of 942 points within 139.97,107.28 171.51,128.94
GND on IN4 (solid shape): outline of 969 points within 10.42,117.39 19.56,141.27
GND on IN4 (solid shape): outline of 1325 points within 96.69,89.85 222.87,152.9
GND on IN4 (solid shape): outline of 2873 points within 4.82,124.17 180.59,166.7
GND on TOP: 199.97,113.21 199.32,113.86 199.32,115.8 193.74,121.37 193.74,126.64 194.27,127.17 204.26,127.17 204.28,127.14 204.28,124.52 204.28,124.51 204.28,121.72 205.39,120.6 205.39,120.59 206.59,120.59 208.84,118.33 209.98,118.33 210.16,118.15 210.16,117.3 209.79,116.92 209.79,115.84 208.38,115.84 208.38,115.1 209.79,115.1 209.79,113.92 209.08,113.21 208.22,113.21 207.89,113.39 207.57,113.21
GND on TOP: 56.44,112.97 56.44,113.07 56.57,113.2 57.71,113.2 57.89,113.02 57.89,112.42 57.84,112.37 56.57,112.37 56.38,112.18 55.8,112.18 55.73,112.26 55.73,112.64 55.8,112.72 56.18,112.72
GND on TOP: 38.46,138.11 38.52,138.16 38.52,138.97 38.64,139.09 40.31,139.09 40.37,139.04 40.37,137.35 40.3,137.28 37.57,137.28 37.48,137.36 37.48,138.02 37.57,138.11
GND on TOP: 173.74,104.85 175.55,104.85 175.58,104.88 176.49,104.88 176.59,104.78 176.59,104.16 176.52,104.09 175.69,104.09 175.46,103.86 175.46,103.14 175.41,103.09 173.75,103.09 173.71,103.14 173.71,104.82
GND on BOTTOM: 180.89,104.31 180.07,104.31 180.02,104.26 180.02,103.72 180.11,103.63 180.62,103.63 180.66,103.59 180.66,103.13 180.75,103.05 181.03,103.05 181.14,103.16 181.14,104.05
GND on BOTTOM: 48.24,108.54 47.85,108.54 47.68,108.37 47.68,106.71 47.92,106.47 48.18,106.47 48.36,106.64 48.36,108.42
GND on BOTTOM: 72.08,102.73 72.08,105.96 71.98,106.06 71.5,106.06 71.45,106.11 71.45,106.42 71.65,106.62 72.36,106.62 72.44,106.54 72.44,106.16 72.49,106.11 73.05,106.11 73.38,106.44 73.91,106.44 73.96,106.39 73.96,105.88 73.91,105.83 73.38,105.83 73.25,105.7 73.25,104.94 73.05,104.74 73.05,103.32 73.46,102.91 73.76,102.91 74.04,102.63 74.04,102.38 73.96,102.3 72.52,102.3
GND on VCC: 179.58,98.47 179.48,98.57 179.48,100.27 180.09,100.88 187.63,100.88 188.11,100.39 188.11,99.21 187.88,98.97 181.02,98.97 180.51,98.47
GND on VCC: 105.39,101.23 105.08,101.54 105.08,104.15 106.48,105.53 109.8,105.53 110.44,104.89 110.44,101.9 109.77,101.23
GND on VCC: 37.88,56.75 37.88,59.69 37.99,59.79 40.43,59.79 40.6,59.63 40.6,56.75
GND on VCC: outline of 127 points within 1.53,110.28 32.13,166.7
GND on VCC: 37.75,63.15 37.64,63.25 37.64,66.09 37.87,66.32 39.74,66.32 39.93,66.51 40.08,66.51 40.27,66.32 40.59,66.32 40.69,66.22 40.69,63.38 40.46,63.15
GND on VCC: 31.56,71.73 30.12,73.17 30.12,76.64 31.52,78.04 31.52,80.02 31.8,80.3 33.15,80.3 33.68,80.83 33.68,82.74 34.17,83.23 38.74,83.23 41.81,86.3 41.81,86.93 42.17,87.29 45.98,87.29 45.98,71.73
GND on VCC: 157.27,90.05 157.07,90.24 157.07,90.26 156.87,90.45 156.87,90.46 156.49,90.82 156.49,90.82 156.11,91.2 156.11,91.63 161.93,97.45 163.24,97.45 165.91,94.78 193.93,94.78 196.09,96.94 222.88,96.94 222.88,90.85 222.64,90.29 222.08,90.05 215.68,90.05 215.12,90.29 214.88,90.85 214.88,91.55 214.53,92.4 213.68,92.75 189.88,92.75 189.03,92.4 188.68,91.55 188.68,90.05 187.18,90.05 187.18,90.4 184.68,92.9 182.18,90.4 182.18,90.05
GND on VCC: 53.57,131.74 53.24,132.07 53.24,134.83 53.47,135.04 55.67,135.04 56.03,134.68 56.03,132.07 55.7,131.74
GND on VCC: outline of 93 points within 0.2,0.2 45.98,66.02 ; 2 cut-outs
GND on VCC: 122.75,112.68 122.39,113.04 122.39,115.49 122.49,115.6 128,115.6 128.1,115.49 128.1,113.04 127.75,112.68
GND on VCC: 122.62,101.01 122.19,101.44 122.19,106.35 122.55,106.71 128.05,106.71 128.41,106.35 128.41,101.35 128.06,101.01
GND on VCC: 90.14,126.56 89.69,127.01 89.69,131 89.92,131.23 101.14,131.23 103.28,129.09 103.28,127.55 102.28,126.56
GND on VCC: 214.89,112.12 213.55,113.45 205.68,113.45 205.38,113.75 205.38,116.71 205.62,116.94 213,116.94 213.17,117.11 213.41,117.11 213.58,116.94 215.95,116.94 216.81,116.08 216.81,112.35 216.58,112.12
GND on VCC: 216.13,119.57 214.57,121.14 213.05,121.14 210.51,123.67 210.51,134.57 210.44,134.71 209.65,135.5 206.98,135.5 205.51,134.03 199.49,134.03 197.81,132.32 166.87,132.32 166.52,131.97 166.52,130.29 164.65,130.29 160.51,134.43 136.55,134.46 136.54,134.47 133.11,134.47 132.87,134.71 133.43,135.4 133.81,136.21 134.01,136.85 134.06,137 134.44,137.38 134.49,137.4 134.54,137.4 134.59,137.4 134.72,137.43 134.82,137.45 134.92,137.51 135.03,137.58 135.15,137.78 135.2,137.99 135.18,138.12 135.15,138.22 135.08,138.34 135.03,138.4 173.08,138.4 173.08,136.6 175.58,134.1 178.08,136.6 178.08,138.4 181.11,138.4 181.96,138.75 182.31,139.6 182.31,145.07 182.35,145.42 182.51,145.97 182.53,146.2 182.53,152.1 182.77,152.66 183.33,152.9 222.08,152.9 222.64,152.66 222.88,152.1 222.88,119.92 222.53,119.57
GND on VCC: 134.96,123.99 134.96,126.64 134.38,127.22 132.76,127.22 131.95,126.41 130.11,126.41 130,126.52 130,127.56 130.11,127.68 131.58,127.68 133.8,129.9 136.7,129.9 138.65,127.95 138.65,124.75 137.89,123.99
GND on VCC: 24.77,72.81 24.66,72.92 24.66,77.3 25,77.64 25.12,77.64 25.14,77.61 25.73,77.61 26.06,77.28 26.06,72.81
GND on VCC: 114.11,125.14 113.41,125.84 113.41,130.95 113.63,131.17 115.02,131.17 116.31,129.89 118.64,129.89 119.13,129.4 119.13,126.82 117.45,125.14
GND on GND1: outline of 263 points within 0.2,0.2 222.88,166.7 ; 8 cut-outs
GND on IN1: 139.42,114.85 138.7,115.57 135.61,115.57 134.9,116.28 134.9,117.65 137.43,120.18 141.08,120.18 142.36,121.46 148.35,121.46 149.26,120.55 159.68,120.55 160.68,119.55 160.68,117.87 159.91,117.09 151.75,117.09 151.14,116.48 147.29,116.48 146.73,117.04 145.24,117.04 144.52,116.32 144.52,115.48 143.89,114.85
GND on IN2: 200.6,106.36 198.23,103.99 184.75,103.99 184.1,103.34 180.11,103.34 179.83,103.62 179.83,103.7 182.13,103.7 182.73,104.3 197.99,104.3 201.21,107.52 201.21,107.83 200,107.83 197.49,105.33 194.92,105.33 194.92,105.37 194.62,105.64 194.31,105.37 194.31,105.33 182.3,105.33 181.7,104.73 180.04,104.73 179.94,104.79 179.97,104.9 181.75,106.68 198.16,106.68 199.04,107.56 199.06,107.56 199.31,107.72 199.3,108.02 199.28,108.05 199.28,112.15 206.25,119.13 206.25,126.86 206.58,127.19 206.86,127.19 208.45,125.6 208.45,120.76 208.14,120.45 208.14,108.41 205.49,105.76 203.94,105.76 203.34,106.36 ; 2 cut-outs
GND on IN2: outline of 148 points within 119.92,106.19 187.86,123.48
GND on IN2: 190.38,111.12 186.65,114.86 177.9,114.86 177.84,114.8 175.23,114.8 175.22,114.83 175,115.02 174.72,114.95 174.65,114.92 174.58,114.95 173.67,115.85 173.67,116.33 174.46,117.12 177.57,117.12 178.08,117.35 177.57,117.58 174.02,117.58 172.61,118.99 172.61,122.35 173.99,123.74 185.01,123.74 186.61,125.34 193.85,125.34 195.48,126.96 204.9,126.96 205.92,125.95 205.92,119.61 197.44,111.12
GND on IN2: outline of 763 points within 0.2,0.21 222.87,152.9 ; 12 cut-outs
GND on GND2: outline of 268 points within 0.2,0.2 222.88,166.7 ; 9 cut-outs
GND on IN3: 193.17,100.85 197.32,100.85 198.46,101.99 201.35,101.99 201.97,102.61 205.1,102.61 205.84,102.61 207.23,104 207.23,104.65 207.5,104.92 208.68,104.92 209.02,104.59 209.02,102.67 204.94,98.59 198.42,98.59 196.61,96.78 189.51,96.78 189.51,96.78 176.12,96.78 173.92,94.58 134.75,94.58 131.14,98.19 115.16,98.19 114.38,97.41 114.33,97.41 114.28,97.45 114.28,97.49 115.27,98.48 134.4,98.48 138,94.88 174.03,94.88 176.25,97.1 189.41,97.1 ; 1 cut-out
GND on IN3: outline of 934 points within 0.2,0.2 48.93,142.66 ; 14 cut-outs
GND on IN3: 152.76,108.17 152.22,108.7 152.22,109.92 151.59,110.56 148.69,110.56 147.52,111.72 147.52,112.36 149.68,114.52 159.69,114.52 160.07,114.14 160.07,111.52 159.77,111.22 159.77,110.25 160.25,109.77 160.68,109.77 161.21,110.3 161.21,110.66 162.13,111.57 162.13,115.03 160.2,116.96 159,116.96 158.55,116.5 145.24,116.5 144.53,115.79 144.53,115.46 143.48,114.42 143.13,114.42 142.44,113.73 139.04,113.73 138.18,114.59 137.82,114.59 135.89,116.53 134.11,116.53 133.4,117.24 133.4,119.27 133.88,119.75 136.07,119.75 137.69,121.38 139.88,121.38 140.21,121.05 140.21,119.42 139.85,119.07 139.85,115.26 140.31,114.8 142.29,114.8 142.75,115.26 142.75,116.65 145.21,119.12 145.21,120.23 145.01,120.44 145.01,120.94 145.19,121.12 145.19,122.8 145.36,122.98 155.45,122.98 157.86,120.56 161.34,120.56 161.65,120.87 165.86,120.87 167.97,118.76 167.97,115.92 160.22,108.17
GND on IN3: 190.6,123.99 192.58,125.97 194.74,125.97 195.45,125.26 195.45,117.59 186.54,108.68 182.83,108.68 182.24,109.26 182.24,110.38 182.3,110.56 182.25,110.73 182.24,110.75 182.24,110.81 182.12,110.94 181.89,110.94 181.64,110.68 181.64,108.83 181.43,108.63 180.76,108.63 180.62,108.68 180.48,108.65 180.47,108.65 179.3,108.65 177.16,110.78 170.99,110.78 170.69,111.09 170.69,112.18 170.92,112.41 171.63,112.41 173.71,114.49 173.71,115.51 173.94,115.74 174.83,115.74 175.08,115.99 175.08,116.91 173.58,118.41 173.58,122.21 174.4,123.03 179.15,123.03 179.16,123.04 180.75,123.04 183.48,125.77 184.12,125.77 184.94,124.95 184.97,124.85 184.88,124.78 184.7,124.26 185.22,124.44 185.28,124.53 185.39,124.51 185.9,123.99
GND on IN3: 121.98,101.95 121.49,102.43 121.47,102.43 121.31,102.59 121.31,104.63 122.13,105.45 128.71,105.45 129.45,106.19 131.05,106.19 131.08,106.19 131.74,106.86 131.91,106.86 131.96,106.8 131.96,105.05 130.23,103.32 128.85,103.32 128.66,103.13 128.66,102.51 128.98,102.2 128.98,101.95
GND on IN3: 118.04,102.77 119.79,101.01 120.86,101.01 122.03,99.84 122.13,99.84 122.13,99.54 115.44,99.54 114.13,100.84 113.23,100.84 112.83,101.25 111.58,101.25 111.43,101.4 111.43,101.76 112.44,102.77 ; 1 cut-out
GND on IN3: 44.84,109.93 44.73,109.91 44.67,110 44.67,118.47 45.22,119.02 45.33,119.04 45.39,118.95 45.39,118.86 45.49,118.76 45.51,118.73 45.5,118.54 45.58,118.4 45.6,118.33 45.58,118.26 45.52,118.02 45.67,117.81 45.71,117.76 45.71,117.69 45.98,117.29 46.3,117.65 46.3,117.67 46.3,117.69 46.82,118.21 47.09,118.21 47.17,118.17 47.19,118.1 47.2,118.04 47.21,117.99 47.21,117.96 47.2,117.94 47.17,117.88 47.14,117.81 47.12,117.77 47.09,117.77 46.81,117.61 46.9,117.31 46.91,117.29 46.92,117.26 46.92,117.16 46.94,117.07 46.95,117 46.91,116.94 46.86,116.89 46.82,116.83 46.77,116.78 46.69,116.78 46.39,116.59 46.64,116.34 46.72,116.3 46.75,116.22 46.75,116.13 46.79,116.06 46.79,115.95 46.7,115.9 46.37,115.9 45.82,115.35 45.82,114.02 45.75,113.95 45.72,113.94 45.68,113.95 45.67,113.96 45.66,113.98 45.67,114.04 45.67,114.32 45.44,114.54 45.21,114.32 45.21,114.22 45.2,114.19 45.18,114.19 45.06,113.73 45.53,113.7 45.64,113.72 45.71,113.63 45.71,112.53 44.91,111.72 44.91,109.99
GND on GND3: outline of 272 points within 0.2,0.2 222.88,166.7 ; 9 cut-outs
GND on IN4: 182.84,110.23 181.61,109 181.61,108.64 181.37,108.4 180.35,108.4 179.61,107.66 175,107.66 171.46,111.2 171.46,112.36 171.17,112.65 171.17,115.29 171.65,115.77 171.65,117.26 171.79,117.4 172.09,117.4 172.56,116.93 173.48,116.93 173.96,116.45 173.96,115.97 174.1,115.84 174.74,115.84 174.87,115.97 174.87,116.06 174.86,116.07 174.86,116.35 174.96,116.45 174.96,117.74 174.54,118.16 174.54,118.95 174.21,119.28 173.87,119.28 173.77,119.39 173.77,120.78 173.54,121 173.23,121 172.54,121.69 172.54,124.34 173.33,125.13 177.56,125.13 177.69,125.25 177.69,126.61 177.36,126.93 175.74,126.93 175.57,127.11 175.57,127.5 176.71,128.65 178.15,128.65 183.8,122.99 183.8,110.29 183.75,110.23
GND on IN4: 133.95,129.58 139.53,129.58 139.79,129.33 139.79,128.88 139.6,128.69 133.88,128.69 133.76,128.82 133.76,129.39
GND on IN4: 35.46,107.05 35.15,107.36 35.15,108.88 35.43,109.16 41.38,109.16 41.43,109.11 41.43,108.96 41.3,108.83 41.17,108.83 41.05,108.96 41.04,108.96 40.89,109.01 40.75,108.96 40.67,108.96 40.59,108.88 40.59,108.86 39.87,108.86 39.87,108.28 40.6,108.28 40.67,108.22 40.67,108.12 40.59,108.04 40.31,108.04 40.16,107.89 40.16,107.41 40.28,107.28 40.28,107.18 40.16,107.05
GND on IN4: outline of 197 points within 0.2,41.47 38.2,144.06
GND on IN4: 16.89,37.91 21.13,42.15 21.14,42.16 21.24,42.22 21.3,42.31 21.3,42.32 26.85,47.87 26.85,62.33 26.49,62.69 26.49,76.8 26.57,76.88 29.71,76.88 29.97,76.61 29.97,69.54 30.94,68.57 31.57,68.57 32.33,69.33 32.33,79.84 32.08,80.09 29.08,80.09 28.73,80.45 28.73,80.81 32.92,85 37.11,85 38.2,83.91 38.2,77.56 34.16,73.52 34.16,51.12 34.31,50.97 34.31,50.71 36.22,48.8 36.22,37.02 32,32.81 32,31.45 30.82,30.27 24.22,30.27 21.62,27.66 17.36,27.66 16.89,28.13
GND_SIGNAL on TOP (solid shape): 119.66,102.66 120.68,102.66 120.7,102.63 121.11,102.63 121.28,102.45 121.28,100.65 120.8,100.17 113.84,100.17 113.49,100.52 113.49,101.03 113.64,101.18 114.2,101.18 114.22,101.16 118.19,101.16 118.41,101.39 118.41,102.89 118.26,103.04 116.23,103.04 116.1,103.16 116.1,104.05 116.23,104.18 118.14,104.18
GND_SIGNAL on BOTTOM (solid shape): 128.69,106.5 128.69,105.79 128.63,105.73 128.63,105.13 128.58,105.08 127.29,105.08 126.75,105.63 126.75,106.21 127.15,106.61 128.58,106.61
GND_SIGNAL on BOTTOM (solid shape): 129.8,114.79 129.8,114.19 129.42,113.81 126.82,113.81 126.52,113.5 126.52,113.15 126.21,112.84 125.53,112.84 125.45,112.92 125.45,114.39 125.63,114.57 126.49,114.57 126.87,114.95 129.64,114.95
GND_SIGNAL on IN4 (solid shape): 122.78,102.84 122.78,102.4 122.61,102.22 121.13,102.22 120.92,102.44 120.92,102.94 120.99,103.01 121.75,103.01 121.76,103.02 122.61,103.02
GND_SIGNAL on IN4 (solid shape): outline of 106 points within 125.45,105.55 128.09,113.17
GNDA_CHG on TOP (solid shape): 141.66,111.75 141.66,109.24 141.6,109.08 141.66,108.93 141.66,108.32 140.46,108.32 140.31,108.47 140.31,111.33 140.75,111.78 141.63,111.78
GNDA_CHG on IN3 (solid shape): 141.6,111.67 141.6,111.22 141.4,111.01 140.51,111.01 140.23,111.29 140.23,111.72 140.33,111.83 141.45,111.83
GNDA_CHG on GND3 (solid shape): 141.6,111.67 141.6,111.08 141.51,110.99 140.42,110.99 140.23,111.17 140.23,111.72 140.33,111.83 141.45,111.83
GNDA_CHG on IN4 (solid shape): outline of 419 points within 136.26,108.44 147.32,115.15
VCC_D3.D6 on IN4 (solid shape): outline of 124 points within 112.56,118.53 113.16,121.55
VIN_0.85VS_VCCPIO on TOP (solid shape): 38.38,141.55 38.38,141.14 38.53,140.99 39.57,140.99 39.9,140.66 39.9,139.39 39.8,139.28 36.58,139.28 36.45,139.16 33.96,139.16 33.81,139.31 33.81,141.37 34.24,141.8 38.13,141.8
VIN_0.95V_PRIM on TOP (solid shape): 176.01,102.42 178.96,102.42 179.04,102.33 179.04,101.18 178.92,101.06 178.02,101.06 178.02,101.06 177.94,101.06 177.53,100.65 174.83,100.65 174.73,100.75 174.73,101.36 174.12,101.97 174.12,102.73 174.29,102.91 175.51,102.91
+AC_DOCK_IN on BOTTOM (solid shape): 196.19,106.11 196.19,104.26 196.01,104.08 194.28,104.08 194.23,104.13 194.23,105.6 194.84,106.21 196.09,106.21
+AC_DOCK_IN on BOTTOM (solid shape): 141.3,99.46 141.3,98.24 141.03,97.97 140.66,97.97 140.6,98.03 140.6,98.97 140.33,99.24 140.33,99.48 140.39,99.53 141.22,99.53
+AMP_AVDD1 on TOP (solid shape): 41.12,81.65 41.12,81.24 41.17,81.19 41.78,81.19 42.04,81.45 42.7,81.45 42.75,81.4 42.75,80.53 42.7,80.48 40.94,80.48 40.64,80.79 38.84,80.79 38.76,80.86 38.76,81.32 38.84,81.4 40.44,81.4 40.72,81.68 41.1,81.68
+AMP_AVDD1 on IN1 (solid shape): 42.52,85.89 42.52,83.74 43.37,82.89 43.37,81.32 42.43,80.38 42.16,80.38 42.06,80.48 42.06,81.3 42.65,81.88 42.65,82.67 42.46,82.85 41.71,82.85 41.48,83.08 41.48,85.92 41.63,86.07 42.34,86.07
+BAT_DOCK on BOTTOM (solid shape): 140.12,100.7 140.12,99.14 140.42,98.83 140.42,94.08 140.84,93.67 140.84,91.79 140.79,91.73 137.45,91.73 136.63,92.56 136.63,98.99 136.63,98.99 136.63,99.75 138.05,101.17 139.65,101.17
+BAT_DOCK on BOTTOM (solid shape): 156.69,99.66 156.69,95.65 152.78,91.73 148.72,91.73 148.41,92.04 148.41,93.61 149.68,94.88 149.68,99.33 150.24,99.89 156.47,99.89
+BAT_DOCK on BOTTOM (solid shape): 150.16,110.91 150.16,107.97 149.99,107.79 148.46,107.79 148.36,107.69 148.36,106.97 148.26,106.87 147.57,106.87 147.42,107.03 147.42,110.31 147.8,110.7 147.94,110.7 148.49,111.24 149.83,111.24
+BAT_DOCK on GND1 (solid shape): 155.45,109.57 155.45,108.42 155.24,108.22 154.51,108.22 154.43,108.3 154.43,109.46 154.63,109.67 155.35,109.67
+BAT_DOCK on GND1 (solid shape): 157.28,99.61 157.28,98.77 157.1,98.59 155.02,98.59 154.71,98.9 154.71,99.74 155.02,100.04 156.84,100.04
+BAT_DOCK on GND1 (solid shape): 151.64,109.24 151.64,108.75 151.16,108.27 149.96,108.27 149.43,108.81 149.43,110.21 149.51,110.29 150.59,110.29
+BAT_DOCK on IN1 (solid shape): 157.28,99.66 157.28,98.69 157.17,98.59 154.94,98.59 154.76,98.77 154.76,99.84 154.94,100.02 156.92,100.02
+BAT_DOCK on IN1 (solid shape): 158.57,110.58 158.57,108.47 158.56,108.46 158.56,107.7 158.32,107.46 149.75,107.46 149.21,108 149.21,110.54 149.55,110.89 158.27,110.89
+BAT_DOCK on IN3 (solid shape): 151.82,109.74 151.82,108.4 151.59,108.17 149.2,108.17 148.92,108.45 148.92,109.84 149.15,110.07 151.49,110.07
+BAT_DOCK on IN3 (solid shape): 157.06,99.64 157.06,98.89 156.79,98.62 154,98.62 153.8,98.82 153.8,99.47 154.28,99.95 156.75,99.95
+BAT_DOCK on GND3 (solid shape): 151.82,110 151.82,108.4 151.59,108.17 149.2,108.17 148.92,108.45 148.92,109.9 149.24,110.21 151.6,110.21
+BAT_DOCK on GND3 (solid shape): 157.14,99.74 157.14,98.64 157.02,98.52 154.15,98.52 154.08,98.59 154.08,99.68 154.28,99.88 157,99.88
+BAT_DOCK on TOP: 154.46,98.59 153.88,99.18 153.88,109.32 154.43,109.87 157.73,109.87 159.49,108.12 159.49,99.63 158.44,98.59
+BAT_DOCK on VCC: 149.3,107.74 148.87,108.17 148.87,112.25 149.3,112.69 158.92,112.69 159.41,112.2 159.41,108.22 158.92,107.74
+BAT_TABLET on TOP (solid shape): 152.6,115.94 152.6,112.06 152,111.46 148.92,111.46 148.81,111.57 148.81,112.7 148.95,112.84 151.21,112.84 151.56,113.2 151.56,115.92 151.64,115.99 152.55,115.99
+BAT_TABLET on BOTTOM (solid shape): 164.66,109.88 166.49,109.88 166.67,109.7 166.67,107.48 166.29,107.1 164.44,107.1 163.98,106.64 163.98,105.73 163.83,105.58 162.1,105.58 161.95,105.73 161.95,107.28 161.11,108.12 161.11,110.66 161.42,110.96 163.58,110.96
+BAT_TABLET on IN1 (solid shape): 167.39,111.5 167.39,108.17 167.16,107.94 165.76,107.94 165.56,108.14 165.56,110.4 160.71,115.26 151.84,115.26 151.64,115.46 151.64,116.55 151.99,116.91 161.98,116.91
+BAT_TABLET on IN3 (solid shape): 167.06,109.03 167.06,107.99 166.93,107.86 166.12,107.86 166.04,107.94 166.04,108.96 166.22,109.13 166.95,109.13
+BATT on BOTTOM (solid shape): 163.22,103.27 163.22,102.63 162.71,102.13 162.71,100.15 162.48,99.92 159.56,99.92 159.31,100.17 159.31,102.79 159.97,103.45 163.04,103.45
+BATT on BOTTOM (solid shape): 166.6,106.7 166.6,105.37 166.14,104.92 166.14,104.69 166.09,104.64 159.26,104.64 159.16,104.74 159.16,106.14 159.23,106.21 159.87,106.21 160.38,106.72 161.44,106.72 161.54,106.62 161.54,105.4 161.92,105.4 161.95,105.37 164.08,105.37 164.19,105.48 164.19,106.47 164.52,106.8 166.5,106.8
+BATT on IN4 (solid shape): 166.47,104.57 166.47,103.79 165.59,102.91 159.41,102.91 159.15,103.17 159.15,104.69 159.44,104.98 166.06,104.98
+CHG_VIN on TOP (solid shape): 44.5,31.5 44.5,29.33 44.5,29.33 44.5,28.77 44.45,28.72 42.67,28.72 42.33,29.06 42.33,31.19 42.77,31.62 44.38,31.62
+CHG_VIN on TOP (solid shape): 162.78,111.58 162.78,99.68 162.24,99.15 159.94,99.15 159.64,99.46 159.64,108.47 156.16,111.95 154.89,111.95 154.38,112.46 154.38,115.15 154.63,115.41 158.95,115.41
+CHG_VIN on BOTTOM (solid shape): 44.7,31.41 44.7,18.53 44.12,17.95 41.68,17.95 41.2,18.43 41.2,30.98 41.96,31.74 44.37,31.74
+CHG_VIN on BOTTOM (solid shape): 144.45,110.59 144.45,110.28 144.27,110.1 143.97,110.1 143.79,109.92 143.79,109.08 143.99,108.88 144.58,108.88 144.65,108.8 144.65,108.12 144.83,107.94 145.26,107.94 145.36,107.84 145.36,107.41 145.31,107.36 144.12,107.36 143.97,107.51 143.97,108.52 143.79,108.7 143.26,108.7 143.18,108.78 143.18,110.04 143.87,110.73 144.31,110.73
+CHG_VIN on BOTTOM (solid shape): 133.83,114.01 134.16,113.68 134.49,114.01 134.49,115.53 135.58,115.53 135.71,115.41 135.71,111.85 135.36,111.5 133.2,111.5 133.02,111.67 133.02,115.31 133.25,115.53 133.83,115.53
+CHG_VIN on GND1 (solid shape): 44.63,89.3 44.63,88.25 44.48,88.1 43.15,88.1 42.95,88.31 42.95,89.3 43.28,89.63 44.3,89.63
+CHG_VIN on GND1 (solid shape): 135.84,113.02 135.84,111.83 135.48,111.47 135.18,111.47 134.98,111.67 134.98,112.74 135.46,113.22 135.64,113.22
+CHG_VIN on IN1 (solid shape): outline of 195 points within 134.9,110.35 158.67,115.28
+CHG_VIN on IN3 (solid shape): 44.66,89.43 44.66,88.07 44.6,88.01 43,88.01 42.89,88.12 42.89,89.47 43,89.58 44.51,89.58
+CHG_VIN on IN3 (solid shape): 135.81,113.1 135.81,111.8 135.5,111.48 134.3,111.48 134.24,111.55 134.24,113.07 134.44,113.27 135.64,113.27
+CHG_VIN on IN3 (solid shape): 144.71,111.11 144.71,110.81 144.09,110.19 143.67,110.19 143.56,110.3 143.56,110.75 143.58,110.77 143.68,110.92 143.64,111.1 143.63,111.13 143.65,111.16 143.73,111.25 144.57,111.25
+CHG_VIN on GND3 (solid shape): 135.81,113.54 135.81,111.8 135.5,111.48 134.3,111.48 134.24,111.55 134.24,113.34 134.6,113.7 135.66,113.7
+CHG_VIN on IN4 (solid shape): 44.58,33.42 44.58,29.05 44.2,28.67 42.16,28.67 41.55,29.28 41.55,33.75 42.16,34.36 43.64,34.36
+CHG_VIN on IN4 (solid shape): 44.62,89.2 44.62,87.86 44.91,87.57 44.91,86.91 44.72,86.74 44.65,86.49 44.65,85.5 44.72,85.26 44.91,85.09 44.91,84.17 43.89,83.15 41.94,83.15 41.55,83.53 41.55,87.26 41.57,87.28 41.57,88.57 42.29,89.29 44.53,89.29
+CHG_VIN on VCC: 42.04,87.8 41.81,88.03 41.81,90.61 43.95,92.75 84.2,92.75 87.25,95.8 97.2,95.8 99.87,93.13 152.53,93.13 159.13,99.74 161.46,99.74 162.33,98.87 162.33,98.57 154.78,91.02 97.65,91.02 97.65,92.09 97.63,92.11 97.16,93.03 96.24,93.5 96.22,93.52 88.24,93.52 88.22,93.5 87.21,92.93 86.81,91.85 86.81,91.79 86.82,91.73 86.82,89.77 86.77,89.71 47.26,89.71 47.22,89.75 47.14,89.75 47.1,89.71 46.95,89.71 46.94,89.7 45.87,89.27 45.18,88.35 45.14,88.07 45.24,87.8
+DCIN on BOTTOM (solid shape): 145.47,115.39 145.47,114.52 145.31,114.37 143.81,114.37 142.98,115.2 142.87,115.2 142.85,115.18 142.85,114.42 142.8,114.37 142.72,114.37 142.65,114.44 142.65,115.38 142.85,115.59 143.87,115.59 143.88,115.6 145.26,115.6
+DCIN on GND1 (solid shape): 146.1,115.87 146.1,115.35 145.69,114.95 145.44,114.95 145.29,115.1 145.29,115.36 144.7,115.94 144.7,116.11 145.04,116.44 145.53,116.44
+DCIN on IN1 (solid shape): 146.11,116.3 146.11,115.43 145.68,115 144.86,115 144.7,115.17 144.7,116.3 144.79,116.4 146.01,116.4
+DCIN on IN3 (solid shape): 146.02,115.79 146.02,115.15 145.39,114.52 144.88,114.52 144.78,114.62 144.78,115.23 145.14,115.59 145.14,115.79 145.26,115.92 145.9,115.92
+DCIN on GND3 (solid shape): 146.1,115.81 146.1,115.38 146.08,115.32 146.07,115.26 146.07,115.2 145.39,114.52 144.88,114.52 144.78,114.62 144.78,115.29 145.4,115.92 145.99,115.92
+INV_PWR_SRC on BOTTOM (solid shape): 118.08,106.67 118.08,105.3 117.88,105.1 116.03,105.1 115.9,105.22 115.9,106.11 116,106.21 116.64,106.21 117.22,106.8 117.96,106.8
+INV_PWR_SRC on BOTTOM (solid shape): 123.34,113.83 123.34,113.2 123.22,113.07 122.96,113.07 122.45,112.56 122.45,111.93 122.05,111.52 120.7,111.52 120.5,111.72 120.5,112.61 120.9,113.02 120.93,113.02 121.11,113.2 121.95,113.2 122.71,113.96 123.22,113.96
+INV_PWR_SRC on IN4 (solid shape): outline of 91 points within 116.99,105.64 121.75,112.44
+LCDVDD on TOP (solid shape): 106.07,102.4 106.07,101.51 106.32,101.26 108.23,101.26 108.51,100.98 108.51,100.4 108.23,100.12 105.82,100.12 105.18,100.75 105.18,100.88 105.02,101.04 103.94,101.04 103.53,100.62 103.15,100.62 103.09,100.69 103.09,102.42 103.33,102.66 105.82,102.66
+LCDVDD on BOTTOM (solid shape): 108.48,98.95 108.48,96.58 108.8,96.26 108.8,94.53 108.71,94.44 107.4,94.44 107.27,94.56 107.27,96.87 107.29,96.88 107.56,97.15 107.56,97.97 107.17,98.36 107.17,99.04 107.31,99.19 108.25,99.19
+LCDVDD on BOTTOM (solid shape): 176.7,106.18 176.7,105.74 176.52,105.56 176.52,104.37 176.46,104.31 175.84,104.31 175.69,104.47 175.69,104.77 175.33,105.13 172.92,105.13 172.67,104.89 172.25,104.89 172.1,104.74 172.1,104.43 171.92,104.25 171.92,101.61 171.72,101.41 168.66,101.41 168.57,101.5 168.57,102.07 168.67,102.17 170.67,102.17 170.78,102.28 170.78,103.93 171.61,104.76 171.61,106.04 171.82,106.24 175.14,106.24 175.39,106.49 176.39,106.49
+LCDVDD on GND1 (solid shape): 108.43,100.53 108.43,99.9 108.24,99.71 106.91,99.71 106.73,99.89 106.73,100.52 106.79,100.58 108.37,100.58
+LCDVDD on GND3 (solid shape): 108.41,100.04 108.41,99.03 108.6,98.84 108.6,98.45 108.22,98.07 107.18,98.07 106.99,98.26 106.99,99.57 106.81,99.76 106.81,100.19 106.88,100.27 108.18,100.27
+LCDVDD on IN4 (solid shape): 169.23,101.67 169.23,100.81 168.76,100.34 168.01,100.34 167.9,100.45 167.9,101.34 168.36,101.79 169.11,101.79
+LCDVDD on IN4: 107.23,97.89 107.23,98.43 107.17,98.49 107.17,98.62 107.34,98.79 108.34,98.79 108.44,98.69 109.44,98.69 109.61,98.52 109.61,97.88 109.31,97.57 107.55,97.57
+LED_AN on TOP (solid shape): 115.47,103.24 115.47,102.66 115.34,102.53 115.21,102.53 114.96,102.28 113.82,102.28 113.52,102.58 113.52,103.18 113.7,103.37 115.34,103.37
+LED_AN on BOTTOM (solid shape): 124.51,108.22 124.51,106.54 124.79,106.26 125.91,106.26 125.91,105.25 125.84,105.18 121.78,105.18 121.72,105.25 121.72,108.42 121.79,108.5 124.23,108.5
+LED_AN on BOTTOM (solid shape): 122.66,103.37 122.66,102.68 122.5,102.53 112.24,102.53 112.16,102.61 104.32,102.61 103.45,101.74 103.43,101.74 102.57,100.89 102.59,100.87 102.59,95.64 102.8,95.43 102.8,94.52 102.7,94.42 101.97,94.42 101.86,94.53 101.86,95.4 101.6,95.65 101.6,97.27 101.53,97.35 101.53,101.49 103.48,103.44 122.58,103.44
+LED_AN on GND1 (solid shape): 114.33,102.66 114.33,102.38 114.21,102.26 113.55,102.26 112.98,101.69 112.52,101.69 112.32,101.89 112.32,102.15 112.95,102.78 114.2,102.78
+LED_AN on GND3 (solid shape): 113.17,102.66 113.17,101.92 113.02,101.77 112.22,101.77 112.04,101.95 112.04,102.71 112.14,102.81 113.02,102.81
+LED_AN on IN4 (solid shape): 122.66,106.21 122.66,103.48 122.33,103.16 121.71,103.16 121.6,103.27 121.6,103.56 121.67,103.62 121.67,106.16 121.81,106.31 122.56,106.31
+PWR_SRC_AC on BOTTOM (solid shape): 141.91,122.39 141.91,121.17 142.14,120.94 144.88,120.94 144.91,120.92 144.91,120.34 144.88,120.31 144.42,120.31 144.22,120.11 144.22,119.36 144.42,119.16 144.42,118.46 144.35,118.38 142.47,118.38 142.34,118.51 142.34,119.12 142.19,119.27 141.71,119.27 141.55,119.42 136.3,119.42 135.86,118.99 134.98,118.99 134.75,119.22 134.75,120.77 134.52,121 134.52,122.42 134.65,122.54 141.76,122.54
+RTCVCC on TOP (solid shape): 193.47,144.93 193.47,139.51 193.78,139.21 194.44,139.21 194.49,139.16 194.49,138.69 194.45,138.65 193.37,138.65 192.86,139.16 192.86,144.87 192.94,144.95 193.44,144.95
+RTCVCC on IN1 (solid shape): 194.16,145.25 194.16,144.45 194.1,144.39 193.08,144.39 192.99,144.49 192.99,145.32 193.12,145.45 193.96,145.45
+RTCVCC on IN3 (solid shape): 103.97,138.06 103.97,137.55 103.91,137.49 103.43,137.49 102.92,138 102.92,138.39 103.07,138.54 103.49,138.54
+RTCVCC on IN3 (solid shape): 46.21,131.16 46.21,130.86 45.59,130.24 45.31,130.24 45.03,130.52 45.03,130.93 45.57,131.46 45.91,131.46
+RTCVCC on IN3 (solid shape): 44.68,128.41 45.08,128.41 45.24,128.26 45.24,127.78 45.16,127.7 44.68,127.7 44.14,128.23 44.14,128.49 44.3,128.64 44.45,128.64
+RTCVCC on GND3 (solid shape): 103.97,138.06 103.97,137.55 103.91,137.49 103.19,137.49 102.74,137.94 102.74,138.44 102.83,138.54 103.49,138.54
+RTCVCC on IN4 (solid shape): 45.7,131.15 45.7,130.3 45.59,130.19 45.59,127.91 45.36,127.68 44.58,127.68 44.5,127.75 44.5,129.35 44.68,129.53 44.68,130.73 45.28,131.34 45.51,131.34
+RTCVCC on TOP: 56.12,125.86 55.94,126.04 55.94,126.7 55.7,126.94 55.7,127.51 56.13,127.94 56.6,127.94 56.73,127.82 56.73,125.5 56.58,125.35 56.16,125.35 56.12,125.39
+RTCVCC on IN1: 86.51,138.92 86.58,138.85 86.58,138.53 86.39,138.34 85.5,138.34 85.24,138.09 84.92,138.09 84.86,138.15 84.86,138.66 84.99,138.79 85.5,138.79 85.62,138.92
+RTCVCC_EC on TOP (solid shape): 195.43,138.27 195.43,137.83 195.17,137.57 195.17,136.96 195.01,136.79 194.64,136.79 193.85,137.58 193.85,138.27 193.9,138.32 195.38,138.32
+RTCVCC_EC on IN4 (solid shape): 198.35,138.98 198.35,138.48 197.77,137.9 197.07,137.9 196.27,137.1 194.23,137.1 194.16,137.18 194.16,137.48 194.26,137.58 195.73,137.58 196.69,138.54 197.57,138.54 198.06,139.04 198.29,139.04
+SIM_PWR on BOTTOM (solid shape): 212.49,139.33 212.49,138.93 212.18,138.93 211.81,139.31 209.79,139.31 209.71,139.39 209.71,139.54 209.76,139.6 211.45,139.6 211.6,139.75 212.07,139.75
+SIM_PWR on BOTTOM: 214.88,113.02 215.12,113.02 215.69,112.45 215.69,111.81 216.91,110.59 218.12,110.59 218.17,110.54 218.17,110.47 218.1,110.39 217.93,110.39 217.9,110.36 216.27,110.36 214.88,111.74
+SYS_DOCK on BOTTOM (solid shape): 158.32,114.72 158.32,107.94 157.86,107.48 152.76,107.48 152.5,107.74 152.5,110.53 152.86,110.89 153.98,110.89 154.26,111.17 155.24,111.17 155.68,111.6 155.68,114.65 155.9,114.87 158.17,114.87
+V_DDR_0_DQ_VREF on TOP (solid shape): 87.88,129.52 87.88,128.08 86.91,127.11 86.79,127.11 86.59,127.31 86.59,127.54 87.14,128.1 87.14,128.9 87.42,129.18 87.42,129.54 87.46,129.58 87.82,129.58
+V_DDR_1_DQ_VREF on TOP (solid shape): 82.87,125.69 82.87,125.42 82.14,124.69 81.47,124.69 81.33,124.82 81.33,125.21 81.48,125.36 81.83,125.36 82.23,125.77 82.79,125.77
+VDISPLAY_VCC on TOP (solid shape): 15.14,54.75 15.14,53.81 14.81,53.48 8.64,53.48 8.53,53.58 8.53,54.07 8.61,54.14 10.49,54.14 11.33,54.98 14.91,54.98
+VDISPLAY_VCC on BOTTOM (solid shape): 19.91,57.98 19.91,56.94 20.24,56.61 20.24,53.86 19.99,53.61 14.25,53.61 14.05,53.81 14.05,54.47 14.33,54.75 18.49,54.75 18.86,55.12 18.86,57.86 19.02,58.03 19.86,58.03
AMP_AGND on TOP (solid shape): 29.24,83.57 29.24,82.34 29.24,82.33 29.24,82.18 29.46,81.96 29.77,81.96 29.81,81.91 29.81,81.7 30.08,81.44 30.8,81.44 30.83,81.4 30.83,80.48 30.95,80.36 31.68,80.36 31.92,80.6 33.51,80.6 33.59,80.52 33.59,80.44 33.53,80.39 32.05,80.39 31.84,80.17 30.41,80.17 29.91,80.67 29.91,81.09 29.81,81.19 28.56,81.19 28.47,81.27 28.47,82.59 28.24,82.82 25.54,82.82 25.39,82.97 25.39,83.52 25.47,83.6 26.02,83.6 26.47,83.6 26.51,83.64 29.16,83.64
AMP_AGND on VCC: 30.61,80.81 30.38,81.04 30.38,82.12 30.65,82.46 33.17,82.46 33.17,81.04 32.94,80.81 31.85,80.81 31.83,80.84 31.62,80.84 31.59,80.81
AMP_LDO_A1.5V on TOP (solid shape): 30.19,82.72 30.19,82.22 30.43,81.98 31.44,81.98 32,81.42 32.66,81.42 32.71,81.37 33.5,81.37 33.55,81.32 33.55,81.24 33.5,81.19 31.85,81.19 31.7,81.04 31.01,81.04 30.99,81.06 30.99,81.5 30.91,81.57 30.09,81.57 29.95,81.71 29.95,82.01 29.86,82.11 29.6,82.11 29.54,82.17 29.54,82.77 29.58,82.81 30.1,82.81
AUDIO_PWR_EN_R on TOP (solid shape): 30.1,115.03 30.1,112.51 29.63,112.04 29.63,111.09 29.58,111.04 29.03,111.04 28.96,111.11 28.04,111.11 27.98,111.18 27.98,111.28 28.04,111.34 28.88,111.34 28.95,111.41 29.09,111.54 29.08,111.74 29.08,111.85 29.02,111.91 28.04,111.91 27.99,111.97 27.99,112.09 28.04,112.14 28.75,112.14 28.97,112.36 28.97,112.55 29.57,113.15 29.57,115.01 29.62,115.06 30.06,115.06
B1-4_PHASE_GT on BOTTOM (solid shape): 106.45,124.78 106.45,120.89 106.34,120.78 104.31,120.78 104.04,121.05 104.04,123.33 103.99,123.38 103.58,123.38 103.4,123.56 103.4,124.5 103.78,124.88 106.35,124.88
B1-4_PHASE_GT on BOTTOM (solid shape): 111.27,122.79 111.27,122.23 111.41,122.09 111.89,122.09 112.01,121.96 112.01,119.62 111.91,119.52 111.79,119.52 111.68,119.62 111.68,121.27 111.45,121.5 110.85,121.5 110.64,121.71 110.64,122.82 110.69,122.87 111.19,122.87
B1-4_PHASE_GT on GND3 (solid shape): 105.86,124.15 105.86,122.03 105.76,121.93 104.32,121.93 104.26,121.99 104.25,122.07 104.25,124.11 104.38,124.23 105.77,124.23
B1-4_PHASE_GT on IN3: 104.67,119.58 104.22,120.04 104.22,124.77 104.34,124.89 106.1,124.89 107.21,123.78 109.63,123.78 111.96,121.45 111.96,119.65 111.89,119.58 110.18,119.58 109.93,119.71 109.68,119.58
B5-8_PHASE_IA on BOTTOM (solid shape): 106.47,119.3 106.47,116.02 106.36,115.92 106.36,115.89 104.32,115.89 104.15,116.06 104.15,119.29 104.29,119.43 106.33,119.43
B5-8_PHASE_IA on BOTTOM (solid shape): 112.02,119.26 112.02,117.55 111.38,116.91 111.12,116.91 110.94,116.72 110.37,116.72 110.34,116.75 110.34,117.36 110.37,117.39 111.4,117.39 111.68,117.67 111.68,119.28 111.73,119.34 111.94,119.34
B5-8_PHASE_IA on GND3 (solid shape): 106.17,118.4 106.17,116.33 105.97,116.13 104.56,116.13 104.42,116.26 104.42,119.22 104.61,119.41 105.17,119.41
B5-8_PHASE_IA on IN3: 109.63,119.41 109.93,119.1 110.24,119.41 111.78,119.41 111.98,119.21 111.98,117.59 108.7,114.32 104.71,114.32 104.06,114.97 104.06,118.89 104.57,119.41
B+ on TOP (solid shape): 116.36,110.99 116.33,110.96 114.66,110.96 114.48,111.14 114.48,111.93 114.6,112.05 116.36,112.05
B+ on TOP (solid shape): 121.59,114.76 121.59,114.62 120.64,113.67 118.63,113.67 118.41,113.88 118.41,114.42 118.73,114.73 120.12,114.73 120.81,115.43 120.92,115.43
B+ on TOP (solid shape): 27.06,123.87 27.9,123.87 27.94,123.84 27.94,123.07 27.78,122.91 25.12,122.91 24.44,123.59 24.44,124.14 24.64,124.35 26.59,124.35
B+ on TOP (solid shape): 202.49,106.34 202.49,101.87 202.7,101.65 204.07,101.65 204.22,101.5 204.22,100.46 204.15,100.39 203.53,100.39 203,100.92 201.99,100.92 201.68,101.24 201.68,106.01 199.06,108.63 192.05,108.63 191.96,108.71 191.96,109.6 192.13,109.76 199.06,109.76
B+ on BOTTOM (solid shape): 204.75,101.13 204.75,99.86 204.37,99.48 203.35,99.48 203.35,101.13 203.61,101.39 204.5,101.39
B+ on BOTTOM (solid shape): 28.68,112.74 28.68,111.94 27.92,111.17 24.45,111.17 24.28,111.34 24.28,112.68 24.46,112.86 28.56,112.86
B+ on BOTTOM (solid shape): 193.84,109.6 193.84,106.47 193.71,106.34 192.13,106.34 191.98,106.49 191.98,109.51 192.21,109.74 193.7,109.74
B+ on BOTTOM (solid shape): 180.46,112.2 180.46,110.41 180.27,110.22 178.23,110.22 178.1,110.35 178.1,112.17 178.23,112.3 180.37,112.3
B+ on BOTTOM (solid shape): 26.57,124.37 26.83,124.37 27.22,123.99 27.22,122.15 27.17,122.1 26.36,122.1 26.1,122.37 24.89,122.37 24.46,122.8 24.46,124.2 24.64,124.37 26.57,124.37
B+ on BOTTOM (solid shape): 114.66,111.42 114.66,110.53 114.4,110.28 114.4,109.06 114.27,108.93 113.56,108.93 113.44,109.06 113.44,111.27 113.61,111.45 114.63,111.45
B+ on BOTTOM (solid shape): 121.24,117.76 121.24,116.82 121.41,116.65 122.38,116.65 122.5,116.53 122.5,115.1 122.4,115 120.93,115 120.78,115.15 120.78,116.6 120.7,116.68 120.22,116.68 120.12,116.78 120.12,117.74 120.19,117.82 121.18,117.82
B+ on BOTTOM (solid shape): 155.5,124.58 155.5,123.17 155.57,123.1 155.57,123.09 155.64,123.02 156.4,123.02 156.49,122.93 156.49,121.4 156.41,121.32 155.59,121.32 155.5,121.23 155.5,119.32 155.7,119.12 160.68,119.12 160.76,119.04 160.76,118 160.6,117.85 159.74,117.85 159.33,117.44 159.33,117.08 159.21,116.96 157.67,116.96 157.32,116.6 157.67,116.25 159.03,116.25 159.03,115.64 158.67,115.28 149.94,115.28 149.65,115.56 149.65,117.09 149.5,117.24 149.5,122.42 148.23,123.69 148.23,124.73 148.51,125.01 155.07,125.01
B+ on GND1 (solid shape): 122.29,115.89 122.29,115.51 121.84,115.06 121.29,115.06 120.94,115.41 120.94,115.56 121.5,116.11 122.07,116.11
B+ on GND1 (solid shape): 115.11,111.83 115.11,111.19 115.06,111.14 113.64,111.14 113.39,111.39 113.39,111.83 113.59,112.03 114.91,112.03
B+ on GND1 (solid shape): 26.67,111.88 26.67,111.65 26.57,111.55 26.01,111.55 25.78,111.78 25.53,111.78 25.32,111.57 25.32,111.42 25.2,111.29 24.33,111.29 24.26,111.37 24.26,112.16 24.36,112.26 26.29,112.26
B+ on IN1 (solid shape): 26.67,112.13 26.67,111.45 26.52,111.29 24.31,111.29 24.21,111.39 24.21,112.06 24.43,112.28 26.52,112.28
B+ on IN1 (solid shape): 35.18,138.37 35.18,136.95 35,136.77 30.56,136.77 30.42,136.91 30.42,138.33 30.63,138.55 35,138.55
B+ on IN1 (solid shape): 122.35,115.76 122.35,115.46 121.97,115.08 121.13,115.08 120.9,115.31 120.9,115.59 121.44,116.12 122,116.12
B+ on IN3 (solid shape): 155.19,124.55 155.19,123.54 155.12,123.46 148.54,123.46 148.31,123.69 148.31,124.6 148.56,124.86 154.89,124.86
B+ on IN3 (solid shape): 27.18,112.16 27.18,111.78 26.57,111.17 24.16,111.17 24.08,111.24 24.08,111.78 24.53,112.23 27.1,112.23
B+ on IN3 (solid shape): 122.54,116.31 122.54,115.34 122.3,115.1 121.31,115.1 121.11,115.31 121.11,115.61 121.89,116.4 122.45,116.4
B+ on GND3 (solid shape): 27.18,112.16 27.18,111.78 26.86,111.46 24.36,111.46 24.21,111.61 24.21,111.91 24.53,112.23 27.1,112.23
B+ on GND3 (solid shape): 114.33,111.7 114.33,110.96 113.99,110.63 113.56,110.63 113.49,110.71 113.49,111.93 113.61,112.05 113.97,112.05
B+ on GND3 (solid shape): 122.54,116.31 122.54,115.34 122.3,115.1 121.31,115.1 121.11,115.31 121.11,115.61 121.89,116.4 122.45,116.4
B+ on TOP: 106.13,115.99 106.13,116.75 106.71,116.75 106.71,117.2 106.13,117.2 106.13,117.96 106.71,117.96 106.71,118.4 106.13,118.4 106.13,119.1 106.51,119.48 106.51,119.93 106.45,119.99 105.31,119.99 105.12,119.8 105.12,115.99 105.18,115.93 106.07,115.93
B+ on VCC: outline of 96 points within 20.85,110.28 161.57,153.93 ; 3 cut-outs
B+ on IN1: 194.08,111.39 194.08,109.05 193.66,108.63 191.45,108.63 188.39,111.69 185.24,111.69 185.23,111.71 184.96,111.88 184.68,111.71 184.67,111.69 181.27,111.69 180.47,110.88 180.46,110.88 180.36,110.78 179.51,110.78 178.38,111.91 178.38,112.37 175.75,115 175.07,115 175.06,115 174.93,115.03 174.8,115 174.79,115 165.74,115 159.88,120.86 149.44,120.86 148.26,122.04 148.26,124.2 148.79,124.73 153.51,124.73 153.53,124.71 161.53,124.71 164.53,121.71 164.49,121.7 164.45,121.69 164.42,121.69 164.4,121.67 164.32,121.62 164.27,121.55 164.25,121.52 164.25,121.49 164.24,121.4 164.25,121.31 164.25,121.28 164.27,121.26 164.32,121.19 164.4,121.13 164.42,121.11 164.45,121.11 164.54,121.1 164.63,121.11 165.13,121.11 167.97,118.27 178.96,118.27 182.15,115.08 190.38,115.08
B+_1.0V on BOTTOM (solid shape): 180.39,115.2 180.39,112.89 180.03,112.53 178.34,112.53 177.93,112.94 176.33,112.94 176.17,113.1 176.17,113.71 175.41,114.47 175.41,115.38 175.44,115.41 180.19,115.41
B+_5V on TOP (solid shape): 27.36,117.67 27.36,116.55 26.85,116.04 24.54,116.04 24.35,116.23 24.35,116.49 24.33,116.5 24.33,117.57 24.55,117.78 27.24,117.78
B+_5V on BOTTOM: 24.57,113.19 24.28,113.48 24.28,117.82 24.54,118.07 27.28,118.07 27.51,117.85 27.86,117.85 27.94,117.77 27.94,117.52 27.74,117.31 26.67,117.31 26.54,117.19 26.54,114.85 27.41,113.98 27.41,113.26 27.34,113.19
BATDRV# on BOTTOM (solid shape): 160.93,112.59 160.93,112.05 160.71,111.83 158.83,111.83 158.72,111.93 158.72,112.36 158.83,112.46 159.99,112.46 160.15,112.61 160.91,112.61
BGT on BOTTOM (solid shape): 112.43,123.23 112.43,122.27 112.41,122.24 111.54,122.24 111.45,122.33 111.45,123.19 111.6,123.33 112.33,123.33
BQ24777_REGN on BOTTOM (solid shape): 141,116.8 141,115.89 141.25,115.64 141.25,114.42 141.2,114.37 141.1,114.37 141.05,114.42 141.05,115.41 140.61,115.84 138.96,115.84 138.63,116.17 137.82,116.17 137.74,116.25 137.74,116.83 137.99,117.07 140.73,117.07
BQ24777_REGN on IN4 (solid shape): 139,116.98 139,116.47 138.64,116.11 136.92,116.11 136.74,116.29 136.74,116.76 136.85,116.87 136.85,116.87 137.15,117.17 138.81,117.17
CHG_BTS on BOTTOM (solid shape): 142.1,116.56 142.1,115.95 142.06,115.92 141.76,115.92 141.66,115.81 141.66,114.42 141.6,114.37 141.5,114.37 141.45,114.42 141.45,115.66 141.12,115.99 141.12,116.53 141.2,116.6 142.06,116.6
CHG_BTS_C on BOTTOM (solid shape): 143.76,118.13 143.76,117.52 143.66,117.41 141.15,117.41 141.1,117.46 141.1,118.13 141.15,118.18 143.71,118.18
CHG_LGATE on IN3 (solid shape): 141.1,116.73 141.1,115.46 140.89,115.26 140.31,115.26 140.08,115.48 140.08,116.63 140.23,116.78 141.05,116.78
CHG_LGATE on IN3 (solid shape): 144.91,122.82 144.91,121.86 144.35,121.3 144.04,121.3 143.76,121.58 143.76,122.14 144.17,122.54 144.17,122.75 144.36,122.94 144.79,122.94
CHG_SW on BOTTOM (solid shape): 144.32,116.58 144.32,115.97 144.14,115.79 142.87,115.79 142.44,115.36 142.44,114.42 142.39,114.37 142.32,114.37 142.27,114.42 142.27,116.19 142.87,116.8 144.09,116.8
CHG_SW on BOTTOM (solid shape): 148.67,122.47 148.67,117.77 148.41,117.52 145.77,117.52 145.54,117.74 145.54,120.56 144.96,121.15 142.34,121.15 142.27,121.22 142.27,121.94 142.28,121.95 142.28,122.2 142.37,122.29 144.96,122.29 145.38,122.71 148.42,122.71
CHG_UGATE on IN3 (solid shape): 142.52,116.91 142.52,115.51 142.27,115.26 141.76,115.26 141.5,115.51 141.5,116.63 141.88,117.01 142.42,117.01
CHG_UGATE on IN3 (solid shape): 144.93,120 144.93,119.42 144.04,118.53 143.79,118.53 143.43,118.89 143.43,119.32 144.32,120.21 144.73,120.21
CMSRC on IN3 (solid shape): 144.55,113.12 144.55,112.92 144.5,112.87 144.47,112.85 144.43,112.84 144.42,112.84 144.38,112.85 144.35,112.87 144.31,112.89 144.04,112.89 143.92,112.77 143.92,112.36 144.1,112.17 144.18,112.2 144.21,112.2 144.26,112.21 144.33,112.19 144.39,112.14 144.43,112.1 144.47,112.1 144.47,111.83 144.37,111.72 143.64,111.72 143.46,111.9 143.46,112.94 143.76,113.25 144.42,113.25
CORE_FB on TOP (solid shape): 127.79,132.25 127.79,130.85 128.55,130.09 128.55,129.83 128.68,129.71 128.68,129.33 128.63,129.28 128.5,129.28 128.45,129.33 128.45,129.5 127.28,130.67 127.28,131.38 127.1,131.56 125.15,131.56 124.89,131.31 124.89,130.88 124.71,130.7 124.24,130.7 124.08,130.86 124.08,132.43 124.18,132.53 127.51,132.53
CORE_SW on TOP (solid shape): 127.86,129.71 127.86,129.3 128.04,129.12 128.22,129.12 128.3,129.05 128.3,128.95 128.19,128.84 127.48,128.84 127.18,129.15 127.18,129.17 127.11,129.31 126.97,129.38 126.95,129.38 126.78,129.54 125.16,129.54 125.07,129.63 125.07,130.24 125.32,130.5 127.08,130.5
