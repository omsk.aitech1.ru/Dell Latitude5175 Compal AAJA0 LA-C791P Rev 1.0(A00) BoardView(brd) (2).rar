# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ_49: length 15.6
  IN3 w0.06: 64.55,127.8 68.61,123.74 68.61,122.69 68.66,122.64 68.66,122.37 68.31,122.03 v10(68.31,122.03)
  IN3 w0.076: 64.55,127.8 64.31,128.04 64.31,129.33 65.13,130.14 65.13,131.54 64.04,132.63 64.04,133.51 63.86,133.68 63.75,133.68 63.58,133.52 63.58,133.2 63.78,133 v10(63.78,132.78)
M_B_DQ_50: length 11.9
  IN3 w0.06: v10(67.34,122.77) 67.34,122.77 67.34,123.33 66.5,124.18 66.44,124.23 62.89,127.78 62.89,128.16
  IN3 w0.076: 62.89,128.16 62.89,130.09 63.26,130.46 63.26,131.12 62.28,132.1 v10(62.28,132.28)
M_B_DQ_51: length 13.5
  IN3 w0.06: 64.14,128.09 64.14,128.03 68.47,123.69 68.47,122.66 68.52,122.61 68.52,122.43 68.4,122.3 68.31,122.3 68.23,122.23 68.23,122.23 68.11,122.11 68.11,122.1 67.99,121.98 v10(67.99,121.78)
  IN3 w0.076: 64.14,128.09 64.14,129.37 64.95,130.19 64.95,131.21 63.88,132.28 v10(63.78,132.28)
M_B_DQ_52: length 14.8
  IN3 w0.06: v10(67.99,122.77) 67.99,123.58 63.63,127.94 63.63,128.22
  IN3 w0.076: v10(62.78,132.78) 62.63,132.78 62.45,132.96 62.45,133.33 62.53,133.41 62.94,133.41 63.03,133.31 63.03,132.21 63.83,131.41 63.93,131.41 64.46,130.88 64.46,130.39 63.63,129.55 63.63,128.22
M_B_DQ_53: length 12.9
  IN3 w0.06: v10(67.99,122.27) 68.1,122.39 68.1,122.42 68.09,122.43 68.09,122.59 68.19,122.68 68.19,122.7 68.2,122.72 68.2,123.56 63.8,127.97 63.8,128.05
  IN3 w0.076: v10(63.28,132.28) 63.28,132.25 63.91,131.62 63.98,131.62 64.62,130.98 64.62,130.31 63.8,129.49 63.8,128.05
M_B_DQ_54: length 14.2
  IN3 w0.06: v10(67.34,122.27) 67.47,122.15 67.47,122.11 67.47,121.94 67.58,121.83 67.75,121.83 67.75,121.83 67.87,121.94 67.87,122.11 67.79,122.19 67.79,122.29 67.78,122.3 67.78,122.33 67.79,122.34 67.79,122.36 67.87,122.44 67.87,122.6 67.79,122.68 67.79,122.7 67.78,122.71 67.78,122.87 67.8,122.88 67.8,123.58 63.44,127.93 63.44,128.06
  IN3 w0.076: v10(62.78,132.28) 62.78,132.23 63.82,131.19 63.89,131.19 64.31,130.76 64.31,130.46 63.44,129.59 63.44,128.06
M_B_DQ_55: length 13.8
  IN3 w0.06: 62.72,128.24 62.72,127.76 64,126.48 66.36,124.12 67.17,123.31 67.17,122.88 67.14,122.85 67.14,122.68 67.24,122.59 67.24,122.45 67.14,122.36 67.14,122.19 67.22,122.11 67.22,122.11 67.34,121.98 v10(67.34,121.78)
  IN3 w0.076: 62.72,128.24 62.72,130.22 63.04,130.54 63.04,131.01 62.02,132.03 62.02,132.7 62.09,132.78 v10(62.28,132.78)
M_B_DQ_56: length 20.8
  IN3 w0.06: 62.18,128.26 62.18,128.05 63.75,126.48 66.12,124.12 67.03,123.2 67.03,122.93 67.02,122.91 67.02,122.52 v10(67.02,122.52)
  IN3 w0.076: v10(63.28,136.28) 63.55,136.55 63.55,136.74 63.8,137 64.19,137 64.19,137 64.72,137 65.09,136.63 65.09,136.44 65.09,136.44 65.09,136.29 64.3,135.5 63.88,135.5 63.88,135.5 63.69,135.5 63.56,135.37 63.56,135.37 63.54,135.35 63.54,135.35 63.36,135.17 63.14,135.17 63.13,135.16 63.09,135.16 62.73,134.81 62.73,134.73 61.44,133.45 61.44,131.06 62,130.5 62,129.15 62.18,128.97 62.18,128.26
M_B_DQ_57: length 21.9
  IN3 w0.06: 62.01,128.29 62.01,128.01 66.9,123.11 66.9,122.68 66.83,122.61 66.83,122.61 66.82,122.6 66.82,122.44 66.91,122.34 66.91,122.13 v10(67.02,122.03)
  IN3 w0.076: v10(62.28,135.78) 62.45,135.78 62.69,136.02 62.93,136.02 63.17,135.78 63.29,135.78 63.4,135.88 63.76,135.88 64.05,136.18 64.05,136.44 64.14,136.53 64.44,136.53 64.54,136.43 64.54,136.12 64.44,136.02 64.33,136.02 63.98,135.68 63.58,135.68 63.4,135.5 62.72,135.5 62.69,135.5 62.56,135.37 62.56,134.82 61.27,133.52 61.27,130.93 61.82,130.37 61.82,129.07 62.01,128.89 62.01,128.29
M_B_DQ_58: length 16.8
  IN3 w0.06: v10(66.05,122.77) UC1.BG21 66.06,122.97 65.22,123.8 65.22,123.8 64.9,124.12 64.85,124.12 61.62,127.35 61.61,127.35 61.33,127.63
  IN3 w0.076: v10(62.28,136.28) 62.07,136.28 61.04,135.25 61.04,134.59 60.38,133.93 60.38,130.4 60.93,129.84 60.93,128.72 61.11,128.54 61.11,127.85 61.33,127.63
M_B_DQ_59: length 20.8
  IN3 w0.06: v10(66.7,121.78) 66.34,121.78 66.19,121.62 66.18,121.62 66.14,121.58 65.97,121.58 65.86,121.7 65.86,121.86 65.86,121.86 65.86,121.94 65.68,122.12 65.68,122.41 65.58,122.51 65.58,122.8 61.45,126.94 61.3,126.94 60.89,127.35
  IN3 w0.076: 60.89,127.35 60.58,127.66 60.58,128.31 60.4,128.49 60.4,129.51 59.84,130.07 59.84,134.18 60.51,134.85 60.51,135.53 62.16,137.19 62.38,137.19 v10(62.79,136.78)
M_B_DQ_60: length 17.9
  IN3 w0.06: 61.66,128.29 61.66,127.95 63.13,126.48 65.49,124.12 66.5,123.11 66.5,122.85 66.5,122.85 66.5,122.68 66.6,122.58 66.6,122.37 v10(66.7,122.27)
  IN3 w0.076: v10(62.78,136.28) 62.64,136.28 62.38,136.02 62.04,136.02 61.65,135.63 61.65,135.52 61.73,135.45 61.95,135.45 62.03,135.37 62.03,134.79 60.91,133.67 60.91,130.68 61.47,130.12 61.47,128.95 61.66,128.75 61.66,128.29
M_B_DQ_61: length 16.1
  IN3 w0.06: 61.84,128.27 61.84,127.97 66.7,123.11 UC1.BG23 v10(66.7,122.77)
  IN3 w0.076: v10(62.78,135.78) 62.66,135.65 62.63,135.65 62.27,135.29 62.27,134.78 61.09,133.6 61.09,130.8 61.62,130.27 61.62,129.02 61.84,128.8 61.84,128.27
M_B_DQ_62: length 18.7
  IN3 w0.06: 61.02,127.48 61.42,127.08 61.5,127.08 62.14,126.44 62.15,126.44 64.87,123.72 64.92,123.72 65.71,122.93 65.71,122.62 65.81,122.52 65.81,122.18 66.06,121.94 UC1.BC21 v10(66.05,121.78)
  IN3 w0.076: 61.02,127.48 60.78,127.71 60.78,128.39 60.58,128.59 60.58,129.61 60.02,130.17 60.02,134.1 60.69,134.77 60.69,135.46 62.04,136.81 62.25,136.81 v10(62.28,136.78)
M_B_DQ_63: length 19.7
  IN3 w0.06: v10(66.05,122.27) 66.01,122.31 66.01,122.52 65.84,122.7 65.84,122.97 64.97,123.84 64.94,123.84 62.2,126.57 62.2,126.57 61.56,127.21 61.53,127.21 61.33,127.41
  IN3 w0.076: 61.33,127.41 60.96,127.78 60.96,128.46 60.76,128.67 60.76,129.74 60.2,130.3 60.2,134.03 60.86,134.69 60.86,135.38 62.01,136.53 62.94,136.53 63.04,136.43 63.04,136.15 63.14,136.04 63.55,136.04 v10(63.78,136.28)
M_B_DQS_DN_0: length 20.4
  IN3 w0.06: 72.57,126.35 72.57,126.29 72.1,125.83 72.1,123.02 72.05,122.97 72.05,122.68 71.97,122.59 71.97,122.44 72.13,122.28 72.14,122.28 72.17,122.25 72.17,122.03 v10(72.17,122.03)
  IN3 w0.091: v6(70.07,137.49) 70.08,137.51 70.14,137.51 70.22,137.43 70.22,137.29 71.44,136.07 71.44,134.12 71.67,133.89 71.67,131.11 72.57,130.21 72.57,126.35
  IN4 w0.069: v6(70.07,137.49) 70.06,137.51 70.05,137.51 70.03,137.52 69.87,137.52 69.87,137.52 69.61,137.52 69.46,137.37 67.6,137.37 67.19,137.78 v5(66.78,137.78)
M_B_DQS_DN_1: length 28.3
  IN3 w0.06: 73.31,125.1 73.31,125.08 73.3,125.07 73.3,124.64 73.31,124.64 73.31,122.99 73.34,122.96 73.34,122.68 73.31,122.65 73.31,122.65 73.26,122.6 73.26,122.44 73.38,122.32 73.46,122.24 73.46,122.03 v10(73.46,122.03)
  IN3 w0.091: v10(64.28,138.78) 64.3,138.8 64.86,138.8 65.14,139.09 65.14,139.65 66.25,140.75 70.74,140.75 74.04,137.45 74.04,130.94 74.2,130.78 74.2,126.18 73.31,125.28 73.31,125.18 73.31,125.18 73.31,125.1
M_B_DQS_DN_2: length 15.8
  IN3 w0.091: v6(62.77,130.68) 62.62,130.83 62.58,130.83 62.36,130.83 61.67,131.52 61.67,133.04 62.9,134.27 62.9,134.72 63.02,134.84 63.1,134.92 63.2,135.02 63.38,135.02 63.62,134.78 v10(63.78,134.78)
  IN4 w0.06: v5(67.67,123.5) 67.68,123.52 67.68,123.73 67.75,123.8 67.87,123.91 67.87,124.08 67.78,124.17 67.78,124.33 67.81,124.37 67.81,124.94 67.38,125.38 67.34,125.38 63.9,128.82
  IN4 w0.069: 63.9,128.82 63.9,128.82 63.81,128.91 63.81,129.71 63.56,129.96 63.11,130.41 62.9,130.41 62.75,130.57 62.75,130.65 v6(62.77,130.68)
M_B_DQS_DN_3: length 19.1
  IN4 w0.06: 62.06,128.37 62.61,128.37 65.7,125.28 65.7,124.89 65.79,124.81 65.79,124.77 66,124.57 66,124.56 66.19,124.56 66.38,124.37 UC1.BM22 v5(66.38,124)
  IN4 w0.069: v5(62.78,137.28) 62.91,137.28 62.97,137.22 62.97,137.1 62.87,137 62.01,137 61.86,136.84 61.86,136.62 60.52,135.29 60.52,134.45 60.02,133.95 60.02,128.85 60.51,128.37 62.06,128.37
M_B_DQS_DN_4: length 26.2
  IN3 w0.091: v10(65.78,137.78) 65.78,137.86 66.03,138.11 66.03,138.2 66.35,138.51 66.35,139.28 66.55,139.48 66.66,139.59 66.95,139.88 66.95,139.97 66.95,139.99 67.08,140.12 v6(67.09,140.12)
  IN4 w0.06: v5(73.46,123.5) 73.34,123.63 73.34,123.83 73.28,123.9 73.28,123.9 73.26,123.91 73.26,124.08 73.28,124.09 73.28,124.1 73.34,124.16 73.34,124.43 73.18,124.59 73.18,124.59 73.14,124.62 73.14,125.21 73.25,125.32 73.25,125.32 73.25,125.33
  IN4 w0.069: v6(67.09,140.12) 67.09,140.29 67.27,140.47 71.39,140.47 74.19,137.66 74.19,128.06 74.22,128.04 74.22,127 73.33,126.1 73.33,126 73.33,125.72 73.33,125.72 73.33,125.4 73.25,125.33
M_B_DQS_DN_5: length 20.8
  IN3 w0.091: v6(70.29,138.8) 70.43,138.8 70.52,138.71 70.52,138.7 70.55,138.67 70.55,138.39 70.48,138.32 70.4,138.24 70.3,138.24 70.22,138.32 70.22,138.48 70.15,138.56 70,138.56 69.92,138.48 69.92,138.32 69.84,138.24 69.66,138.24 69.11,138.79 68.93,138.79 68.85,138.87 68.85,138.96 68.77,139.04 68.62,139.04 68.55,138.96 68.55,138.87 68.5,138.83 68.47,138.79 68.38,138.79 68.37,138.78 v10(68.28,138.78)
  IN4 w0.06: v5(72.17,124) 72.17,124 72.17,124.49 72.07,124.59 72.07,126.68 72.14,126.74
  IN4 w0.069: v6(70.29,138.8) 70.29,138.82 70.5,139.04 70.84,139.04 70.92,138.96 71.29,138.59 71.29,138.13 72.2,137.21 72.2,131.9 72.3,131.79 72.3,129.88 72.84,129.35 72.84,127.44 72.14,126.74
M_B_DQS_DN_6: length 15.5
  IN3 w0.06: 67.45,123.47 67.46,123.47 67.55,123.39 67.55,122.97 67.54,122.96 67.54,122.68 67.47,122.61 67.47,122.6 67.47,122.44 67.58,122.32 67.59,122.32 67.67,122.25 67.67,122.03 v10(67.67,122.03)
  IN3 w0.091: v6(63.79,130.91) 63.79,130.73 63.08,130.02 63.08,127.83 67.45,123.47
  IN4 w0.069: v6(63.79,130.91) 63.72,130.85 63.26,130.85 62.7,131.41 62.52,131.41 62.26,131.41 62.02,131.65 62.02,132.95 62.03,132.96 62.03,132.98 62.1,133.05 62.39,133.05 62.62,133.28 v5(62.78,133.28)
M_B_DQS_DN_7: length 18.3
  IN3 w0.06: 61.57,127.82 61.57,127.81 61.57,127.8 66.38,123 66.38,122.52 v10(66.38,122.52)
  IN3 w0.091: v6(61.44,134.68) 61.45,134.67 61.45,134.5 61.37,134.42 61.37,134.41 60.71,133.76 60.71,130.56 61.26,130.01 61.26,128.85 61.46,128.66 61.46,127.93 61.57,127.82
  IN4 w0.069: v5(63.78,135.78) 63.52,135.51 63.52,135.18 63.36,135.03 63.19,135.03 63.01,134.85 63.01,134.69 62.83,134.51 62.21,134.51 61.81,134.91 61.59,134.91 61.44,134.76 v6(61.44,134.68)
M_B_DQS_DP_0: length 20.5
  IN3 w0.06: v10(72.17,122.52) 72.17,122.52 72.17,122.92 72.22,122.97 72.22,125.78 72.73,126.28 72.73,126.35
  IN3 w0.091: v6(69.94,137.83) 70.06,137.83 70.37,137.53 70.37,137.36 71.59,136.13 71.59,134.18 71.82,133.95 71.82,131.17 72.73,130.27 72.73,130.15 72.73,126.44 72.73,126.44 72.73,126.35
  IN4 w0.069: v6(69.94,137.83) 69.77,137.65 69.55,137.65 69.4,137.5 67.66,137.5 67.25,137.91 66.99,137.91 66.78,138.11 v5(66.78,138.28)
M_B_DQS_DP_1: length 28.2
  IN3 w0.06: v10(73.46,122.52) 73.46,123.01 73.43,123.04 73.43,124.69 73.42,125 73.46,125.04 73.46,125.06
  IN3 w0.091: 73.46,125.06 73.46,125.22 74.36,126.11 74.36,130.84 74.19,131.01 74.19,137.51 70.81,140.9 66.18,140.9 64.99,139.71 64.99,139.15 64.79,138.95 64.43,138.95 64.25,139.14 64.25,139.25 v10(64.28,139.28)
M_B_DQS_DP_2: length 15.9
  IN3 w0.091: v6(62.49,131.05) 62.35,131.05 61.82,131.58 61.82,132.98 63.04,134.2 63.23,134.2 63.31,134.12 63.31,134.07 63.38,134 63.54,134 63.61,134.07 63.61,134.12 63.69,134.2 63.99,134.2 64.08,134.29 64.08,134.39 64,134.46 63.4,134.46 63.28,134.58 v10(63.28,134.78)
  IN4 w0.06: 63.79,128.75 63.84,128.7 63.85,128.7 67.29,125.26 67.33,125.26 67.69,124.89 67.69,124.41 67.64,124.36 67.64,124.02 v5(67.67,124)
  IN4 w0.069: v6(62.49,131.05) 62.49,131.05 62.53,131.01 62.53,130.61 62.6,130.54 62.6,130.53 62.85,130.28 63.05,130.28 63.68,129.66 63.68,128.86 63.79,128.75
M_B_DQS_DP_3: length 19
  IN4 w0.06: 61.94,128.24 62.57,128.24 65.58,125.23 65.58,124.84 65.67,124.76 65.67,124.72 65.88,124.52 65.88,124.51 65.95,124.44 66.05,124.44 66.14,124.44 66.26,124.33 66.26,124.16 66.16,124.07 66.16,123.93 66.38,123.71 66.38,123.51 v5(66.38,123.5)
  IN4 w0.069: v5(62.28,137.28) 62.22,137.21 62.04,137.21 61.73,136.9 61.73,136.68 60.39,135.34 60.39,134.5 59.89,134 59.89,128.8 60.45,128.24 61.94,128.24
M_B_DQS_DP_4: length 26.1
  IN3 w0.091: v6(66.7,140.14) 66.7,140.14 66.7,140.13 66.8,140.04 66.8,139.94 66.55,139.7 66.14,139.28 65.96,139.28 65.89,139.21 65.89,139.05 65.96,138.98 66.12,138.98 66.19,138.9 66.19,138.58 65.9,138.28 v10(65.78,138.28)
  IN4 w0.06: v5(73.46,124) 73.48,124.02 73.48,124.09 73.46,124.11 73.46,124.47 73.46,124.48 73.3,124.64 73.3,124.64 73.26,124.67 73.26,125.16 73.35,125.24
  IN4 w0.069: 73.35,125.24 73.46,125.35 73.46,126.05 74.35,126.94 74.35,128.09 74.32,128.12 74.32,137.72 71.44,140.6 67.22,140.6 67.04,140.43 66.75,140.14 v6(66.7,140.14)
M_B_DQS_DP_5: length 20.9
  IN3 w0.091: v6(70.74,138.8) 70.7,138.76 70.7,138.32 70.59,138.21 70.47,138.09 69.6,138.09 69.04,138.64 68.5,138.64 68.42,138.55 68.19,138.55 68.06,138.69 68.06,138.93 68.28,139.15 v10(68.28,139.28)
  IN4 w0.06: v5(72.17,123.51) 72.17,123.71 71.97,123.91 71.97,124.08 71.98,124.09 71.98,124.09 72.05,124.16 72.05,124.44 71.95,124.54 71.95,126.63 71.95,126.74 72.04,126.83
  IN4 w0.069: v6(70.74,138.8) 70.76,138.81 70.88,138.81 71.16,138.54 71.16,138.07 72.07,137.16 72.07,131.84 72.17,131.74 72.17,129.83 72.71,129.29 72.71,127.49 72.04,126.83
M_B_DQS_DP_6: length 15.4
  IN3 w0.06: 67.57,123.56 67.67,123.46 67.67,122.92 67.66,122.91 67.66,122.66 67.67,122.65 v10(67.67,122.52)
  IN3 w0.091: v6(64.08,130.65) 63.93,130.65 63.23,129.96 63.23,127.9 67.51,123.62 67.57,123.56
  IN4 w0.069: v5(62.28,133.28) 62.15,133.28 61.9,133.03 61.9,133.01 61.89,133 61.89,131.6 62.21,131.28 62.57,131.28 62.64,131.28 63.21,130.72 63.56,130.72 63.7,130.58 63.7,130.4 63.78,130.32 63.94,130.32 64.08,130.47 v6(64.08,130.65)
M_B_DQS_DP_7: length 18.3
  IN3 w0.06: v10(66.38,122.03) 66.38,122.03 66.38,122.24 66.3,122.32 66.29,122.32 66.18,122.44 66.18,122.6 66.26,122.68 66.26,122.95 61.54,127.67 61.51,127.67 61.3,127.87 61.3,128
  IN3 w0.091: 61.3,128 61.3,128.6 61.11,128.79 61.11,129.94 60.56,130.49 60.56,133.82 61.21,134.47 61.21,134.8 61.26,134.84 61.36,134.94 61.57,134.94 v6(61.76,135.14)
  IN4 w0.069: v6(61.76,135.14) 61.91,135.14 62.02,135.03 62.88,135.03 63.05,135.2 63.05,135.4 63.28,135.63 v5(63.28,135.78)
M_B_ODT0: length 28.6
  IN3 w0.06: v10(70.56,121.78) 70.26,121.78 69.85,122.18 69.85,122.55 69.7,122.7 69.7,122.93 69.85,123.08 69.85,124.55 69.62,124.78 69.62,126.03 69.2,126.46 68.82,126.46 v6(68.79,126.49)
  IN3 w0.076: v10(63.78,135.28) 64.66,135.28 65.17,135.79 v6(65.74,135.79) 65.73,135.8 65.73,136.94 66.08,137.29 66.08,137.58 v10(66.28,137.78) ; v6(66.78,134.56) 66.78,135.66 66.96,135.83 68.25,135.83 68.37,135.71 68.37,135.6 68.25,135.48 67.16,135.48 67.06,135.38 67.06,135.07 67.36,134.77 68.86,134.77 69.7,133.92 69.7,133.39 68.89,132.58 68.89,132.04 69.04,131.9 69.24,131.9 69.37,131.77 69.37,130.3 68.9,129.83 68.69,129.83 68.67,129.82 v6(68.62,129.82)
  IN4 w0.06: v6(68.79,126.49) 68.77,126.51 68.77,126.69 68.91,126.83 68.91,127.8 68.55,128.16
  IN4 w0.061: v6(66.78,134.56) 66.78,134.69 65.74,135.73 v6(65.74,135.79) ; v6(68.62,129.82) 68.62,129.8 68.55,129.72 68.55,128.16
ME_FWP#: length 148.1
  TOP w0.119: Q7.5 50.42,130.11 v1(50.83,129.71)
  IN1 w0.084: v2(51.06,130.25) 51.05,130.25 51.05,130.19 50.83,129.96 v1(50.83,129.71)
  IN2 w0.079: v2(121.69,136.08) 120.78,136.99 110.78,136.99 110.12,136.33 96.6,136.33 96.13,136.8 94.61,136.8 94.01,136.21 72.53,136.21 72.35,136.03 60.78,136.03 59.59,134.84 58.89,134.84 55.52,131.47 55.4,131.47 55.06,131.13 55.06,130.88 54.61,130.43 53.48,130.43 53.06,130.85 51.66,130.85 v2(51.06,130.25)
  IN3 w0.084: v7(184.91,133.06) 184.86,133.01 178.93,133.01 178.47,132.55 167.92,132.55 165.81,134.66 134.44,134.66 132.98,133.2 132.69,133.2 132.34,132.84 127.05,132.84 123.48,136.41 122.02,136.41 v2(121.69,136.08)
  BOTTOM w0.119: v7(184.91,133.06) 184.92,133.05 R346.1 ; R346.1 185.32,133.63 R344.2 ; R346.1 185.35,133.08 185.7,132.72 186.08,132.72 186.4,133.04 187.38,133.04 188.08,133.74 U34.J13
MEC_XTAL1: length 4.1
  BOTTOM w0.119: U34.A1 195.01,137.74 195.56,138.29 195.56,139.08 C236.1 195.33,139.86 Y2.1
MEC_XTAL2: length 4.9
  BOTTOM w0.119: U34.B1 194.87,137.19 195.39,137.19 196.2,138 196.2,139.17 C235.1 196.34,140.42 Y2.2
MEM_CONFIG0: length 22
  TOP w0.119: v1(46.05,120.31) RH31.1
  IN1 w0.084: v1(46.05,120.31) 46.05,120.28 v2(45.82,120.06)
  IN3 w0.06: 56.25,121.23 57.51,121.23 57.89,120.84 58.78,120.84 59.14,120.49 59.79,120.49 60.68,119.6 61.18,119.6 61.43,119.35 61.86,119.35 62.1,119.11 62.44,119.11 62.52,119.03 62.69,119.03 62.77,119.11 62.94,119.11 63.14,118.91 v10(63.35,118.91)
  IN3 w0.084: 56.25,121.23 55.28,120.26 54.9,120.26 53.51,121.66 52.51,121.66 51.85,122.32 49.56,122.32 48.73,121.49 47.26,121.49 v2(45.82,120.06)
MEM_CONFIG1: length 20.7
  TOP w0.119: RH29.1 v1(46.05,121.2)
  IN1 w0.084: v1(46.05,121.2) 46.05,121.12 45.92,121 v2(45.92,120.89)
  IN3 w0.06: 56.14,121.38 57.55,121.38 57.96,120.98 58.82,120.98 59.19,120.61 59.84,120.61 60.73,119.72 61.23,119.72 61.48,119.47 61.91,119.47 62.15,119.23 v10(62.61,119.23)
  IN3 w0.084: v2(45.92,120.89) 46.5,121.47 46.83,121.47 47.04,121.68 48.66,121.68 49.48,122.5 51.93,122.5 52.59,121.84 53.58,121.84 54.98,120.45 55.2,120.45 56.14,121.38
MEM_CONFIG2: length 21.6
  TOP w0.119: v1(46.05,119.42) RH34.1
  IN1 w0.084: v1(46.05,119.42) 46.05,119.3 v2(45.88,119.14)
  IN3 w0.06: v10(62.85,118.91) 62.81,118.91 62.61,118.71 62.27,118.71 62.2,118.79 62.08,118.79 61.76,119.11 61.33,119.11 61.08,119.36 60.58,119.36 59.7,120.25 59.04,120.25 58.7,120.58 57.66,120.58 57.38,120.87
  IN3 w0.084: v2(45.88,119.14) 46.09,119.34 46.3,119.34 47.57,120.6 48.4,120.6 49.75,121.95 51.58,121.95 52.66,120.87 52.66,120.82 53.41,120.07 54.57,120.07 54.75,119.89 55.44,119.89 56.42,120.87 57.38,120.87
MEM_CONFIG3: length 21.7
  TOP w0.119: RH36.1 54.01,119.22 v1(54.01,119.83)
  IN1 w0.084: v2(56.11,115.31) 55.95,115.47 55.95,116.08 54.32,117.71 53.14,117.71 52.81,118.04 52.81,118.49 54.01,119.7 v1(54.01,119.83)
  IN3 w0.06: 56.18,115.28 58.12,115.28 59.06,116.21 60.45,116.21 60.72,116.49 60.72,116.49 60.77,116.53 61.99,116.53 62.32,116.21 62.73,116.21 62.83,116.11 62.83,115.98 62.92,115.89 62.94,115.89 63.03,115.79 63.16,115.79 64.05,114.9 64.46,114.9 64.62,115.05 64.62,115.48 64.8,115.66 64.8,116.83 64.64,116.99 v3(64.03,116.99)
  IN3 w0.084: v2(56.11,115.31) 56.14,115.28 56.18,115.28
  IN4 w0.06: v3(64.03,116.99) 63.99,116.99 63.65,117.33 63.35,117.33 63.18,117.5 63.16,117.5 63.04,117.62 v5(62.85,117.62)
MIC1-VREFO_L: length 12
  IN1 w0.254: v1(9.14,139.75) 9.27,139.88 v2(9.27,140.73)
  IN3 w0.254: v2(9.27,140.73) v3(9.27,140.3)
  IN4 w0.254: v4(8.51,131.28) 8.58,131.36 8.58,131.71 8.2,132.1 8.2,139.46 9.04,140.3 v3(9.27,140.3)
  BOTTOM w0.203: UA3.38 8.58,131.22 v4(8.51,131.28)
MIC1-VREFO_R: length 15.9
  IN1 w0.254: v1(8.94,144.63) 8.94,144.69 v2(8.69,144.95)
  IN3 w0.254: v2(8.69,144.95) 8.36,144.95 v3(8.31,144.9)
  IN4 w0.254: v3(8.31,144.9) 7.67,144.26 7.67,132.02 8.15,131.54 v4(8.23,131.54)
  BOTTOM w0.203: UA3.39 8.73,131.62 8.61,131.74 8.43,131.74 v4(8.23,131.54)
MONO_IN: length 5.1
  IN4 w0.203: v4(13.16,122.01) 12.42,122.75 12.42,125.62 v4(12.09,125.95)
  BOTTOM w0.203: UA3.23 12.18,126.34 12.09,126.25 v4(12.09,125.95)
MSCLK: length 18.1
  IN3 w0.084: v10(189.82,136.74) 189.12,136.74 188.35,137.5 188.35,141.12 187.35,142.13 v7(187.35,143.04) 187.6,143.29 188.02,143.29 192.48,147.75 194.33,147.75 195.13,146.95 v7(195.13,146.6)
MSDATA: length 22.2
  IN3 w0.084: v10(190.32,135.74) 190.06,136 190.06,136.34 189.9,136.5 189.1,136.5 188.04,137.56 188.04,141.15 v7(186.16,143.03) 186.6,143.47 187.94,143.47 192.4,147.93 194.4,147.93 195.63,146.71 v7(195.63,146.6)
  BOTTOM w0.119: R311.2 186.73,143.03 v7(186.16,143.03)
MUX_DP_AUXN: length 18.1
  TOP w0.119: v1(32.85,49.89) 32.71,50.04 32.14,50.04 32.01,50.16 31.82,50.16 31.71,50.04 UV2.27
  IN1 w0.109: v1(34.09,44.8) 34.09,45.12 v2(34.06,45.15) ; v2(30.89,39.54) 30.76,39.66 v1(30.52,39.66) ; v1(32.85,49.89) v2(32.52,49.89)
  IN3 w0.084: v2(30.89,39.54) 31.1,39.32 31.96,39.32 32.69,40.05 32.69,42.06 32.98,42.34 33.86,42.34 34.36,42.84 34.36,44.86 v2(34.06,45.15) 34.26,45.35 34.26,46.7 33.59,47.37 33.59,50 33.49,50.11 32.74,50.11 v2(32.52,49.89)
MUX_DP_AUXP: length 18.5
  TOP w0.119: v1(32.85,50.45) 32.71,50.3 32.24,50.3 32.12,50.42 31.82,50.42 31.71,50.54 UV2.28
  IN1 w0.109: v2(34.62,45.15) 34.62,44.83 v1(34.65,44.8) ; v1(30.52,38.78) 30.7,38.78 v2(30.89,38.97) ; v1(32.85,50.45) v2(32.52,50.45)
  IN3 w0.084: v2(30.89,38.97) 31.08,39.16 32.03,39.16 32.85,39.98 32.85,41.99 33.05,42.18 33.93,42.18 34.52,42.77 34.52,45.05 v2(34.62,45.15) 34.43,45.34 34.43,46.77 33.75,47.44 33.75,50.07 33.55,50.27 32.7,50.27 v2(32.52,50.45)
MUX_DP_N0: length 1.7
  TOP w0.119: CV42.2 27.41,42.61 27.41,42.04 27.39,42.02 27.39,41.88 27.51,41.76 U31.15
MUX_DP_N0_C: length 6
  TOP w0.119: CV42.1 27.41,43.5 27.41,44.24 28.09,44.92 28.09,45.76 29.69,47.36 29.69,47.61 29.81,47.73 UV2.23
MUX_DP_N1: length 1.8
  TOP w0.119: U31.18 26.01,41.16 26.01,41.76 25.89,41.88 25.89,41.94 25.99,42.04 25.99,42.61 CV40.2
MUX_DP_N1_C: length 5.9
  TOP w0.119: UV2.20 28.31,47.79 28.16,47.63 28.16,47.17 25.99,45 v17(25.99,44.24) 25.99,43.5 CV40.1
MUX_DP_N2: length 1.7
  TOP w0.119: U31.20 25.01,41.76 24.89,41.88 24.89,42.63 CV38.2
MUX_DP_N2_C: length 5.8
  TOP w0.119: UV2.17 26.81,47.65 26.7,47.54 26.7,46.71 24.87,44.89 24.87,43.5 CV38.1
MUX_DP_N3: length 1.8
  TOP w0.119: U31.23 23.44,41.23 23.44,41.57 23.39,41.62 23.39,41.92 23.14,42.17 23.14,42.59 CV44.2
MUX_DP_N3_C: length 5.9
  TOP w0.119: UV2.14 25.31,47.74 25.23,47.67 25.23,47.17 24.98,46.91 23.72,45.65 23.72,44.41 23.14,43.83 23.14,43.47 CV44.1
MUX_DP_P0: length 1.7
  TOP w0.119: CV41.2 27.15,42.61 27.15,42.15 27.12,42.13 27.12,41.88 27.01,41.76 U31.16
MUX_DP_P0_C: length 5.9
  TOP w0.119: UV2.22 29.31,47.79 29.43,47.68 29.43,47.46 28.16,46.2 27.83,45.87 27.83,45.03 v17(27.53,44.73) 27.15,44.35 27.15,43.5 CV41.1
MUX_DP_P1: length 1.8
  TOP w0.119: U31.19 25.51,41.76 25.62,41.88 25.62,42.05 25.73,42.15 25.73,42.61 CV39.2
MUX_DP_P1_C: length 5.9
  TOP w0.119: UV2.19 27.81,47.63 27.89,47.55 27.89,47.28 25.73,45.11 25.73,43.5 CV39.1
MUX_DP_P2: length 1.7
  TOP w0.119: U31.21 24.57,41.23 24.57,41.82 24.62,41.88 24.62,42.6 CV37.2
MUX_DP_P2_C: length 5.8
  TOP w0.119: CV37.1 24.61,43.5 v17(24.61,44.36) 24.61,45 26.43,46.82 26.43,47.54 26.31,47.67 UV2.16
MUX_DP_P3: length 1.8
  TOP w0.119: CV43.2 22.88,42.57 22.88,42.06 23.12,41.82 23.12,41.7 23.01,41.58 U31.24
MUX_DP_P3_C: length 5.9
  TOP w0.119: CV43.1 22.81,43.43 22.88,43.49 22.88,43.94 23.46,44.52 23.46,45.76 24.97,47.28 24.97,47.63 24.81,47.79 UV2.13
MUX_RFU1: length 2
  TOP w0.119: U31.13 28.88,39.61 29.6,38.89 R277.1
MUX_RFU2: length 1.7
  TOP w0.119: U31.14 28.7,40.11 29.14,39.66 R276.1
NB_MUTE#: length 208.6
  IN1 w0.084: v2(100.96,137.78) 101.03,137.85 101.03,138.13 100.76,138.39 90.26,138.39 90.09,138.22 85.53,138.22 84.76,137.45 82.25,137.45 81.72,137.98 74.03,137.98 61.62,150.39 46.96,150.39 45.92,149.35 38.34,149.35 23.7,134.71 23.7,132.77 24.58,131.89 24.58,130.88 24.49,130.79 24.49,128.92 24.8,128.6 24.8,127.38 v1(24.49,127.08)
  IN2 w0.079: v2(122.95,136) 122.95,135.99 121.59,137.35 104.5,137.35 103.4,138.46 102.6,138.46 101.85,137.71 101.49,137.71 101.41,137.78 v2(100.96,137.78)
  IN3 w0.084: v2(122.95,136) 123.28,136 v7(123.33,135.95)
  IN4 w0.06: 191.57,140.63 191.63,140.68 191.9,140.68 191.99,140.59 191.99,138.71 192.53,138.17 192.53,136.95 192.32,136.74 v10(192.32,136.74)
  IN4 w0.089: v4(126.64,134.15) 126.47,134.15 124.68,135.94 v4(124.68,136.18) ; 191.57,140.63 191.26,140.63 190.54,141.35 186.84,141.35 186.51,141.02 186.51,140.9 184.52,138.91 184.52,137.69 183.97,137.13 183.97,136.84 182.69,135.56 182.69,133.63 182.45,133.39 181.3,133.39 180.26,132.35 180.26,130.57 179.7,130.01 v4(179.7,129.91)
  BOTTOM w0.119: v4(179.7,129.91) 179.65,129.91 178.59,128.84 152.3,128.84 151.26,129.89 143.96,129.89 143.73,129.65 133.62,129.65 133.04,130.23 133.04,131.93 131.93,133.05 127.04,133.05 126.71,133.38 126.71,134.09 v4(126.64,134.15) ; v7(123.33,135.95) 123.37,135.95 123.6,136.18 v4(124.68,136.18)
NFC_DET#: length 230.2
  IN1 w0.084: v2(210.03,126.58) 210.01,126.61 208.19,126.61 205.78,129.02 203.43,129.02 202.79,129.66 200.23,129.66 200.02,129.45 197.4,129.45 196.97,129.02 190.8,129.02 189.13,130.69 189.13,131.24 187.56,132.81 184.76,132.81 183.43,131.48 183.43,131.13 180.68,128.37 171.74,128.37 167.8,132.31 152.34,132.31 151.58,131.55 149.75,131.55 147.78,129.58 145.79,129.58 143.22,127.02 138.44,127.02 138.18,126.75 135.35,126.75 132.66,124.05 132.66,121.96 132.05,121.36 128.68,121.36 128.31,121.72 127.55,121.72 126.78,120.95 119.58,120.95 117.57,122.95 117.57,123.1 116.06,124.61 114.81,124.61 113.48,125.94 113,125.94 112.45,126.49 112.45,126.74 110.87,128.32 110.87,130.17 110.01,131.04 105.94,131.04 105.46,131.51 105.16,131.82 100.96,131.82 99.56,130.43 97.32,130.43 96.94,130.8 96.44,130.8 93.88,128.23 93.88,127.71 93.46,127.3 92.82,127.3 91.95,126.43 89.16,126.43 86.59,129 83.83,129 83.32,128.49 78.5,128.49 77.52,127.51 71.19,127.51 70.59,128.11 67.03,128.11 66.2,127.28 63.95,127.28 60.74,124.07 60.74,123.83 60.09,123.19 60.09,123.18 59.78,122.86 59.42,122.86 59.33,122.77 57.46,122.77 57.04,122.36 56.21,122.36 v2(55.6,121.74)
  IN3 w0.06: v2(55.6,121.74) 55.68,121.82 v7(55.68,122.13)
  IN3 w0.084: v2(210.03,126.58) 210.06,126.61 210.06,126.96 210.05,126.97 v3(210.04,126.97)
  IN4 w0.06: v7(55.68,122.13) 55.95,122.13 56.69,121.39 58.43,121.39 58.5,121.32 59.73,121.32 60.08,121.66 60.99,121.66 61.04,121.61 61.21,121.61 61.29,121.68 61.46,121.68 61.55,121.59 61.68,121.59 61.78,121.68 61.95,121.68 62.03,121.61 62.2,121.61 62.36,121.77 v5(62.36,122.13)
  IN4 w0.089: v3(210.04,126.97) 210.04,120.26 207.11,117.33 206.19,117.33 205.23,116.36 205.23,107.83 204.11,106.72 203.03,106.72 201.37,105.06 201.37,103.93 202.32,102.98 202.32,98.57 v4(202.34,98.55)
  BOTTOM w0.119: JNFC1.3 202.73,98.16 v4(202.34,98.55)
NFC_EN: length 192.9
  TOP w0.119: R162.2 216.15,106.3 216.42,106.03 U18.3 ; R162.2 215.8,106.02 215.62,105.84 U18.5 ; R162.2 215.56,106.3 215.38,106.48 215.38,107.22 215.25,107.35 v1(214.52,107.35)
  IN1 w0.084: v1(214.52,107.35) 213.93,106.76 213.93,105.87 214.71,105.1 214.71,103.93 213.79,103.01 211.64,103.01 210.81,102.19 204.3,102.19 203.78,102.72 202.56,102.72 201.59,101.74 197.42,101.74 196.63,102.53 193.14,102.53 192.51,101.89 190.66,101.89 190.15,102.41 181.1,102.41 178.39,99.71 171.78,99.71 171.09,100.4 166.24,100.4 165.47,101.16 154.55,101.16 154.55,101.16 154.39,101.16 152.26,99.03 140.29,99.03 138.8,100.51 136.79,100.51 136.07,101.23 135.94,101.36 135.75,101.55 135.08,101.55 133.79,102.84 133.79,104.81 133.93,104.95 133.93,105.76 133.86,105.83 133.86,106.28 133.45,106.69 132.41,106.69 131.88,106.16 130.84,106.16 130,105.32 115.09,105.32 112.7,102.93 112.17,102.93 110.36,101.12 106,101.12 104.74,102.39 100.72,102.39 99.25,103.85 97.69,103.85 97.48,104.07 95.61,104.07 94.37,105.31 88.36,105.31 88.11,105.06 83.86,105.06 82.17,103.37 80.11,103.37 79.22,102.48 79.12,102.48 77.57,102.48 76.55,101.46 75.55,101.46 74.85,100.75 72.62,100.75 72.2,101.17 69.19,101.17 68.79,101.57 64.91,101.57 64.73,101.75 64.73,102.06 64.01,102.78 63.38,102.78 62.15,104.01 62.15,105.81 60.62,107.34 59.95,107.34 59.04,108.26 59.04,109.53 58.17,110.4 v2(58.17,111.52)
  IN3 w0.06: v2(58.17,111.52) 58.36,111.52 58.44,111.61 58.44,111.69 v3(58.45,111.69)
  IN4 w0.06: v3(58.45,111.69) 58.67,111.92 59.21,111.92 60.92,113.63 61.21,113.63 61.29,113.55 61.5,113.55 v5(61.62,113.43)
NFC_IRQ: length 183.4
  TOP w0.119: v1(209.51,102.69) 209.23,102.69 208.76,102.23 v14(208.76,102.24) 208.62,102.1 208.62,98.5 R195.2 209.14,97.98 v1(209.14,97.37)
  IN1 w0.084: v1(209.51,102.69) 209.19,102.38 204.38,102.38 203.85,102.9 202.48,102.9 201.51,101.93 197.49,101.93 196.71,102.71 193.07,102.71 192.44,102.08 190.74,102.08 190.22,102.6 181.02,102.6 178.32,99.89 171.86,99.89 171.16,100.58 166.4,100.58 165.55,101.43 154.4,101.43 152.18,99.21 140.37,99.21 138.88,100.7 136.87,100.7 136.32,101.24 136.07,101.49 135.83,101.74 135.16,101.74 133.98,102.92 133.98,104.41 135.03,105.46 135.03,106.62 134.59,107.06 132.25,107.06 131.73,106.53 130.68,106.53 129.88,105.73 114.97,105.73 112.55,103.3 112.02,103.3 110.21,101.49 106.16,101.49 104.89,102.76 103.96,102.76 103.29,103.43 100.25,103.43 99.43,104.25 97.82,104.25 97.61,104.46 97.08,104.46 95.14,106.4 91.3,106.4 90.77,105.88 88.12,105.88 87.88,105.63 83.62,105.63 82.53,104.54 81.32,104.54 80.71,103.93 79.84,103.93 78.95,103.04 77.34,103.04 76.32,102.02 75.32,102.02 74.61,101.31 72.85,101.31 70.59,103.57 69.36,103.57 69,103.21 68.06,103.21 67.12,104.16 66.18,104.16 66.02,104.32 64.52,104.32 64.43,104.22 63.95,104.22 63.5,104.68 63.5,104.85 63.51,104.86 v2(63.5,104.86) ; v1(209.14,97.37) v2(209.5,97.37)
  IN3 w0.084: v7(63.17,105.45) 63.17,105.43 63.34,105.26 63.34,105.02 v2(63.5,104.86) ; v7(213.69,95.84) 211.04,95.84 v2(209.5,97.37)
  BOTTOM w0.06: 62.22,109.1 62.26,109.13 62.26,109.79 UC1.B8
  BOTTOM w0.119: v7(63.17,105.45) 63.17,105.91 62.91,106.17 62.82,106.17 RH109.1 62.61,106.75 61.98,107.38 61.98,108.86 62.22,109.1 ; v7(213.69,95.84) 213.61,95.76 JNFC1.16
NFC_RST#: length 196.8
  IN1 w0.084: v2(213.89,98.06) 213.65,98.06 210.85,100.86 207.03,100.86 206.63,100.47 204.92,100.47 204.69,100.24 204.38,100.24 203.9,99.76 203.4,99.76 203.12,100.05 202.4,100.05 202.13,99.78 202.13,99.76 198.23,99.76 198.11,99.88 197.82,99.88 197.71,99.76 197.24,99.76 196.06,100.94 193.66,100.94 193.07,100.35 191.25,100.35 190.48,99.58 188.27,99.58 186.92,100.93 181.71,100.93 179.67,98.88 179.67,98.28 178.57,97.18 175.37,97.18 175.06,96.87 170.92,96.87 170.02,95.98 139.02,95.98 137.51,97.49 135.54,97.49 134.91,98.12 116.59,98.12 115.47,96.99 103.81,96.99 102.38,98.42 93.51,98.42 93.4,98.31 85.77,98.31 85.4,97.94 83.66,97.94 81.31,95.59 81.31,95.37 81.14,95.21 77.84,95.21 77.41,94.78 62.55,94.78 61.85,95.48 61,95.48 60.83,95.64 59.83,95.64 58.74,96.74 56.04,96.74 54.3,98.48 51.75,98.48 v2(51.06,99.17)
  IN1 w0.109: v2(213.89,98.06) 213.92,98.03 v1(214.3,98.03)
  IN3 w0.06: v10(62.36,111.82) 62.08,111.55 61.47,111.55 61,111.08 59.85,111.08 58.77,110 58.66,110
  IN3 w0.084: v2(51.06,99.17) 51.15,99.25 51.15,101.46 50.67,101.94 50.67,102.64 50.71,102.69 50.71,104.11 50.99,104.39 51.37,104.39 52.02,105.03 52.02,105.35 52.5,105.83 52.8,105.83 53.21,106.24 53.21,106.5 53.58,106.87 53.59,106.87 54.76,106.87 55.4,107.52 55.4,107.89 57.52,110 58.66,110 ; v2(213.89,98.06) 213.89,97.48 v7(213.79,97.37)
  BOTTOM w0.119: JNFC1.8 213.78,97.36 v7(213.79,97.37)
NGFF1_CONFIG_0: length 26.6
  IN2 w0.079: v2(186.98,136.14) 187.43,136.59 192.69,136.59 194.02,137.92 194.02,139.81 194.02,141.9 196.7,144.58 202.33,144.58 202.96,143.96 v2(202.96,143.58)
  IN3 w0.084: v7(202.96,143.21) v2(202.96,143.58) ; v2(186.98,136.14) 186.98,134.46 v7(187.08,134.32)
  BOTTOM w0.119: U34.G13 188.76,134.8 187.79,134.8 187.27,134.28 R343.2
NGFF1_CONFIG_1: length 21.8
  IN3 w0.084: v3(198.55,131.46) 197.93,131.46 197.47,131.92 195.47,131.92 195.2,131.65 193.65,131.65 192.26,130.25 191.02,130.25 188.88,128.11 187.91,128.11 187.66,128.35 187.66,128.86 187.49,129.04 187.49,130.19 v7(187.15,130.52)
  IN4 w0.089: v3(198.55,131.46) 198.56,131.45 198.87,131.45 199.11,131.21 v4(201.63,131.21)
  BOTTOM w0.119: R353.2 187.26,130.55 188.45,131.74 U34.N13 ; v4(201.63,131.21) JNGFF1.61
NGFF1_CONFIG_2: length 19
  IN1 w0.084: v2(199.82,130.11) 199.36,129.66 198.2,129.66 197.77,130.09 v1(197.73,130.09)
  IN3 w0.084: v3(200.05,129.38) 200.05,129.89 v2(199.82,130.11) 199.85,130.14 199.85,130.21 199.47,130.58 199.47,130.88 199.47,131.71 198.33,132.85 195.13,132.85 194.75,133.23 193.79,133.23 193.71,133.31 193.64,133.31 193.29,133.66 193.29,133.84 191.88,135.25 190.83,135.25 v10(190.64,135.06)
  IN4 w0.089: v4(201.01,129.71) 200.38,129.71 v3(200.05,129.38)
  BOTTOM w0.119: v10(190.64,135.06) U34.G10 ; JNGFF1.67 v4(201.01,129.71)
NGFF1_CONFIG_3: length 35.8
  IN1 w0.084: v2(191.31,133.24) 190.25,133.24 189.48,134 185.57,134 184.91,134.66 184.91,135.17 185.11,135.37 185.53,135.37 188.44,138.28 188.44,139.21 191.72,142.48 195.45,142.48 196.43,143.46 v2(196.96,143.46)
  IN3 w0.084: v7(189.13,129.95) 189.13,130.92 190.82,132.61 v10(190.82,132.74) 190.82,132.76 191.15,133.09 191.16,133.09 v2(191.31,133.24) ; v2(196.96,143.46) 197.57,143.46 198.82,144.71 199.65,144.71 202.96,148.01 v7(202.96,148.21)
NGFF_COEX1: length 206.5
  IN2 w0.079: v2(45.67,150.1) 46.08,150.51 60.77,150.51 73.52,137.75 96.54,137.75 96.68,137.9 97.63,137.9 97.89,137.63 v2(98.68,137.63)
  IN3 w0.084: v2(98.68,137.63) 98.68,137.4 v3(98.94,137.15) ; v2(45.67,150.1) v7(45.19,150.1)
  IN4 w0.089: v3(98.94,137.15) 99.69,137.9 102.31,137.9 104.68,135.52 121.68,135.52 125.13,132.08 126.27,132.08 127.02,131.32 131.56,131.32 132.86,132.62 133.57,132.62 133.8,132.84 134.3,132.84 134.49,133.04 135.6,133.04 136.01,133.44 136.2,133.44 136.84,134.07 136.84,134.81 137.53,135.5 169.02,135.5 173.36,131.16 177.86,131.16 181.34,134.63 181.34,135.02 183.4,137.08 183.4,137.37 183.95,137.92 183.95,139.15 184.08,139.27 184.08,139.8 184.66,140.38 184.66,142.46 186.67,144.47 198.36,144.47 199.23,145.34 205.19,145.34 v4(205.74,145.89)
  BOTTOM w0.119: JNGFF3.48 46.34,145.64 46.13,145.43 44.7,145.43 44.48,145.66 44.48,149.39 v7(45.19,150.1) ; JNGFF1.56 208.46,132.46 207.42,133.5 207.42,143.44 206.17,144.69 206.17,145.45 v4(205.74,145.89)
NGFF_COEX2: length 208.8
  IN2 w0.079: v2(44.86,149.75) 45.94,149.75 46.47,150.28 60.73,150.28 73.47,137.54 83.7,137.54 83.8,137.44 93.35,137.44 93.47,137.56 96.6,137.56 96.76,137.72 97.55,137.72 v2(98.12,137.15)
  IN3 w0.084: v2(98.12,137.15) 98.12,137.04 v3(98.29,136.87) ; v7(44.5,150.05) 44.86,149.7 v2(44.86,149.75)
  IN4 w0.089: v3(98.29,136.87) 98.29,136.89 99.5,138.09 102.39,138.09 104.76,135.71 121.76,135.71 125.21,132.27 126.34,132.27 127.1,131.51 131.48,131.51 132.78,132.81 133.49,132.81 133.72,133.04 134.22,133.04 134.42,133.23 135.52,133.23 135.93,133.63 136.12,133.63 136.65,134.15 136.65,134.89 137.45,135.69 169.1,135.69 173.44,131.35 177.78,131.35 181.15,134.71 181.15,135.1 182.86,136.81 183.21,137.16 183.21,137.45 183.76,138 183.76,139.3 183.89,139.42 183.89,139.88 184.47,140.46 184.47,142.54 186.59,144.66 198.24,144.66 200.62,147.04 205.72,147.04 v4(206.28,146.48)
  BOTTOM w0.119: JNGFF3.46 44.61,145.14 44.17,145.58 44.17,149.72 v7(44.5,150.05) ; JNGFF1.54 208.6,132.96 207.65,133.91 207.65,143.54 206.39,144.8 206.39,146.37 v4(206.28,146.48)
NGFF_COEX3: length 209.9
  IN2 w0.079: v2(97.59,137.18) 97.22,137.54 96.83,137.54 96.68,137.38 93.54,137.38 93.43,137.26 83.72,137.26 83.63,137.36 73.4,137.36 73.37,137.39 73.36,137.39 60.65,150.1 46.86,150.1 45.83,149.06 44.86,149.06 v2(44.22,149.7)
  IN3 w0.084: v3(97.69,136.83) 97.59,136.94 v2(97.59,137.18) ; v7(43.87,150.03) 44.22,149.67 v2(44.22,149.7)
  IN4 w0.089: v4(206.43,146.84) 206.04,147.23 200.54,147.23 198.16,144.85 186.51,144.85 184.28,142.61 184.28,140.54 183.7,139.96 183.7,139.5 183.57,139.37 183.57,138.08 183.02,137.53 183.02,137.24 182.78,137 180.96,135.18 180.96,134.79 177.7,131.54 173.52,131.54 169.18,135.88 137.37,135.88 136.38,134.89 136.38,134.16 136.04,133.82 135.85,133.82 135.45,133.42 134.34,133.42 134.14,133.23 133.64,133.23 133.41,133 132.7,133 131.4,131.7 127.18,131.7 126.42,132.46 125.95,132.46 124.09,134.32 123.43,134.32 121.84,135.91 104.84,135.91 102.47,138.28 99.13,138.28 v3(97.69,136.83)
  BOTTOM w0.119: v7(43.87,150.03) 43.87,145.43 44.65,144.64 JNGFF3.44 ; JNGFF1.52 209.28,133.46 208.09,134.65 208.09,143.72 206.65,145.17 206.65,146.62 v4(206.43,146.84)
NGFF_WWAN_PWREN: length 177.2
  TOP w0.119: v1(203.31,130.48) 203.23,130.4 203.23,126.71 D6.2
  IN1 w0.084: v2(57.4,125.48) 57.47,125.55 58.05,125.55 58.63,126.13 58.87,126.13 59.03,126.29 60.82,126.29 64.49,129.97 65.72,129.97 66,130.25 70.73,130.25 70.93,130.05 71.9,130.05 72.64,129.31 75.53,129.31 76.48,130.26 77.51,130.26 78.03,130.78 86.35,130.78 87.94,132.37 89.94,132.37 90.61,131.71 92.89,131.71 93.47,132.28 97.66,132.28 97.92,132.03 98.92,132.03 99.69,132.8 104.72,132.8 105.52,133.6 109.54,133.6 112.36,130.79 112.36,129.75 114.04,128.07 116.95,128.07 117.42,127.6 118.25,127.6 119.23,126.63 122.09,126.63 122.78,125.93 126.81,125.93 127.67,125.07 130.62,125.07 131.8,126.25 132.76,126.25 135.27,128.76 136.9,128.76 138.08,129.94 140.12,129.94 140.38,130.2 143.1,130.2 143.7,130.8 145.44,130.8 145.72,130.52 146.37,130.52 147.03,131.18 147.03,131.72 148.66,133.35 152.73,133.35 153.14,132.94 168.19,132.94 172.12,129.01 180.26,129.01 182.69,131.44 182.69,132.27 183.97,133.55 187.87,133.55 189.05,132.37 193.44,132.37 194.17,133.1 195.74,133.1 196.34,132.5 196.34,129.88 196.62,129.6 196.95,129.6 197.23,129.88 197.23,130.24 197.64,130.65 200.8,130.65 200.98,130.46 203.29,130.46 v1(203.31,130.48)
  IN3 w0.06: v2(57.4,125.48) 57.15,125.72 v3(57.15,125.75)
  IN4 w0.06: v3(57.15,125.75) 58.47,124.42 59.11,124.42 59.41,124.72 60.95,124.72 61.47,124.2 v5(61.47,124.09)
OSC_IN: length 11.4
  TOP w0.119: Y1.1 137.85,127.01 C83.1 136.98,128.25 137.13,128.4 R72.1 136.19,129.73 134.59,129.73 132.98,128.12 132.98,127.76 132.05,126.82 130.72,126.82 U6.B1
OSC_OUT: length 11.9
  TOP w0.119: U6.A1 132.11,126.58 132.98,127.45 133.22,127.45 134.98,129.2 135.86,129.2 136.22,128.84 R72.2 136.22,128.41 136.12,128.31 C82.1 136.12,127.88 136.65,127.35 136.65,125.51 Y1.3
OTG_ID: length 111.7
  TOP w0.119: v1(37.67,33.61) 38,33.94 38.66,33.94 38.87,34.15 38.87,34.95 39.14,35.22 R300.2
  IN1 w0.084: v1(37.67,33.61) 37.67,33.68 37.64,33.71 37.64,34.68 37.68,34.73 37.68,36.49 v2(37.52,36.66)
  IN3 w0.084: v2(37.52,36.66) 37.52,36.76 37.05,37.23 v3(36.6,37.23)
  IN4 w0.06: 53.16,115.43 53.22,115.5 54.12,115.5 v4(54.23,115.38) 55.07,115.38 55.5,115.81 55.92,115.81 56.04,115.7 58.17,115.7 58.6,116.13 60.56,116.13 60.89,116.45 61.7,116.45 61.91,116.65 v5(62.11,116.65)
  IN4 w0.089: v3(36.6,37.23) 36.6,48.63 34.26,50.97 34.26,71.43 36.01,73.17 36.01,74.77 38.61,77.37 38.61,84.36 33.81,89.16 33.81,97.14 39.73,103.06 41.92,103.06 45.09,106.23 45.91,106.23 46.93,107.25 46.93,107.36 48.22,108.66 48.22,109.37 48.72,109.87 48.72,112.62 49.6,113.5 50.22,113.5 51.07,114.35 51.16,114.35 52.14,115.33 52.15,115.33 52.25,115.43 53.16,115.43
  BOTTOM w0.119: v4(54.23,115.38) 54.23,116.07 54,116.3 RH90.1
OUT1_CA_DET: length 1.2
  BOTTOM w0.119: R469.1 54.26,95.21 U47.43
P_SENSOR_ACT#: length 50.1
  IN2 w0.079: v2(218.19,136.39) 218.19,136.77 214.15,140.8 208.92,140.8 207.35,139.24 202.52,139.24 201.62,138.34 199.76,138.34 199.3,137.89 196.84,137.89 196.07,137.11 196.07,137.11 v2(196,137.04)
  IN3 w0.084: v7(221.57,118.12) 221.51,118.19 220.36,118.19 220.22,118.33 220.22,123.69 218.54,125.36 218.54,133.59 218.19,133.95 v2(218.19,136.39) ; v2(196,137.04) 195.85,136.89 194.24,136.89 194.15,136.98 193.72,136.98 193.58,136.84 193.58,136.83 193.56,136.81 193.56,136.64 193.32,136.4 v10(193.32,136.24)
  BOTTOM w0.119: v7(221.57,118.12) 221.32,118.12 221.27,118.08 JIO1.11
P_SYS: length 128
  TOP w0.119: v1(147.62,107.98) 147.62,107.99 147.39,108.23 145.77,108.23 PR522.1 ; v1(118.72,115.67) 118.8,115.75 118.8,116.47 118.53,116.74 117.72,116.74 117.36,117.09 v9(117.36,117.3)
  GND1 w0.084: v2(117.02,117.3) v9(117.36,117.3)
  IN1 w0.084: v2(148.26,107.29) 148.27,107.29 148.27,107.29 147.62,107.94 v1(147.62,107.98) 147.03,108.56 145.37,108.56 143.35,110.59 135.44,110.59 131.91,114.11 131.91,115.01 129.25,117.67 123.73,117.67 123.13,118.27 122.21,118.27 119.7,115.77 118.81,115.77 v1(118.72,115.67)
  IN2 w0.079: v2(199.03,107.86) 199.03,107.75 197.52,106.24 180.61,106.24 179.88,105.51 167.87,105.51 167.82,105.56 167.8,105.56 166.87,106.49 160.24,106.49 159.94,106.79 150.22,106.79 149.92,106.49 148.75,106.49 148.26,106.99 v2(148.26,107.29)
  IN3 w0.084: v3(199.08,108.45) 199.08,107.91 v2(199.03,107.86)
  GND3 w0.084: v8(116.66,117.24) 116.73,117.3 v2(117.02,117.3)
  IN4 w0.089: v8(116.66,117.24) 114.1,117.24 113.33,118 v4(113.33,118.2) ; v3(199.08,108.45) 199.03,108.5 199.03,109.19 199.25,109.41 199.25,111.89 201.79,114.43 201.79,124.28 198.67,127.4 197.72,127.4 197.46,127.66 196.43,128.69 196.43,129.25 195.92,129.76 195.85,129.76 v4(195.78,129.82)
  BOTTOM w0.119: U34.M1 195.16,131.9 195.16,130.87 195.78,130.24 v4(195.78,129.82)
PANEL_BKEN_EC: length 129.2
  IN3 w0.084: v3(202.16,126.96) 202.02,126.82 202.02,116.18 200.83,114.98 200.51,114.67 200.51,112.46 195.67,107.61 192.29,107.61 191.45,106.78 190.33,106.78 187.15,103.6 178.17,103.6 177.17,102.6 153.99,102.6 152.79,103.8 150.35,103.8 150.13,103.58 137.95,103.58 v3(137.85,103.67) ; v3(124.92,102) 124.92,102.1 124.76,102.26 122.24,102.26 121.67,102.83 121.67,103.49 121.39,103.77 119.58,103.77 v3(119.13,104.23)
  IN4 w0.089: v4(194.32,135.24) 194.85,134.71 195.16,134.71 196.31,133.56 196.31,132.23 196.75,131.79 196.75,131.48 197.38,130.84 197.38,129.72 198.57,128.53 199.9,128.53 201.47,126.96 v3(202.16,126.96) ; v4(119.13,104.71) v3(119.13,104.23) ; v3(137.85,103.67) 135.73,101.55 130.09,101.55 129.74,101.9 129.74,103.02 129.4,103.37 127.59,103.37 126.22,102 v3(124.92,102)
  BOTTOM w0.119: v4(119.13,104.71) 119.05,104.64 113.97,104.64 113.77,104.84 112.04,104.84 111.2,105.68 111.2,106.41 110.77,106.84 D37.3
PBAT_PRES#_CHR: length 70.3
  TOP w0.119: PQ150.3 184.89,103.11 184.67,102.89 183.24,102.89 182.98,103.14 182.98,104.22 183.19,104.43 184.98,104.43 185.28,104.73 185.28,105.95 184.87,106.37 182.22,106.37 182,106.59 PR151.2 181.75,107.39 181.43,107.08 180.78,107.08 180.58,107.27 180.58,108.87 181,109.29 v1(181,109.54)
  IN1 w0.084: v2(182,110.56) 181,109.57 v1(181,109.54)
  IN3 w0.084: v2(182,110.56) 182,108.84 v3(182.8,108.04)
  IN4 w0.089: v3(182.8,108.04) 180.06,105.29 175.45,105.29 174.98,105.76 159.46,105.76 158.9,105.2 158.2,105.2 157.63,105.77 155.75,105.77 155.53,105.55 153.38,105.55 152.69,104.85 151.26,104.85 150.76,105.36 149.92,105.36 147.86,103.3 144.77,103.3 144.36,103.7 144.36,104.59 142.85,106.1 140.6,106.1 v4(139.92,106.77)
  BOTTOM w0.119: PR531.1 140.08,107.58 140.08,106.93 v4(139.92,106.77)
PBAT_SMBCLK: length 87.1
  IN3 w0.084: v3(157.76,103.25) 176.9,103.25 177.9,104.25 186.88,104.25 190.06,107.43 191.18,107.43 191.95,108.19 191.95,109.64 192.28,109.97 197.11,109.97 199.86,112.73 199.86,114.94 200.56,115.63 201.3,116.38 201.3,130.36 200.93,130.73 200.93,132.94 200.15,133.73 200.15,136.57 197.4,139.32 193.85,139.32 193.77,139.4 193.48,139.4 193.14,139.74 192.26,139.74 v7(191.77,139.25) 191.69,139.16 191.69,138.62 191.62,138.55 191.62,137.39 191.82,137.18 v7(191.82,136.74)
  IN4 w0.089: v3(157.76,103.25) 157.76,103.38 157.49,103.65 157.49,104.71 v4(157.25,104.94)
  BOTTOM w0.119: PR106.2 157.63,105.43 157.25,105.04 v4(157.25,104.94)
PBAT_SMBDAT: length 87.1
  IN3 w0.084: v7(191.82,136.24) 192.08,136.5 192.08,137.78 192.18,137.87 192.36,138.06 192.36,139.02 v7(192.61,139.27) 192.89,139.27 193.51,138.65 197.41,138.65 199.67,136.39 199.67,133.54 200.43,132.79 200.43,130.58 200.84,130.17 200.84,116.57 200.36,116.1 199.4,115.13 199.4,112.92 197.67,111.2 192.41,111.2 189.85,108.63 189.85,107.88 186.69,104.72 177.71,104.72 176.71,103.72 158.03,103.72 157.76,103.99 156.88,103.99 156.37,103.48 155.98,103.48 v3(155.87,103.37)
  IN4 w0.089: v4(155.53,104.75) 155.53,103.71 v3(155.87,103.37)
  BOTTOM w0.119: v4(155.53,104.75) 155.53,104.76 PR108.2
PBTN_OUT#_R: length 14.4
  TOP w0.119: RH22.1 54.04,127.29 RH20.2 54.28,127.6 54.28,127.61 v1(54.26,127.61)
  IN1 w0.084: v2(54.03,127.87) 54.03,127.84 v1(54.26,127.61)
  IN3 w0.06: v10(63.8,122.52) 63.78,122.54 63.78,122.61 63.44,122.95 62.62,122.95 61.27,124.3
  IN3 w0.084: 61.27,124.3 60.88,124.69 60.88,124.7 57.47,128.11 57.45,128.11 57.43,128.14 56.05,128.14 55.43,128.76 54.2,128.76 54,128.56 54,127.91 v2(54.03,127.87)
PC10: length 3.5
  BOTTOM w0.119: U47.56 49.34,99.02 R448.2 49.19,99.46 49.07,99.57 48.07,99.57 47.99,99.49 R449.2
PC11: length 3.5
  BOTTOM w0.119: R451.2 47.98,98.69 48.1,98.81 49.1,98.81 49.19,98.72 R452.2 49.61,98.44 49.79,98.62 U47.55
PC20: length 4
  BOTTOM w0.119: U47.54 49.71,98.22 49.61,98.12 49.61,97.63 49.5,97.53 R456.2 49.16,97.28 49.05,97.16 48.08,97.16 47.97,97.28 R457.2
PC21: length 4.2
  BOTTOM w0.119: U47.53 50.04,97.82 49.86,97.64 49.86,97.1 49.34,96.59 R460.2 49.16,96.78 49,96.94 48.11,96.94 47.94,96.78 47.94,96.61 R461.2
PCH_DDI1_AUXN: length 118.7
  IN1 w0.109: v2(33.87,51.03) v1(33.41,51.03)
  IN2 w0.079: v2(33.87,51.03) 34.02,51.18 34.21,51.18 34.5,51.46 34.5,54.02 32.09,56.43 23.97,56.43 21.23,59.17 21.23,65.94 19.99,67.19 19.99,81.87 24.1,85.98 24.1,87.02 26.49,89.41 26.75,89.41 34.42,97.09 34.87,97.09 40.05,102.27 46.9,102.27 48.49,100.68 53.88,100.68 55.13,99.43 61.87,99.43 62.6,98.71 67.48,98.71 68.57,99.8 70.99,99.8 72.54,101.34 73.08,101.34 73.62,101.88 73.71,101.97 v2(73.79,101.97)
  IN3 w0.06: 74.58,104.84 74.58,104.85 74.55,104.88 74.55,104.9 74.54,104.91 74.54,105.87 74.75,106.08 74.75,107.26 73.15,108.85 73.15,109.89 72.7,110.34 72.7,110.77 72.5,110.98 v10(72.5,111.18)
  IN3 w0.084: 74.58,104.84 74.58,103.79 74.62,103.74 74.62,102.89 74.2,102.47 74.2,102.39 v2(73.79,101.97)
PCH_DDI1_AUXN_C: length 1.7
  TOP w0.119: UV2.29 31.11,51.04 32.82,51.04 CV34.2
PCH_DDI1_AUXP: length 118.7
  IN1 w0.109: v2(33.88,51.77) 33.88,51.55 33.79,51.46 33.55,51.46 v1(33.42,51.59)
  IN2 w0.079: v2(73.75,102.52) 73.44,102.21 73.44,101.96 73,101.53 72.46,101.53 70.92,99.98 68.5,99.98 67.4,98.89 62.68,98.89 61.95,99.62 55.21,99.62 53.96,100.86 48.57,100.86 46.98,102.45 39.97,102.45 34.79,97.27 34.34,97.27 26.67,89.6 26.41,89.6 23.92,87.1 23.92,86.06 19.81,81.94 19.81,67.11 21.05,65.86 21.05,59.09 23.89,56.24 32.02,56.24 34.32,53.94 34.32,51.54 34.16,51.39 33.85,51.39 33.76,51.48 33.76,51.64 v2(33.88,51.77)
  IN3 w0.06: v10(72.5,110.69) 72.58,110.61 72.58,110.29 73.03,109.84 73.03,108.8 74.63,107.21 74.63,106.13 74.42,105.92 74.42,104.84
  IN3 w0.084: 74.42,104.84 74.42,103.72 74.46,103.67 74.46,102.96 74.02,102.52 v2(73.75,102.52)
PCH_DDI1_AUXP_C: length 1.7
  TOP w0.119: CV36.2 32.79,51.54 UV2.30
PCH_DDI1_CLK: length 12.8
  IN4 w0.06: 58.65,105.63 58.9,105.88 58.9,108.1 59.24,108.44 59.24,109.86 60.88,111.5 61.52,111.5 61.84,111.82 v5(61.87,111.82)
  IN4 w0.089: 58.65,105.63 57.84,104.82 57.25,104.82 57.08,104.64 55.79,104.64 v4(55.14,104)
  BOTTOM w0.119: v4(55.14,104) 55.14,104.13 RC89.2
PCH_DDI1_DAT: length 13.5
  IN4 w0.06: v5(61.87,111.18) 61.67,111.38 60.93,111.38 59.36,109.81 59.36,108.39 59.02,108.05 59.02,105.6 58.8,105.39
  IN4 w0.089: 58.8,105.39 57.61,104.19 56.82,104.19 56.56,104.45 56.13,104.45 v4(55.68,104)
  BOTTOM w0.119: v4(55.68,104) 55.68,104.38 54.94,105.12 RC85.2
PCH_DDI1_N0: length 108.3
  IN1 w0.109: v2(29.9,58.03) 29.7,58.03 29.63,57.96 29.63,57.6 29.68,57.55 v1(29.84,57.55)
  IN2 w0.079: v2(29.9,58.03) 29.66,58.03 29.57,57.94 29.57,57.67 29.67,57.57 30.05,57.57 30.27,57.78 30.27,58.37 30.12,58.52 30.12,60.82 22.18,68.75 22.18,80.9 26.4,85.11 26.4,85.6 39.26,98.47 42.8,98.47 43.39,97.88 46.61,97.88 47.2,98.47 49.96,98.47 50.33,98.09 51.38,98.09 51.65,98.36 53.06,98.36 54.14,97.27 60.99,97.27 62.22,96.04 62.79,96.04 62.98,96.23 62.98,96.52 63.28,96.82 64.2,96.82 64.65,96.37 68.9,96.37 69.11,96.58 69.93,96.58 70.79,97.44 71.93,97.44 72.7,98.22 73.58,98.22 75.53,100.17 75.99,100.17 76.37,100.55 76.37,101.4 77.36,102.39 77.36,103.69 76.88,104.16 75.61,104.16 75.48,104.3 75.33,104.3 v2(74.98,103.95)
  IN3 w0.084: v2(74.98,103.95) v3(75.31,103.95)
  IN4 w0.06: v5(74.11,109.43) 74.19,109.35 74.19,108.85 74.72,108.31 74.72,107.84 75.02,107.55 75.02,106.7 75.39,106.32 75.39,105.13 74.92,104.66 74.92,104.4 75.06,104.27 75.46,104.27 75.55,104.18 75.55,104.03 75.48,103.95 v3(75.31,103.95)
PCH_DDI1_N0_C: length 1.7
  TOP w0.119: CV31.2 29.7,56.81 29.7,56.24 29.69,56.24 29.69,56.06 29.81,55.94 UV2.38
PCH_DDI1_N1: length 107.9
  IN1 w0.109: v1(28.35,57.52) 28.23,57.41 28.23,57.12 28.23,57.12 v2(28.4,56.95)
  IN2 w0.079: v2(28.4,56.95) 28.24,57.11 28.24,57.34 27.94,57.64 27.33,57.64 26.89,57.19 24.01,57.19 21.8,59.4 21.8,66.41 20.57,67.65 20.57,81.58 24.76,85.78 24.76,86.86 26.71,88.8 26.95,88.8 34.64,96.49 35.08,96.49 40.29,101.7 46.63,101.7 48.22,100.11 53.6,100.11 54.87,98.84 61.68,98.84 62.27,98.25 67.89,98.25 68.84,99.2 71.3,99.2 72.75,100.66 73.47,100.66 74.28,101.46 v2(74.47,101.66)
  IN3 w0.084: v2(74.47,101.66) 74.61,101.79 v3(74.9,101.79)
  IN4 w0.06: v5(74.75,109.95) 74.76,109.94 74.76,109.71 74.95,109.52 74.95,109.52 74.95,109.35 74.95,109.35 74.95,109.33 75.44,108.84 75.44,108.07 75.81,107.7 75.81,107 76.23,106.58 76.23,105.82 76.52,105.53 76.52,104.96 76.62,104.87
  IN4 w0.089: v3(74.9,101.79) 75.73,101.79 76.01,102.07 76.01,102.52 76.7,103.2 76.7,104.63 76.62,104.7 76.62,104.87
PCH_DDI1_N1_C: length 1.7
  TOP w0.119: UV2.41 28.31,55.94 28.19,56.06 28.19,56.78 CV29.2
PCH_DDI1_N2: length 105.7
  IN1 w0.109: v1(26.85,57.55) 26.66,57.74 26.66,57.82 v2(26.9,58.06)
  IN2 w0.079: v2(26.9,58.06) 26.64,58.06 26.58,58.12 26.58,58.46 26.39,58.65 26,58.65 25.62,58.28 25.62,58.01 25.37,57.76 24.25,57.76 22.82,59.19 22.82,66.28 21.18,67.93 21.18,81.36 25.35,85.54 25.35,86.59 26.91,88.15 27.14,88.15 34.85,95.87 35.27,95.87 38.04,98.64 40.02,100.62 43.92,100.62 45.67,98.86 46.23,98.86 46.81,99.44 48.7,99.44 48.79,99.53 53.36,99.53 54.64,98.25 61.46,98.25 61.89,97.82 68.44,97.82 69.18,98.56 71.55,98.56 73.01,100.02 73.75,100.02 75.13,101.4 75.13,102.35 74.65,102.84 74.65,102.96 74.79,103.11 75.04,103.11 v2(75.26,102.89)
  IN3 w0.084: v2(75.26,102.89) 75.13,103.01 75.05,103.01 v3(74.92,102.89)
  IN4 w0.06: v5(73.78,109.71) 73.78,108.91 74.45,108.25 74.45,107.75 74.69,107.51 74.69,105.57 74.54,105.42 74.54,103.83 74.33,103.62 74.33,103.37 74.54,103.17 74.88,103.17 74.98,103.07 74.98,102.94 v3(74.92,102.89)
PCH_DDI1_N2_C: length 1.7
  TOP w0.119: UV2.44 26.81,55.94 26.69,56.06 26.69,56.8 CV27.2
PCH_DDI1_N3: length 101.8
  IN1 w0.109: v1(25.45,57.52) 25.12,57.85 25.12,58.17 v2(25.23,58.28)
  IN2 w0.079: v2(25.23,58.28) 25.23,58.29 24.99,58.52 24.99,61.89 25.22,62.12 25.22,64.7 21.77,68.15 21.77,81.03 26.01,85.27 26.01,85.77 39.2,98.95 42.86,98.95 43.55,98.26 46.44,98.26 47.03,98.85 50.36,98.85 50.58,98.64 51.36,98.64 51.49,98.76 53.25,98.76 54.33,97.68 61.22,97.68 61.65,97.25 68.62,97.25 69.33,97.96 71.84,97.96 73.08,99.2 73.83,99.2 75.98,101.34 75.98,101.86 76.91,102.8 76.91,103.14 76.63,103.42 76.33,103.42 v2(76.12,103.62)
  IN3 w0.084: v3(75.72,103.49) 75.63,103.58 75.63,103.72 75.72,103.81 75.93,103.81 v2(76.12,103.62)
  IN4 w0.06: v5(74.43,109.71) 74.43,109.03 75.01,108.45 75.01,107.91 75.35,107.58 75.35,106.87 75.76,106.47 75.76,105.63 76.03,105.36 76.03,104.71 75.86,104.55 75.86,103.97 76.05,103.79 76.05,103.42 76,103.37 75.84,103.37 v3(75.72,103.49)
