# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N19014058: length 0.9
  BOTTOM w0.254: PR1150.2 PC1150.1
N19043300:
  vias: v1(105.75,106.94) v1(106.12,106.94) v1(109.88,113.45) v1(109.91,113.1)
N19043343:
  vias: v1(107.21,106.3) v1(107.21,106.01) v1(109.45,108.37) v1(109.74,108.37)
N19063627: length 2.4
  TOP w0.508: PR1138.2 103.78,115.48 104.03,115.24 PC1126.1
N19378285: length 1.1
  IN1 w0.084: v2(203.48,133.71) 203.9,134.13 v1(204,134.13)
  IN3 w0.084: v7(203.07,133.71) v2(203.48,133.71)
N19378292: length 1.4
  IN1 w0.084: v2(202.63,133.7) 202.19,133.7 v1(201.94,133.95)
  IN3 w0.084: v7(202.96,133.21) 202.63,133.54 v2(202.63,133.7)
N19378299: length 0.7
  IN1 w0.084: v2(202.54,132.68) v1(202.16,132.68)
  IN3 w0.084: v7(202.87,132.7) 202.84,132.68 v2(202.54,132.68)
N19378306: length 1.1
  IN1 w0.084: v1(203.73,132.7) v2(203.33,132.7)
  IN3 w0.084: v7(202.96,132.21) 202.96,132.33 v2(203.33,132.7)
N19388147: length 11.7
  TOP w0.119: v1(57.05,124.5) 57.05,124.5 RH26.1
  IN1 w0.084: v2(56.98,125.13) 57.05,125.06 v1(57.05,124.5)
  IN3 w0.06: v10(64.12,121.29) 64.12,121.49 63.86,121.76 63.79,121.76 63.59,121.96 63.59,122.07 63.35,122.31 63.06,122.31 62.79,122.59 61.94,122.59 60.76,123.76 60.76,124.28
  IN3 w0.084: 60.76,124.28 59.99,125.06 59.51,125.06 59.31,124.86 59.31,124.69 59.04,124.42 58.81,124.42 58.81,124.42 58.62,124.42 58.38,124.42 58.08,124.72 57.82,124.72 57.62,124.93 57.18,124.93 v2(56.98,125.13)
N20063017: length 1.8
  TOP w0.119: R68.1 191.12,129.8 Q6.1
N20421956: length 9.4
  IN3 w0.254: v7(119.82,107.2) 119.82,112 121.36,113.54 v7(121.36,113.99)
  BOTTOM w0.119: PC403.2 119.19,107.2 v7(119.82,107.2) 119.83,107.19 PR402.1
N20422037: length 10.3
  BOTTOM w0.254: PR402.2 119.83,105.33 120.23,104.93 125.91,104.93 126.47,105.49 126.48,105.49 PU400.16
N20422092: length 3.6
  BOTTOM w0.119: PU400.6 126.98,112.16 127.2,112.38 128.96,112.38 129.18,112.61 PC412.1
N20422163: length 5.8
  BOTTOM w0.305: 125.03,112.27 125.03,111.15 124.98,111.1 124.98,110.71 125.24,110.44 PU400.3
  BOTTOM w0.381: PR404.2 123.77,114.54 124.12,114.2 124.12,113.63 PC410.1 125.03,112.72 125.03,112.27
N20422204: length 1.3
  BOTTOM w0.508: PR401.2 124,112.21 PC407.1
N20422218: length 3
  BOTTOM w0.119: PU400.5 126.48,112.12 126.97,112.61 128.07,112.61 128.3,112.83 PR408.1
N20604762: length 3.1
  TOP w0.119: R171.2 70.17,101.83 70.17,100.77 70.31,100.63 70.79,100.63 70.93,100.76 UH2.1
N20604774: length 3.5
  TOP w0.119: UH2.2 71.58,100.55 71.43,100.4 70.08,100.4 R186.2 69.67,100.82 R176.2
N21063245: length 5.2
  TOP w0.119: U2.27 52.76,135.45 53.03,135.17 55.28,135.17 55.54,135.42 R26.1
N21436900: length 14.4
  IN3 w0.084: v7(27.84,101.18) 27.7,101.32 27.7,107.29 28.5,108.09 v7(28.5,108.12)
  BOTTOM w0.119: v7(27.84,101.18) 27.79,101.18 26.28,99.67 JNGFF2.68 ; R409.1 26.7,108.34 26.94,108.09 28.47,108.09 v7(28.5,108.12)
N21485499: length 15.3
  BOTTOM w0.119: PR134.1 PC123.1 208.43,114.89 PQ112.1 205.76,113.42 203.2,110.85 PR132.2 203.19,110.42 198.56,110.42 197.59,111.39 PU101.4
N21528803: length 7.1
  TOP w0.254: PR116.2 38.19,30.43 PC116.2 39.07,31.32 PR122.1 39.42,31.68 39.42,32.31 39.64,32.53 42.29,32.53 42.77,32.04 PQ104.4
N21616317: length 1.2
  TOP w0.254: PC811.1 177.07,116.07 PR816.2
N21618541: length 1.5
  BOTTOM w0.508: PR604.2 192.89,118.48 PC611.1
N21620615: length 2.7
  BOTTOM w0.254: PU600.12 191.58,111.62 191.96,111.25 191.96,110.73 192.32,110.37 PR606.2
N21622453: length 1.1
  BOTTOM w0.508: PC603.1 193.98,114.09 PR603.2
N21624147: length 5.4
  BOTTOM w0.508: PR609.1 31.79,114.48 PC615.2 31.22,117.99 PL603.1
N21624161: length 1.2
  BOTTOM w0.508: PR609.2 34.16,114.26 PC614.1
N21624470: length 11.4
  IN4 w0.305: v4(29.11,115.33) 28.54,115.9 26.82,115.9 26.38,116.35 26.38,117.05 26.03,117.39 24.57,117.39 24.26,117.71 24.26,120.45 v4(24.82,121.04)
  BOTTOM w0.254: PU601.9 28.42,116.27 29.11,115.59 v4(29.11,115.33)
N21624512: length 1.1
  BOTTOM w0.508: PR617.2 30.29,113.57 PC615.1
N21624514: length 3.8
  BOTTOM w0.254: 29.64,117.44 29.38,117.7 PU601.8
  BOTTOM w0.508: 29.64,117.44 29.64,116.27 30.15,115.76 PR617.1
N21628480: length 3.5
  TOP w0.508: v13(124.97,122.65) 124.51,122.65 124.17,122.99 PR703.1
  BOTTOM w0.508: PL701.1 125.28,124.04 PC705.2
N21628490: length 3.2
  BOTTOM w0.254: PU700.13 128.24,119.36 PR706.1 128.31,119.29 PR704.2 128.31,121.05 PC720.2
N21630461:
  vias: v1(122.59,117.96) v1(123.13,117.87) v2(122.21,117.68) v7(122.45,117.13) v7(122.71,117.13)
N21632067: length 1.4
  BOTTOM w0.254: PC715.1 122.72,119.86 PU700.7
N21636311: length 1.2
  TOP w0.508: PC1005.1 34.72,109.41 35.61,109.41 PR1003.2
N21637474: length 2.9
  BOTTOM w0.254: PU700.10 125.95,121.4 126.13,121.58 126.27,121.58
  BOTTOM w0.508: 126.27,121.58 127.01,122.33 PR711.1
N21637478: length 1.4
  BOTTOM w0.508: PC705.1 127.86,123.41 128.28,122.99 PR711.2
N21669783: length 1.7
  TOP w0.119: PR122.2 38.15,32.14 37.95,32.34 PQ105.1
N21685485: length 3.5
  TOP w0.119: US1.16 28.37,61.17 28.47,61.06 30.07,61.06 R249.1
N21700377: length 1.3
  TOP w0.508: PC920.1 179.4,109.94 PR912.2
N21700486: length 3.6
  TOP w0.203: PR914.2 172.34,101.11 PR922.1 172.36,101.12 172.36,103.09 172.5,103.23 173.03,103.23 PU901.8
N21703150: length 3.1
  TOP w0.119: PC118.1 31.32,31.28 PR125.2 ; PC118.1 32.16,32.15 PR126.1 ; PC118.1 31.13,32.15 30.84,32.43 PU100.6
N21703157: length 6.8
  TOP w0.119: PC119.1 31.29,29.56 PR121.2 30.86,30.8 30.86,31.66 30.74,31.78 PU100.5 29.56,31.78 28.52,30.75 PR127.1 PR138.1
N21708061: length 3.6
  TOP w0.254: PR826.1 40.26,140.88 PU808.9 ; PR826.1 38.89,141.42 PR825.2 ; PR826.1 PR822.2
N21768495: length 7.8
  BOTTOM w0.254: PC120.1 PR128.1 201.09,114.59 PQ107.2 201.17,114.9 PR129.1
N21768525: length 4.9
  BOTTOM w0.254: 200.5,118.66 198.84,118.66 PQ108.2 198.38,119.69 197.81,120.26 PR133.2 PR131.2
N21768527: length 2.3
  BOTTOM w0.254: PQ109.6 199.98,119.31 PR133.1
N21768616: length 8
  BOTTOM w0.254: PR130.2 PC114.2 206.54,117.33 206.1,117.77 206.1,119.22 205.74,119.58 204.73,119.58 204.55,119.4 204.55,118.89 204.32,118.66 202.4,118.66
N21768629: length 1
  BOTTOM w0.254: PQ109.3 203.36,118.01 PR129.2
N21778821: length 4.9
  GND1 w0.254: v9(117.46,118.99) 117.34,119.12 116.43,119.12 116.28,118.96 v2(116.28,118.81)
  GND3 w0.084: v8(115.82,119.09) 116,119.09 v2(116.28,118.81)
  IN4 w0.06: 115.05,119.42 114.6,118.96 113.75,118.96 113.49,118.7 v4(113.33,118.7)
  IN4 w0.089: 115.05,119.42 115.5,119.42 v8(115.82,119.09)
N21803687: length 1.3
  BOTTOM w0.254: U41.8 116.17,106.87 R417.1
N21803690: length 1.7
  BOTTOM w0.254: R410.1 117.79,108.6 U41.7
N21803695: length 1.2
  BOTTOM w0.254: U41.1 113.79,107.94 C301.1
N21976735: length 1.7
  TOP w0.119: U25.18 27.09,78.01 27.58,78.5 27.79,78.5 27.89,78.6 R209.1
N22181900: length 1.4
  TOP w0.254: U17.6 150.93,103.09 C166.1
N22436994: length 9.3
  TOP w0.119: U32.F2 37.19,41.87 v1(37.29,41.77)
  IN1 w0.084: v1(37.29,41.77) 37.29,43.37 37.32,43.4 37.51,43.59 37.51,50.41 v1(37.58,50.49)
N22437505: length 6.6
  TOP w0.119: R256.1 38.53,46.17 38,45.63 38,44.06 37.19,43.25 U32.F1
N22440570: length 1.7
  TOP w0.119: U32.E11 37.69,37.05 38.2,36.54 R298.1
N22441485: length 10.3
  IN1 w0.084: v1(36.19,39.66) 35.95,39.91 35.95,41.37 36.04,41.47 36.04,43.55 36.44,43.95 36.44,47.7 35.71,48.43 35.2,48.43 v1(34.93,48.7)
N22441497: length 16.1
  TOP w0.119: v1(40.74,45.64) 40.68,45.7 R496.1 41.11,46.08 41.24,46.21 R484.1 ; v1(37.31,36.2) 37.43,36.33 37.43,37.56 37.43,37.92 U32.F10
  IN1 w0.084: v1(40.74,45.64) 40.79,45.69 40.79,46.14 v2(40.78,46.15) ; v1(37.31,36.2) v2(37.31,35.84)
  IN2 w0.079: v2(40.78,46.15) 40.78,44.2 38.56,41.98 38.56,37 37.4,35.84 v2(37.31,35.84)
N22441511: length 7.9
  TOP w0.119: v1(36.52,41.6) 36.69,41.76 U32.G2
  IN1 w0.084: v1(36.52,41.6) 36.52,43.46 36.81,43.75 36.81,48.6 v1(36.73,48.68)
N22442963: length 0.6
  TOP w0.119: TC23.1 R301.2
N22443085: length 1.4
  TOP w0.119: R257.2 40.24,50.46 TC19.1
N22483897: length 3.4
  TOP w0.119: R50.2 C61.2 143.04,130.3 143.01,130.28 R65.1 143.48,129.37 U9.2
N22869055: length 0.7
  IN1 w0.084: v2(63.52,114.02) 63.52,114.12 v1(63.31,114.33)
  IN3 w0.06: v10(63.35,113.75) 63.35,113.84 v2(63.52,114.02)
N22869056: length 2.5
  IN1 w0.084: v2(61.52,113.37) 61.52,112.92 62.22,112.22 v1(62.22,112.12)
  IN3 w0.06: v10(62.36,113.75) 61.97,113.37 v2(61.52,113.37)
N22869057: length 5.8
  IN4 w0.06: v5(61.13,114.08) 60.85,114.08 59.05,112.28 57.02,112.28 56.98,112.32 56.28,112.32 v4(56.16,112.44)
N22869058: length 1.5
  IN1 w0.084: v2(63.68,114.66) 63.9,114.43 v1(63.9,114.32)
  IN3 w0.06: v10(63.1,114.08) 63.1,114.51 63.25,114.66 v2(63.68,114.66)
N22873097: length 3.9
  BOTTOM w0.119: R412.2 88.75,108.05 88.86,107.94 89.88,107.94 90.17,107.65 90.17,107.01 90,106.85 U45.2
N22924834: length 1.7
  TOP w0.119: U3.6 48.55,138.61 C12.1
N23227151: length 4.8
  TOP w0.254: PU808.8 41.31,138.97 41.45,139.11 41.45,140.6 41.95,141.11 PR807.2 42.82,141.44 PR828.1 PR827.2
N23229153: length 2.4
  TOP w0.203: PU901.9 173.83,102.43 173.83,101.87 174.16,101.54 PR921.1 PR920.2
N23229941: length 1.2
  TOP w0.254: PR1006.2 119.27,116.45 PC1501.1
N23234515: length 0.9
  TOP w0.305: PR1129.1 PC1121.2
N23244273: length 6.7
  TOP w0.254: 66.75,114.47 66.75,108.35
  BOTTOM w0.254: v4(67.54,115.66) 67.54,115.38 67.54,115.38 67.54,115.38 v12(67.54,115.11)
  vias: v1(66.75,115.26) v1(66.75,114.98) v1(66.75,107.76) v1(66.75,107.46) v2(66.4,107.38) v2(67.21,115.11) v7(65.86,106.3) v7(66.31,106.42) v8(67.54,115.36)
N23256891: length 3.9
  BOTTOM w0.076: 89.66,123.36 89.66,124.06 U35.B11
  BOTTOM w0.119: 89.66,123.36 89.66,123.18 90.45,122.39 R392.1
N23436283: length 1.6
  TOP w0.119: U24.4 75.68,101.04 75.89,101.26 75.89,101.64 75.97,101.72 R178.1
N23436874: length 2.1
  TOP w0.119: R170.1 78.32,101.53 U23.4
N23552678: length 1.6
  BOTTOM w0.119: RC127.2 78.24,100.32 JXDP1.9
N23877759: length 31
  TOP w0.119: Q8.2 140.46,128.87 140.78,128.55 R84.1 140.78,127.45 R95.2 141.06,127.43 141.2,127.29 141.2,123.21 139.83,121.83 136.91,121.83 135.43,120.36 127.19,120.36 126.1,121.45 v1(126.1,122.15)
  IN1 w0.084: v2(129.11,124.34) 129.08,124.31 128.85,124.31 128.11,123.57 127.51,123.57 126.89,122.95 126.89,122.8 126.89,122.71 126.34,122.15 v1(126.1,122.15)
  IN3 w0.084: v2(129.11,124.34) 129.09,124.32 128.9,124.32 v7(128.73,124.15)
  BOTTOM w0.119: v7(128.73,124.15) 128.73,125.87 R481.2 R480.2
N23878175: length 4.4
  TOP w0.119: R94.2 140.2,127.45 R84.2 140.16,128.09 R87.1 139.6,129.58 140.46,130.44 Q8.5
N23878217: length 4
  TOP w0.119: Q8.6 139.96,130.27 139.26,129.57 139.26,127.61 139.36,127.51 R87.2
N23948092: length 1.5
  TOP w0.119: UV2.2 22.88,54.04 CV24.1
N23948138: length 1.4
  TOP w0.119: RV22.1 22.75,51.54 UV2.7
N23949763: length 1.7
  TOP w0.119: R235.1 37.61,58.52 37.75,58.66 U27.7
N24004976: length 13.2
  TOP w0.119: PU151.2 182.41,112.77 182.41,112.15 182.21,111.96 181.1,111.96 PR156.2 180.76,113.24 180.76,115.61 181.1,115.95 183.62,115.95 184.2,115.37 184.2,114.18 184.96,113.42 PU150.2
N24005002: length 3
  TOP w0.119: PQ151.1 182.55,114.82 PR152.2 181.91,114.18 PU151.3
N24005016: length 6
  TOP w0.119: PR157.2 PR152.1 182.54,115.73 183.53,115.73 183.98,115.28 183.98,113.91 184.46,113.44 PU150.3
N24005089: length 2.4
  TOP w0.119: PU150.7 184.96,108.52 PC150.1 184.86,107.46 PR154.2
N24005136: length 15.3
  TOP w0.119: PQ150.2 184.24,104.02 184.43,104.21 185.07,104.21 185.51,104.64 185.51,106.04 184.96,106.59 183.62,106.59 183.43,106.78 183.43,108.7 183.96,109.23 PU150.5 183.96,110.77 183.67,111.06 181.41,111.06 ; 181.41,111.06 181.41,110.08 PU151.5 ; 181.41,111.06 180.61,111.06 180.26,110.71 PR153.1
N24005175: length 3.5
  TOP w0.119: PR155.2 181.16,108.41 PC151.1 181.13,108.85 181.33,109.06 182.15,109.06 182.41,109.32 PU151.7
N24036540: length 2.7
  TOP w0.119: U27.5 36.37,60.77 v14(35.84,60.24) 34.86,59.26 R231.2
N24036598: length 2
  TOP w0.119: UV2.26 31.11,49.54 31.87,49.54 32.23,49.18 R242.2
N24116145: length 16.2
  TOP w0.06: 130.94,127.14 130.7,127.38 U6.C1
  TOP w0.119: v1(132.79,128.69) 132.49,128.39 132.49,127.6 131.94,127.05 131.03,127.05 130.94,127.14
  IN1 w0.084: v1(132.79,128.69) 132.78,128.7 130.31,128.7 130.19,128.58 129.63,128.58 129.55,128.49 128.94,128.49 128.47,128.02 127.14,128.02 127.04,127.92 125.99,127.92 125.54,127.92 125.09,128.38 122.96,128.38 122.85,128.48 122.36,128.48 v1(121.16,129.68)
N24124597: length 4.9
  BOTTOM w0.254: PR829.2 169.29,114.85 PR824.2 169.21,114.05 PR830.1 167.82,114.04 PC823.1 166.52,114.04 166.26,114.3 PQ800.2
N24124612: length 1.1
  BOTTOM w0.254: PR823.2 169.26,115.78 PQ800.1
N24309746: length 3.9
  BOTTOM w0.254: Q15.1 205.32,117.92 205.64,117.6 205.64,116.27 R400.2
N24314377: length 5.2
  IN4 w0.06: v4(59.27,122.51) 59.82,122.51 60,122.69 60.61,122.69 60.72,122.57 60.96,122.57 61.04,122.65 61.23,122.65 61.23,122.65 61.7,122.65 61.87,122.49 v5(61.87,122.13)
  BOTTOM w0.06: T22.1 57.63,123.36 58.37,122.62 59.15,122.62 v4(59.27,122.51)
N24314941: length 4.5
  IN1 w0.084: v2(60.9,112.91) 61.32,112.49 61.32,111.7 61.64,111.39 v1(61.73,111.39)
  IN3 w0.06: v10(63.1,112.79) 63.1,112.87 62.86,113.11 62.32,113.11 62.01,112.8 61.01,112.8 v2(60.9,112.91)
N24394551: length 8.5
  TOP w0.119: JHDMI1.15 11.25,52.75 11.25,52.75 v14(13.42,52.75) 14.51,52.75 v1(14.55,52.8)
  IN1 w0.109: v2(14.91,52.75) 14.6,52.75 v1(14.55,52.8)
  IN3 w0.084: v2(14.91,52.75) v3(15.27,52.75)
  IN4 w0.089: v4(18.36,53.05) 17.84,52.52 16.93,52.52 16.6,52.86 16.08,52.86 15.97,52.75 v3(15.27,52.75)
N24397508: length 1.5
  TOP w0.119: C23.1 197.84,137.62 U1.1
N24402677: length 9.9
  IN1 w0.084: v1(35.9,50.51) 37,49.41 37,43.68 36.96,43.64 36.81,43.48 36.81,41.29 v1(36.69,41.17)
N24402691: length 9.6
  IN1 w0.084: v1(37.19,41.17) 37.19,41.47 37.03,41.63 37.03,43.41 37.18,43.56 37.18,50.16 v1(36.83,50.51)
N24403083: length 9.7
  TOP w0.119: v1(37.67,41.67) 37.67,42.15 U32.E2
  IN1 w0.084: v1(37.67,41.67) 37.67,41.75 37.49,41.93 37.49,43.27 37.72,43.5 37.72,50.04 v1(38.16,50.49)
N24433875: length 2.1
  IN1 w0.762: 215.06,101.6 215.06,100.72 214.2,99.86
  vias: v1(213.03,99.63) v1(213.17,99.39) v1(213.33,99.61) v1(214.83,102.5) v1(215.03,102.31) v1(215.22,102.51)
N24433899: length 1.5
  TOP w0.203: C171.1 216.69,102.29 216.42,102.56 U18.12
N24433917: length 1.5
  TOP w0.203: U18.10 215.62,102.45 215.8,102.27 C170.1
N24468854: length 2.4
  IN1 w0.084: v1(35.19,41.17) 35.12,41.17 34.59,41.7 34.01,41.7 v1(33.31,42.4)
N24544896: length 2.8
  TOP w0.508: PR904.1 32.49,124.5 v13(32.61,124.37)
  BOTTOM w0.508: PC901.2 32.72,124.26 v13(32.61,124.37)
N24544907: length 1.3
  TOP w0.508: PR904.2 32.05,123.13 PC911.1
N24545121: length 1.3
  BOTTOM w0.254: PR911.2 27.8,124.02 PU900.12
N24545155: length 9.8
  IN4 w0.305: v4(26.21,128.67) 25.72,128.17 25.72,127.13 26.77,126.08 26.77,124.88 28.22,123.44 29.18,123.44 v4(29.75,124.01)
  BOTTOM w0.254: PU900.9 29.3,124.62 29.75,124.17 v4(29.75,124.01)
N24545187: length 3.5
  BOTTOM w0.254: PU900.8 30.08,126.39 30.42,126.04
  BOTTOM w0.508: 30.42,126.04 30.78,125.69 PR903.1
N24545189: length 1.1
  BOTTOM w0.508: PR903.2 31.07,122.53 PC901.1
N24580839: length 2.2
  TOP w0.119: TC81.1 v1(63.33,116.18)
  IN1 w0.084: v1(63.33,116.18) 63.33,116.07 63.59,115.82 63.59,115.8 v2(63.84,115.55)
  IN3 w0.06: v2(63.84,115.55) 63.59,115.8 63.59,115.87 v6(63.39,116.08)
  IN4 w0.06: v4(63.35,116.33) 63.35,116.12 v6(63.39,116.08)
N24707410: length 1.2
  BOTTOM w0.508: PR1134.1 111.42,123.97 PC1123.2
N24707520: length 1.6
  BOTTOM w0.508: PC1124.1 111.7,115.01 PR1135.2
N24907719: length 0.9
  BOTTOM w0.254: PR1120.2 PC1115.1
N24910627: length 0.9
  BOTTOM w0.254: PR1147.2 115.73,122.47 PC1131.1
N24919089: length 0.9
  BOTTOM w0.254: PC1132.1 114.73,114.85 114.73,115.61
N25217210: length 1.9
  BOTTOM w0.254: PC630.1 192.57,113.12 PU600.9
N25374813: length 2.3
  IN1 w0.084: v2(196.01,99) 196.29,98.72 v1(196.52,98.72)
  IN3 w0.084: v7(195.45,98.86) 195.59,99 v2(196.01,99)
  BOTTOM w0.119: JUSH1.17 195.43,99.33 195.45,99.31 v7(195.45,98.86)
N25375076: length 3.2
  TOP w0.119: v14(204.57,100.33) 203.82,99.58 v1(202.59,99.58)
  IN1 w0.084: v1(202.59,99.58) v2(203.07,99.58)
  IN3 w0.084: v2(203.07,99.58) 202.93,99.73 v7(202.93,99.9)
N25377540: length 2.5
  BOTTOM w0.119: UV3.6 20.24,57.12 20.62,56.73 C342.1 v14(21.67,56.25)
N25410508: length 14.4
  TOP w0.254: PQ1500.1 179.86,115.45 178.5,116.8 176.15,116.8 175.65,117.3 175.65,118.73 176.24,119.32 179.15,119.32 180.12,118.35 PU1500.3 181.66,118.35 PR1501.2
N25410589: length 30.8
  TOP w0.254: v1(178.29,117.35) 178.94,117.35 179.66,116.63 182.7,116.63 PR1503.1
  TOP w0.508: PR1501.1 PR1502.1 PR1503.1
  IN1 w0.254: v1(178.29,117.35) v2(177.76,117.35)
  IN2 w0.254: v2(178.97,125.33) 179.98,125.33 180.24,125.07 180.24,124.69 179.86,124.31 173.57,124.31 171.41,122.15 171.41,119.04 173.1,117.35 177.64,117.35 177.71,117.4 v2(177.76,117.35)
  IN3 w0.254: v7(179.16,126.28) 179.16,125.52 v2(178.97,125.33)
N25410601: length 6.1
  TOP w0.254: PR1503.2 182.14,116.98 179.81,116.98 178.94,117.85 PU1500.7 177.49,117.85 PC1500.1
N25410879: length 1.4
  TOP w0.254: PU1500.2 182.1,117.85 PR1502.2
N25411106: length 4.2
  TOP w0.254: PQ1500.2 178.67,116.1 178.99,115.78 178.99,114.37 178.47,113.85 PR1500.2 PR1504.1
N25438298: length 11.1
  TOP w0.119: RC27.1 52.5,107.58 52.5,106.4 51.93,105.83 43.89,105.83 TC9.1
N25438312: length 11.8
  TOP w0.119: RC28.1 52.72,106.91 52.72,106.31 52.01,105.59 42.62,105.59 TC8.1
N25438359: length 1.6
  TOP w0.119: RC30.1 53.14,106.31 52.08,105.26 TC11.1
N25438360: length 1.1
  TOP w0.119: RC32.1 53.14,103.72 TC12.1
N25438361: length 11
  TOP w0.119: RC25.1 52.28,108.25 52.28,106.5 51.83,106.05 45.53,106.05 TC10.1
N25438362: length 2.3
  TOP w0.119: TC13.1 52.6,103.66 52.6,105.27 52.88,105.55 RC31.1
N25610586: length 27.4
  BOTTOM w0.119: DA7.1 20.01,100.95 22.11,103.05 22.11,126.89 RA54.1
N25857439: length 0.8
  TOP w0.119: QT1.2 34.57,57.42 R238.2
N25857459: length 12.6
  TOP w0.119: QT1.1 35.07,56.12 35.38,55.81 35.38,54.81 34.72,54.15 34.72,51.21 34.96,50.98 38.75,50.98 38.89,50.84 R247.2 38.89,50.28 38.71,50.1 37.77,50.1 37.58,49.92 R259.2
N25860632: length 2.2
  BOTTOM w0.254: PQ504.1 165.35,112.56 165.14,112.78 PR536.2
N25863019: length 3.5
  TOP w0.119: U5.4 27.26,130.57 27.19,130.63 25.37,130.63 R53.1
N25958709: length 1.5
  BOTTOM w0.254: PR718.1 127.89,118.39 127.42,118.86 PU700.14
N25961580: length 15.3
  TOP w0.254: v1(189.31,117.37) 189.54,117.37 189.86,117.69 189.86,118.1 PR1413.2 ; v1(192.63,115.32) 192.63,115.09 192.89,114.84 193.54,114.84 193.93,114.44 v1(193.93,113.49) ; v1(195.01,111.99) 193.28,111.99 192.65,111.36 PU1501.7
  IN1 w0.254: v1(189.31,117.37) 189.31,116.48 189.65,116.14 190.89,116.14 191.75,115.29 192.6,115.29 v1(192.63,115.32) ; v1(193.93,113.49) 193.93,113.07 v1(195.01,111.99)
N25961582: length 6.9
  TOP w0.254: PR1419.2 PR1425.1 PC1408.1 195.9,111.08 PR1416.1 192.87,111.08 191.86,110.06 PU1501.5
N25961915: length 23.3
  TOP w0.254: PR1417.2 194.47,116.8 194.47,119.07 193.55,119.99 188.34,119.99 188.06,119.71 188.06,117.26 188.61,116.72 189.31,116.72 PQ1502.4 189.66,116.72 PR1421.2 190.55,117.39 190.55,113.5 189.77,112.72 188.15,112.72 187.45,112.01 PU1501.1
N25961992: length 4.4
  TOP w0.254: PR1424.2 PU1404.1 187.69,114.29 187.41,114.57 PQ1502.3
N25961994: length 1.5
  TOP w0.254: PU1403.4 189.5,115.2 189.24,114.94 PU1404.2
N25962000: length 12.3
  TOP w0.254: PC1411.2 193.74,119.29 194.12,118.92 194.12,117.16 193.9,116.94 193.7,116.94 PR1420.1 191.73,114.98 PU1403.2 191.04,114.98 190.91,114.85 190.91,114.52 191.1,114.33 PU1403.1
N25962026: length 25
  TOP w0.254: v1(196.88,116.5) 196.88,116.45 195.96,115.53 PC1415.1 PR1414.1 PR1417.1 ; PU1501.3 187.99,110.71 189.28,112 190.08,112 190.76,112.69 v1(193.55,112.69) ; v1(194.63,110.12) 198.22,110.12 198.63,110.54 v1(198.63,110.84)
  IN1 w0.254: v1(194.63,110.12) 194.63,111.48 193.55,112.56 v1(193.55,112.69) ; v1(198.63,110.84) 199.29,111.5 199.29,112.99 198.17,114.11 198.17,115.18 197.43,115.92 197.43,115.94 v1(196.88,116.5)
N25962054: length 5
  TOP w0.254: PU1404.4 186.43,115.59 185.66,116.36 PQ1501.2 185.66,117.17 187.43,118.94 PC1411.1
N25991293: length 6.8
  IN1 w0.084: v1(62.06,121.77) 62.06,121.69 61.45,121.07 v2(61.37,121.07)
  IN3 w0.06: v2(61.37,121.07) 61.81,121.07 62.32,120.56 62.45,120.56 62.57,120.44 62.9,120.44 63.02,120.31 63.18,120.31 63.26,120.39 63.43,120.39 63.64,120.18 v6(63.65,120.18)
  IN4 w0.06: v4(61.87,120.84) 62.08,120.84 62.31,120.6 62.31,120.43 62.16,120.28 62.16,120.11 62.28,120 62.44,120 62.52,120.07 62.69,120.07 62.7,120.06 62.7,120.06 62.77,120 62.94,120 63.05,120.11 63.05,120.19 63.26,120.39 63.43,120.39 63.51,120.32 63.52,120.32 v6(63.65,120.18)
N25991324: length 9.2
  IN4 w0.06: v5(61.37,122.13) 60.58,122.13 60.38,122.33 60.15,122.33 59.72,121.9 58.95,121.9 58.83,122.02 58.45,122.02 58.18,121.75 57.43,121.75 57.26,121.92 57.26,122.27 56.98,122.54 56.52,122.54 56.38,122.68 55.41,122.68 55.37,122.73
  IN4 w0.089: 55.37,122.73 55.37,122.73 55.2,122.9 54.68,122.9 54.21,123.36 53.62,123.36 v4(53.54,123.43)
N26073159: length 2.1
  TOP w0.119: R45.2 141.1,131.68 v13(141.29,131.49)
  BOTTOM w0.119: v13(141.29,131.49) 141.6,131.49 141.8,131.29 141.8,130.55 JWFC.28
N26074196: length 7.9
  TOP w0.119: v1(125.31,132.88) 125.18,132.76 122.83,132.76 122.71,132.64 122.71,131.8 122.56,131.65 122.56,130.53 122.9,130.19 R62.2
  IN1 w0.084: v1(125.31,132.88) 124.93,133.26 v2(124.8,133.26)
  IN3 w0.084: v2(124.8,133.26) 124.8,133.22 v7(125.01,133.01)
  BOTTOM w0.119: JUFC.39 124.76,133.31 125.01,133.05 v7(125.01,133.01)
N26142017: length 11.9
  TOP w0.119: TC82.1 65.24,122.85 v1(66.41,121.67)
  IN1 w0.084: v1(66.41,121.67) 66.81,121.28 66.81,121.06 67.02,120.84 67.02,120.56 66.74,120.28 66.74,119.58 66.5,119.34 66.41,119.34 66.13,119.06 66.13,118.8 65.83,118.5 65.4,118.5 65.05,118.85 v2(64.92,118.85)
  IN3 w0.06: v2(64.92,118.85) 64.8,118.98 64.8,119.17 64.6,119.36 64.35,119.36 63.85,119.86 63.85,120.38 v6(63.97,120.5)
  IN4 w0.06: v4(62.61,120.52) 62.61,120.88 62.81,121.08 62.9,121.08 63.02,120.96 63.19,120.96 63.26,121.04 63.43,121.04 63.97,120.5 v6(63.97,120.5)
N26188269: length 7.9
  BOTTOM w0.254: PR542.2 143.51,107.22 PQ512.2 ; PQ513.1 140.84,105.79 PQ512.2 ; PQ512.2 145.04,105.79 PR545.1
N26188538: length 6
  BOTTOM w0.254: PQ513.2 138.25,105.45 137.03,105.45 PR543.1 136.17,105.63 135.53,106.26 PD505.1 PD506.1
N26388185: length 4.9
  IN4 w0.06: v4(59.82,123.13) 59.9,123.05 60.76,123.05 60.79,123.01 61.59,123.01 61.8,123.23 v5(61.9,123.23)
  BOTTOM w0.06: TC34.1 57.89,124.17 58.86,123.2 59.74,123.2 v4(59.82,123.13)
N26390068: length 6.6
  BOTTOM w0.119: U38.4 41.97,113.02 41.83,112.88 39.22,112.88 38.18,111.84 38.18,110.51 Q18.2
N26391418: length 1.5
  BOTTOM w0.119: R406.2 35.26,108.89 Q18.1
N26425179: length 1.6
  TOP w0.119: U5.2 26.61,127.4 R103.2
N26519107: length 2.6
  TOP w0.119: UV1.26 129.23,107.46 129.41,107.28 129.41,106.67 R163.2
N26559031: length 2.3
  TOP w0.119: PQ106.6 27.24,87.06 ; 27.24,87.06 27.89,86.41 PQ106.5 ; 27.24,87.06 PR137.2
N26666068: length 16.3
  IN3 w0.084: JHP1.5 13.3,155.46 15.21,153.55 15.21,146.37 13.61,144.77 13.61,144.26 v7(12.81,143.46)
  BOTTOM w0.119: RA45.2 12.93,142.44 DA5.1 12.93,143.34 v7(12.81,143.46)
N26874176: length 2.1
  BOTTOM w0.119: D35.2 198.53,138.15 198.53,140.11 R325.2
N26874221: length 2.5
  BOTTOM w0.119: D35.3 198.43,136.83 199.06,137.45 199.06,138.34 198.88,138.52 R333.2
N26878757: length 5.7
  TOP w0.119: RA15.2 9.41,132.86 v1(9.69,133.14)
  IN1 w0.084: v2(10.19,133.8) 9.69,133.3 v1(9.69,133.14)
  IN3 w0.084: v3(9.44,132.76) 9.52,132.84 9.52,133.14 v2(10.19,133.8)
  IN4 w0.089: v3(9.44,132.76) 8.93,132.25 v4(8.56,132.25)
  BOTTOM w0.119: UA3.40 8.79,132.02 v4(8.56,132.25)
N26920051: length 1.8
  BOTTOM w0.119: R411.2 195.41,110.13 LED1.2
N26920096: length 1.8
  BOTTOM w0.119: Q16.1 195.72,111.85 LED1.1
N26961307: length 0.9
  BOTTOM w0.119: PR1118.2 PC1118.1
N26963152: length 0.9
  TOP w0.254: PC1103.1 118.33,118.96 PR1102.2
N26965088: length 8.9
  BOTTOM w0.254: PR1142.2 112.72,113.38 110.95,113.38 110.59,113.73 104.48,113.73 PH1102.1
N27328203: length 1.9
  BOTTOM w0.119: R471.2 18.34,90.33 18.34,91 18.47,91.13 U51.4
N27718925: length 2.4
  BOTTOM w0.119: PR550.1 136.83,110.99 PR546.2 135.53,110.56 PD505.2
N28606576: length 2.6
  TOP w0.119: TC78.1 64.99,122.32 v1(65.24,122.06)
  IN1 w0.084: v2(64.96,121.68) 65.24,121.96 v1(65.24,122.06)
  GND3 w0.06: v8(65.34,121.74) 65.02,121.74 v2(64.96,121.68)
  IN4 w0.06: v8(65.34,121.74) 65.22,121.74 v4(64.77,121.29)
N29359678: length 3
  BOTTOM w0.119: PR831.1 171.54,117.07 169.73,117.07 PC816.2
N29853050: length 28.8
  TOP w0.254: PH1100.1 104.97,104.94 105.22,105.2 v1(105.22,107.01)
  IN1 w0.254: v1(105.22,107.01) v2(104.71,107.01)
  IN3 w0.254: v2(104.71,107.01) v3(104.97,107.27)
  IN4 w0.254: v4(118.49,120.03) 119.11,119.41 119.11,117.43 118.78,117.1 118.78,114.89 116.64,112.75 116.59,112.75 116.59,112.74 116.46,112.74 116.46,112.74 116.21,112.74 115.61,112.14 115.61,110.91 112.08,107.38 106.46,107.38 106.08,107.76 105.46,107.76 v3(104.97,107.27)
  BOTTOM w0.254: PR1116.2 119.99,120.03 v4(118.49,120.03)
N30221004: length 8.6
  BOTTOM w0.119: C369.2 207.47,111.04 R513.2 207.44,110.76 207.53,110.67 Q22.2 206.82,109.3 204.41,106.89 204.09,106.89 203.44,106.24 R514.1
N30221093: length 1.9
  BOTTOM w0.119: R514.2 204.11,104.07 Q23.1
N30221403: length 3.7
  BOTTOM w0.119: C369.1 208.38,111.04 R513.1 209.37,111.01 R511.2 209.46,110.95 Q22.3
N30221460: length 3.1
  BOTTOM w0.119: Q23.2 204.45,106.39 204.77,106.71 206.15,106.71 206.41,106.44 R515.2
N30221480: length 2
  BOTTOM w0.119: R512.1 208.94,106.77 Q22.1
N42233415: length 34.6
  IN1 w0.084: v2(53.87,124.32) 54.33,123.85 v1(54.33,123.64)
  IN2 w0.079: v2(53.87,124.32) 53.87,126.4 53.28,127 v2(53.28,127.29)
  IN3 w0.084: v7(45.08,145.76) 44.97,145.65 44.97,143.39 44.22,142.63 44.22,140.73 42.81,139.32 42.81,131.15 45.25,128.72 45.25,128.72 46.56,127.41 48.06,127.41 48.57,127.92 49.39,127.92 49.72,127.6 50.14,127.6 50.36,127.82 50.81,127.82 50.91,127.71 51.43,127.71 51.72,127.42 53.15,127.42 v2(53.28,127.29)
  BOTTOM w0.119: v7(45.08,145.76) 45.97,145.76 46.36,146.14 JNGFF3.50
N44370994: length 1.7
  TOP w0.203: U20.12 35.12,106.33 C145.1
N45346942: length 1.5
  TOP w0.203: C159.1 46.4,103.82 U22.10
N50930159: length 3
  TOP w0.119: UV1.7 121.05,109.46 120.4,108.8 120.4,108.12 120.12,107.84 RV13.1
N51581718: length 3.7
  TOP w0.119: U26.6 38.57,72.48 38.37,72.68 38.37,73.04 39.85,74.53 C189.1
N51600744: length 1.5
  TOP w0.203: C137.1 25.2,111.14 25.91,111.14 26,111.23 U15.12
N51600766: length 3.4
  TOP w0.203: U15.10 23.82,112.03 C136.1
N53869491: length 0.9
  BOTTOM w0.119: R356.2 191.72,129.3 C261.1
N54227584: length 3.9
  IN3 w0.076: v10(67.82,132.22) 68.36,131.68 68.36,131.12 68.25,131.01 68.25,130.45 68.09,130.29 68.09,129.41 68.14,129.36 v7(68.14,129.1)
  BOTTOM w0.119: v7(68.14,129.1) 68.12,129.08 R365.1
N54227586: length 6
  BOTTOM w0.119: U33.B11 69.53,136.53 69.99,136.53 70.13,136.67 70.84,136.67 72.34,135.17 74.09,135.17 74.21,135.05 R341.1
N54714783: length 5.5
  IN3 w0.076: v7(82.07,126.89) 82.07,126.81 82.17,126.71 82.59,126.71 82.92,126.38 83.24,126.38 83.83,125.79 84.14,125.79 84.43,126.08 85.24,126.08 85.39,125.93 v10(85.39,125.79)
  BOTTOM w0.119: v7(82.07,126.89) 81.87,127.09 R367.1
N55958521: length 4.1
  BOTTOM w0.203: 12.75,125.38 12.75,126.01 12.9,126.16 12.9,126.23 12.98,126.3 UA3.21
  BOTTOM w0.254: CA65.1 12.42,124.45 12.66,124.69 CA58.1 12.75,124.82 12.75,125.38
N55958533: length 4.4
  IN4 w0.203: v4(10.44,134.46) 10.4,134.42 10.35,134.42 10.06,134.71 10.06,135.14 10.57,135.65 10.57,137.2 v4(10.24,137.56)
  BOTTOM w0.203: v4(10.44,134.46) 10.58,134.32 UA3.44
N55958539: length 3.4
  BOTTOM w0.203: 8.51,132.76 8.85,132.42 UA3.41
  BOTTOM w0.305: CA41.1 8.51,134.61 8.51,132.76
N56067860: length 3.4
  BOTTOM w0.203: UA3.18 14.18,126.1
  BOTTOM w0.254: CA61.1 15.77,124.17 15.2,124.74 CA57.1 15.04,125.24 14.18,126.1
N56068412: length 5.9
  IN3 w0.254: v7(6.2,123.71) 6.65,123.71 8.33,125.39 8.33,127.61 v7(8.34,127.62)
  BOTTOM w0.203: v7(8.34,127.62) UA3.29
N56068450: length 5.4
  IN3 w0.254: v7(8.31,128.41) 7.75,127.85 7.75,126.1 7.11,125.47 v7(6.12,125.47)
  BOTTOM w0.203: v7(8.31,128.41) 8.31,128.42 UA3.31
N56068743: length 2.8
  BOTTOM w0.203: UA3.25 11.38,125.95 CA55.1
N56068745: length 1.9
  BOTTOM w0.203: CA55.2 10.03,125.47 10.31,125.47 10.98,126.13 UA3.26
N56068751: length 2.3
  BOTTOM w0.203: UA3.28 10.18,126.29 10.06,126.18 9.19,126.18 8.81,125.8 CA54.2
N56068753: length 3.6
  BOTTOM w0.203: CA54.1 9.22,124.48 9.35,124.6 9.35,125.67 9.52,125.85 10.21,125.85 10.58,126.21 UA3.27
N56194338: length 0.8
  TOP w0.508: R125.1 88.91,122.05 C124.2
N56194376: length 0.8
  TOP w0.508: C86.2 84,126.81 R102.1
N57436928: length 2.8
  TOP w0.119: C98.1 149.35,125.78 148.87,125.3 148.87,124.49 148.99,124.36 U13.6
N57439320: length 1.3
  BOTTOM w0.254: C325.1 65.6,100.42 U50.12
N57439346: length 1.3
  BOTTOM w0.254: U50.10 64.8,100.33 C326.1
N57468046: length 1.3
  BOTTOM w0.508: R441.1 72.72,100.74 73.12,100.33 U48.6
N57645414: length 1.7
  TOP w0.203: U7.12 108.3,126.5 C109.1
N118179758: length 1.2
  TOP w0.508: PR805.2 35.97,132.6 35.51,132.15 PC807.1
N125160725: length 2.4
  TOP w0.119: TC80.1 64.04,117.08 v1(64.04,117.19)
  IN1 w0.084: v2(63.65,116.63) 63.65,116.69 64.04,117.08 v1(64.04,117.19)
  IN3 w0.06: v2(63.65,116.63) v6(63.65,116.98)
  IN4 w0.06: v4(62.85,116.97) 63.06,116.97 63.26,117.17 63.43,117.17 63.62,116.98 v6(63.65,116.98)
N125160734: length 2.2
  TOP w0.119: TC79.1 63.33,117.07 v1(63.27,117.01)
  IN1 w0.084: v2(63.65,117.37) 63.65,117.35 63.31,117.01 v1(63.27,117.01)
  IN3 w0.06: v2(63.65,117.37) 63.31,117.37 63.18,117.5 62.81,117.5 v7(62.61,117.3)
N125162616: length 12.8
  TOP w0.119: TC83.1 65.43,123.36 66.26,122.53 v1(66.26,122.41)
  IN1 w0.084: v2(65.68,118.85) 65.92,119.09 65.92,119.12 66.33,119.53 66.42,119.53 66.55,119.66 66.55,120.06 66.23,120.37 65.97,120.37 65.72,120.62 65.72,121.49 66.26,122.02 v1(66.26,122.41)
  IN3 w0.06: v2(65.68,118.85) 65.62,118.91 65.62,119.09 65.34,119.38 65.34,119.62 65.62,119.9 v6(65.62,120.18)
  IN4 w0.06: v4(62.85,121.48) 62.92,121.48 62.92,121.48 63.14,121.48 63.29,121.33 63.48,121.33 63.51,121.36 63.67,121.36 63.74,121.29 63.85,121.29 64.04,121.49 64.21,121.49 64.32,121.37 64.32,121.2 64.25,121.13 64.25,120.73 64.73,120.25 64.73,120.15 64.96,119.93 65.24,119.93 65.49,120.18 v6(65.62,120.18)
N125184377: length 12
  VCC w0.508: 64.27,121.34 63.72,121.88 63.5,121.88 62.09,123.29 58.56,123.29 58.06,123.79 56.99,123.79 56.89,123.89 55.53,123.89 54.72,123.08 54.05,123.08
  BOTTOM w0.254: v4(65.09,120.55) 65.09,120.16 UC1.AT18
  vias: v2(64.62,120.59) v8(65.21,120.32) v18(53.57,123.17) v21(64.37,120.81) v21(64.59,120.93)
N125185663: length 5.1
  BOTTOM w0.119: UC1.B4 61.21,109.6 61.16,109.6 60.68,109.12 60.68,108.29 59.22,106.84 59.22,106.58 59.22,106.58 59.22,106.17 TC68.1
N125185665: length 4.9
  BOTTOM w0.119: UC1.B3 60.41,109.23 60.41,108.44 59,107.04 59,106.67 59,106.67 59,106.01 TC69.1
N125185667: length 5.3
  IN4 w0.06: v5(61.04,110.72) 60.87,110.55 60.87,110.29 60.71,110.12 60.46,110.12 59.9,109.56 v4(59.9,109.37)
  BOTTOM w0.119: TC53.1 57.68,107.46 58.13,107.46 58.24,107.57 58.57,107.57 59.9,108.89 v4(59.9,109.37)
N125185669: length 5.2
  BOTTOM w0.119: UC1.F1 60.16,110.35 60.16,108.6 58.78,107.22 58.78,106.77 58.78,106.6 TC62.1
N125185671: length 5.8
  IN4 w0.06: v10(70.89,111.92) 70.89,111.82 70.61,111.55 70.61,110.43 70.64,110.4 70.65,110.4 70.89,110.15 71.03,110.15 71.82,109.36 v4(71.82,107.75)
  BOTTOM w0.119: TC57.1 72.08,107.49 v4(71.82,107.75)
N125185842: length 4.8
  IN4 w0.06: v4(76.4,107.71) 76.15,107.71 75.68,108.18 75.68,109.01 75.23,109.45 75.23,109.83 75.07,109.99 v5(75.07,110.2)
  BOTTOM w0.119: TC66.1 76.4,106.14 v4(76.4,107.71)
N125185844: length 6.5
  IN4 w0.06: v4(64.72,107.99) 64.72,108.15 65.35,108.78 65.35,111.33 65.69,111.67 65.69,111.81 v12(66.06,112.17)
  BOTTOM w0.119: TC59.1 64.8,106.62 64.69,106.72 64.69,107.97 v4(64.72,107.99)
N125185848: length 13.4
  IN3 w0.06: v10(65.41,112.17) 65.24,112.17 64.92,112.49 63.99,112.49 63.97,112.47 63.78,112.47 62.48,111.17 61.65,111.17 61.2,110.72 60,110.72 58.74,109.46 57.76,109.46 56.52,108.22 56.52,108.15 56.18,107.81
  IN3 w0.084: 56.18,107.81 56.01,107.64 56.01,107.21 55.89,107.09 55.89,106.34 56.15,106.09 v7(56.24,106.09)
N125185850: length 12.5
  IN4 w0.06: v5(67.67,111.92) 67.23,111.92 66.7,111.39 66.7,110.17 66.4,109.88 66.4,109.14 66.53,109.02 66.53,106.22 66.4,106.09 66.05,106.09 65.98,106.02 65.98,105.89 66.13,105.75 66.13,105.72 66.62,105.22 66.96,105.22 67.12,105.06
  IN4 w0.089: 67.12,105.06 67.3,104.88 67.3,102.15 v4(67.84,101.62)
N125185953: length 3.5
  BOTTOM w0.119: TC40.1 81.72,122.05 80.16,123.61 79.24,123.61 UC1.BL64
N125186153: length 11.7
  IN4 w0.06: v10(63.35,113.11) 63.46,112.99 63.67,112.99 63.79,112.88 63.79,112.69 63.73,112.63 63.71,112.63 63.58,112.51 63.58,112.35 63.18,111.94 63.02,111.94 62.94,112.02 62.77,112.02 62.69,111.94 62.52,111.94 62.31,112.15 62.31,112.22 62.1,112.44 62.1,112.51 62.07,112.55 61.93,112.69 61.81,112.69 61.78,112.67 61.68,112.56 61.56,112.56 61.46,112.67 61.29,112.67 61.21,112.59 61.21,112.59 60.95,112.59 57.63,109.27 57.63,107.91 57.72,107.82 57.72,107.4 57.63,107.32 v4(57.63,106.9)
N125186155: length 9.5
  IN3 w0.06: v10(63.59,112.79) 63.47,112.91 63.26,112.91 62.89,113.28 62.89,113.43 62.69,113.63 62.52,113.63 62.36,113.47 62.34,113.47 61.91,113.04 61.36,113.04 61.06,113.35 60.73,113.35 60.48,113.1 60.48,112.74 59.67,111.92 59.03,111.92 v7(58.81,111.7)
  BOTTOM w0.119: TC46.1 56.38,111.92 58.58,111.92 v7(58.81,111.7)
N125186157: length 10.8
  IN3 w0.06: v10(64.12,112.17) 63.97,112.17 63.68,111.88 63.68,111.59 62.39,110.3 60.97,110.3 60.91,110.36 60.15,110.36 58.62,108.83 58.62,108.39 57.96,107.73 57.96,106.81 57.95,106.8
  IN3 w0.084: 57.95,106.8 56.99,105.83 v7(56.95,105.83)
N125186159: length 11.7
  IN3 w0.06: v10(64.44,111.92) 64.18,111.92 62.44,110.18 60.92,110.18 60.86,110.24 60.2,110.24 58.74,108.78 58.74,108.34 58.15,107.75 58.15,106.8
  IN3 w0.084: 58.15,106.8 58.15,106.73 57.37,105.95 57.37,105.59 57.07,105.3 v7(56.64,105.3)
N125186161: length 12.4
  IN3 w0.06: v10(65.09,111.92) 64.86,111.69 64.11,111.69 62.49,110.06 60.87,110.06 60.81,110.12 60.27,110.12 58.86,108.71 58.86,108.29 58.52,107.95 58.52,106.8
  IN3 w0.084: v7(57.45,104.51) 57.45,105.03 58.52,106.1 58.52,106.8
N125186163: length 11.5
  IN3 w0.06: v10(64.77,112.17) 64.41,112.17 64.21,112.37 64.04,112.37 64.02,112.35 63.83,112.35 62.53,111.05 61.7,111.05 61.25,110.6 60.05,110.6 58.77,109.32 57.9,109.32 56.73,108.16 56.73,106.8
  IN3 w0.084: 56.73,106.8 56.73,106.76 v7(56.92,106.57)
N125186165: length 10.9
  IN3 w0.06: 57.69,106.8 57.73,106.84 57.73,106.85 57.79,106.91 57.79,107.73 58.5,108.44 58.5,108.88 60.1,110.48 61.3,110.48 61.75,110.93 62.58,110.93 63.33,111.68 v10(63.48,111.68)
  IN3 w0.084: v7(55.93,105.3) 56.79,106.16 57.06,106.16 57.69,106.8
N125186167: length 6.2
  IN4 w0.06: v4(62.23,107.58) 62.84,108.19 62.84,108.28 63.73,109.17 63.73,109.76 63.9,109.93 63.9,110.25 63.93,110.29 63.93,110.29 64,110.36 64,110.53 63.88,110.64 63.88,110.86 63.56,111.18 v5(63.48,111.18)
  BOTTOM w0.119: TC63.1 63.17,106.64 v4(62.23,107.58)
N125186171: length 15.4
  IN4 w0.06: v5(61.04,124.09) 60.88,124.25 60.42,124.25 60.37,124.2 60.2,124.2 60.09,124.31 59.45,124.31 59.25,124.11 58.75,124.11 58.69,124.18 58.35,124.18 57.17,125.36 57.06,125.36 56.63,125.79 56.46,125.95 56.27,125.95 55.93,126.29 55.64,126.29
  IN4 w0.089: 55.64,126.29 54.8,126.29 54.64,126.45 54.64,126.47 54.62,126.48 54.62,126.71 54.62,126.8 54.58,126.84 54.45,126.98 54.45,127.04 54.26,127.23 51.67,127.23 51.34,126.89 48.45,126.89 48.37,126.81 v4(47.6,126.81)
N125186173: length 3.7
  BOTTOM w0.119: TC32.1 57.68,124.63 59.03,124.63 59.23,124.83 60.75,124.83 UC1.BP3
N125186177: length 5.7
  IN4 w0.06: v5(66.7,112.17) 66.56,112.17 66.32,111.93 66.32,111.55 65.96,111.19 65.96,110.78 65.82,110.64 65.65,110.64 65.49,110.49 65.49,108.74 65.15,108.4 v4(65.15,108.27)
  BOTTOM w0.119: TC54.1 65.1,108.22 v4(65.15,108.27)
N125186179: length 2.1
  TOP w0.119: TC3.1 64.78,121.41 v1(64.78,121.29)
  IN1 w0.084: v1(64.78,121.29) 64.78,121.19 v2(65.02,120.95)
  IN3 w0.06: v2(65.02,120.95) 65.02,121.14 v3(65.2,121.31)
  IN4 w0.06: v3(65.2,121.31) 65.47,121.04 v10(65.73,121.04)
N125186183: length 4
  BOTTOM w0.119: UC1.BN1 58.77,124.06 58.38,124.45 57.13,124.45 TC33.1
N125186366: length 16.2
  IN3 w0.06: 60.15,124.63 60.52,124.25 60.52,123.83 61.9,122.46 62.75,122.46 63.01,122.19 63.3,122.19 63.46,122.03 63.46,121.88 v10(63.8,121.53)
  IN3 w0.084: 60.15,124.63 60.08,124.69 60.08,124.7 59.91,124.87 59.55,124.87 59.49,124.81 59.49,124.63 59.13,124.28 59,124.28 58.99,124.28 58.87,124.28 58.87,124.28 58.56,124.28 58.56,124.28 58.39,124.28 58.39,124.28 58.1,123.99 57.85,123.99 57.13,124.7 56.92,124.7 56.59,125.03 56.28,125.03 56.08,125.23 55.52,125.79 55.34,125.97 55.2,126.12 55.2,126.67 54.95,126.92 54.4,126.92 53.67,126.19 52.86,126.19 52.61,126.43 v7(52.52,126.43)
  BOTTOM w0.119: RC37.1 52.88,126.62 52.7,126.43 v7(52.52,126.43)
N125186425: length 11.2
  IN4 w0.06: v5(68.31,111.92) 67.95,111.92 67.72,111.7 67.65,111.7 67.43,111.48 67.35,111.48 67.07,111.19 66.99,111.19 66.82,111.02 66.82,110.12 66.52,109.83 66.52,109.19 66.68,109.03 66.68,106.25 67.31,105.63
  IN4 w0.089: 67.31,105.63 67.31,105.12 67.31,105.08 67.45,104.94 67.45,104.52 68.01,103.96 68.01,103.72 68.87,102.86 v4(68.96,102.86)
N125186427: length 14.2
  IN4 w0.06: v10(67.99,112.17) 67.31,112.17 67.11,111.97 66.78,111.97 66.71,111.97 66.44,111.7 66.44,111.5 66.08,111.14 66.08,110.06 66.24,109.9 66.24,109.14 66.34,109.03 66.34,108.45 65.86,107.97 65.86,106.62 65.65,106.4 65.65,106.03 66.01,105.67 66.01,105.67 66.6,105.07 66.9,105.07 66.93,105.04
  IN4 w0.089: 66.93,105.04 67.11,104.86 67.11,101.61 v4(67.82,100.9)
N125186463: length 8.2
  IN4 w0.06: v4(58.72,127.52) 58.86,127.52 59.87,126.52 61.97,126.52 63.45,125.04 63.59,125.04 64.22,124.4 64.22,124.12 64.52,123.81 64.62,123.81 64.77,123.66 v5(64.77,123.26)
N126490868: length 8.4
  TOP w0.119: Q7.2 52.15,130.11 52.23,130.2 52.23,130.52 52.14,130.61 Q7.3 51.78,130.98 52.58,131.78 52.58,134.64 52.23,134.98 51.1,134.98 50.95,134.83 R28.1
N126490934: length 1.5
  TOP w0.119: Q7.1 52.27,129.61 52.53,129.35 RH11.1
N126505111: length 2.3
  BOTTOM w0.119: RC72.1 85.74,106.58 RH108.2 86.25,106.58 86.63,106.2 U45.4
N126538537: length 0.6
  BOTTOM w0.119: RH107.1 TC55.1

## Copper pours and planes (outline as drawn)
0.95V_PRIM_PG on TOP (solid shape): 173.96,106.06 173.96,105.17 173.89,105.1 173.79,105.1 173.71,105.17 173.71,105.91 173.67,105.95 172.22,105.95 171.68,105.4 171.22,105.4 171.17,105.45 171.17,106.15 171.09,106.23 171.09,106.83 171.16,106.9 173.13,106.9
1.0V_PRIM_PG on BOTTOM (solid shape): 173.23,121.5 173.23,120.08 173.18,120.03 172.54,120.03 172.49,120.08 172.49,120.87 172.55,120.93 172.55,121.55 172.6,121.61 173.13,121.61
1.0V_PRIM_PG on IN4 (solid shape): 173.63,120.54 173.63,118.91 173.64,118.91 173.64,118.73 174.8,117.57 174.8,116.55 174.7,116.45 174.14,116.45 174.09,116.5 174.09,117.21 173,118.3 173,119.83 172.8,120.03 172.52,120.03 172.44,120.11 172.44,120.54 172.57,120.67 173.51,120.67
3V_VIN on BOTTOM (solid shape): 190.25,112.56 190.25,111.32 190.43,111.14 191.08,111.14 191.72,110.5 191.72,109.67 191.14,109.45 191.72,109.23 191.72,106.5 191.49,106.27 189.04,106.27 188.88,106.44 188.88,110.76 188.93,110.8 188.96,110.85 189.2,111.09 189.2,111.72 189.59,112.11 189.59,112.5 189.68,112.6 190.21,112.6
3VP_VIN on TOP (solid shape): 27.63,125.82 27.63,124.22 27.56,124.15 26.95,124.15 26.61,124.49 26.07,124.49 25.97,124.59 25.97,125.97 26.06,126.06 27.39,126.06
3VP_VIN on BOTTOM (solid shape): 28.33,126.57 28.68,126.57 28.78,126.47 28.78,126.11 28.57,125.9 27.57,125.9 27.32,125.64 27.32,124.8 27.04,124.53 24.79,124.53 24.66,124.65 24.66,126.69 24.74,126.76 28.14,126.76
+0.6VSP on BOTTOM (solid shape): 123.65,120.54 124.27,120.54 124.35,120.45 124.35,120.27 124.3,120.22 122.38,120.22 122.31,120.3 122.31,121.05 123.13,121.05
+0.6VSP on BOTTOM (solid shape): 124.37,118.94 124.37,118.72 124.31,118.66 123.5,118.66 123.31,118.47 123.31,118.2 122.89,117.78 122.42,117.78 122.32,117.88 122.32,118.56 122.4,118.64 122.99,118.64 123.36,119.01 124.31,119.01
+0.6VSP on IN3 (solid shape): 122.88,121 122.88,118.1 122.76,117.97 122.5,117.97 122.17,118.3 122.17,119.04 121.95,119.27 121.95,120.89 122.15,121.1 122.78,121.1
+0.85VS_VCCIO on TOP (solid shape): 68.78,120.11 68.78,116.83 68.76,116.8 68.4,116.8 68.38,116.83 68.38,120.11 68.43,120.16 68.73,120.16
+0.85VS_VCCIO on TOP (solid shape): 45.26,132.08 45.26,130.66 44.93,130.33 44.93,128.74 44.75,128.56 43.61,128.56 43.59,128.59 43.59,130.24 43.15,130.24 43.08,130.32 43.08,131.32 43.22,131.46 43.97,131.46 44.65,132.15 45.2,132.15
+0.85VS_VCCIO on TOP (solid shape): 73.49,121.34 73.98,121.34 74.04,121.27 74.04,120.84 74.09,120.79 76.25,120.79 76.33,120.72 76.33,120.41 76.2,120.28 72.03,120.28 71.48,120.84 68.38,120.84 68.33,120.89 68.33,121.25 68.38,121.3 69.39,121.3 69.44,121.35 73.48,121.35
+0.85VS_VCCIO on BOTTOM (solid shape): 77.3,128.91 79.36,128.91 79.38,128.89 79.38,128.38 79.18,128.17 77,128.17 76.66,128.51 76.66,129.15 76.71,129.2 77.01,129.2
+0.85VS_VCCIO on BOTTOM (solid shape): 68.17,120.86 68.31,120.81 68.45,120.86 68.81,120.86 68.95,120.81 69.1,120.86 69.45,120.86 69.6,120.81 69.74,120.86 70.1,120.86 70.24,120.81 70.39,120.86 70.74,120.86 70.89,120.81 71.03,120.86 71.39,120.86 71.53,120.81 71.67,120.86 72.03,120.86 72.17,120.81 72.32,120.86 72.67,120.86 72.82,120.81 72.96,120.86 73.32,120.86 73.46,120.81 73.61,120.86 73.96,120.86 74.11,120.81 74.25,120.86 74.61,120.86 74.75,120.81 74.9,120.86 75.25,120.86 75.4,120.81 75.54,120.86 75.65,120.86 75.78,120.74 75.78,120.61 75.65,120.48 67.82,120.48 67.77,120.43 67.64,120.43 67.55,120.53 67.55,120.65 67.71,120.82 67.77,120.84 67.81,120.86
+0.85VS_VCCIO on IN1 (solid shape): outline of 100 points within 66.32,115.99 78.74,121.15
+0.85VS_VCCIO on IN2 (solid shape): 67.92,120.08 67.92,119.8 67.77,119.65 67.77,119.4 67.76,119.39 67.73,119.26 67.76,119.12 67.77,119.11 67.77,118.29 67.76,118.28 67.73,118.14 67.76,118.01 67.77,118 67.77,116.96 67.76,116.95 67.73,116.82 67.76,116.69 67.77,116.68 67.77,116.32 67.36,115.92 66.52,115.92 66.37,116.07 66.37,116.35 66.45,116.42 66.95,116.42 67.36,116.83 67.36,120.16 67.41,120.21 67.79,120.21
+0.85VS_VCCIO on IN2 (solid shape): 68.99,121 69.06,120.97 70.14,120.97 70.21,121 70.28,121 70.34,120.97 71.43,120.97 71.5,121 71.57,121 71.63,120.97 71.77,120.97 71.81,120.98 71.86,121 72.08,121 72.17,120.98 72.26,121 72.47,121 72.52,120.98 72.56,120.97 72.71,120.97 72.78,121 72.85,121 72.91,120.97 74.01,120.97 74.08,121 74.14,121 74.21,120.97 75.23,120.97 75.25,121 75.54,121 75.62,120.92 75.62,120.72 75.49,120.59 68.78,120.59 68.66,120.72 68.66,120.92 68.71,120.97 68.86,120.97 68.92,121
+0.85VS_VCCIO on IN3 (solid shape): 67.89,120.16 67.89,119.8 67.84,119.75 67.84,119.44 67.77,119.26 67.84,119.08 67.84,118.32 67.77,118.14 67.84,117.96 67.84,117.02 67.76,116.84 67.83,116.64 67.83,116.42 67.85,116.41 67.85,115.9 67.48,115.53 66.52,115.53 66.14,115.91 66.14,116.22 66.37,116.45 66.57,116.45 66.63,116.5 66.64,116.51 66.74,116.57 66.8,116.67 66.8,116.68 67.25,117.13 67.25,117.15 67.26,117.17 67.31,117.33 67.25,117.49 67.25,118.27 67.31,118.44 67.25,118.61 67.25,120.12 67.35,120.22 67.83,120.22
+0.85VS_VCCIO on IN3 (solid shape): 71.43,121.16 71.51,121.13 71.55,121.1 71.98,121.1 72.14,121.03 72.3,121.06 72.47,121.03 72.62,121.1 73.53,121.1 73.72,121.02 73.9,121.1 74.82,121.1 75,121.02 75.19,121.1 75.59,121.1 75.59,121.1 75.82,121.1 75.86,121.06 75.86,120.55 75.78,120.47 68.72,120.47 68.68,120.43 67.6,120.43 67.46,120.58 67.46,120.9 67.59,121.03 67.61,121.03 67.74,121.03 67.85,121.1 67.92,121.09 68,121.1 68.38,121.1 68.57,121.02 68.75,121.1 69.68,121.1 69.87,121.02 70.06,121.1 70.97,121.1 71.15,121.02 71.33,121.09 71.36,121.12
+0.85VS_VCCIO on GND3 (solid shape): 67.79,120.44 67.79,119.88 67.67,119.75 67.67,116.65 67.61,116.6 67.49,116.6 67.41,116.68 67.41,119.85 67.54,119.98 67.54,120.41 67.61,120.49 67.74,120.49
+0.85VS_VCCIO on IN4 (solid shape): 68.17,120.9 68.31,120.84 68.45,120.9 68.81,120.9 68.95,120.84 69.1,120.9 70.15,120.9 70.16,120.89 70.24,120.87 70.32,120.89 70.33,120.9 71.44,120.9 71.45,120.89 71.53,120.87 71.6,120.89 71.62,120.9 72.08,120.9 72.09,120.89 72.17,120.87 72.25,120.89 72.27,120.9 72.73,120.9 72.74,120.89 72.82,120.87 72.9,120.89 72.91,120.9 74.02,120.9 74.03,120.89 74.11,120.87 74.19,120.89 74.2,120.9 75.31,120.9 75.32,120.89 75.4,120.87 75.47,120.89 75.49,120.9 75.84,120.9 75.88,120.85 75.88,120.69 75.63,120.43 68.23,120.43 67.72,119.93 67.72,117.04 67.68,116.99 67.68,116.21 67.16,115.69 67.16,115.59 67.1,115.53 66.47,115.53 66.41,115.59 66.41,116.23 66.83,116.65 66.83,116.79 67.32,117.28 67.32,120.44 67.64,120.77 67.72,120.84 67.77,120.86 67.81,120.9
+0.85VS_VCCIO on VCC: 66.45,116.74 66.2,116.98 66.2,118.41 65.82,118.79 65.82,121.53 65.43,121.92 65.43,121.94 60.96,126.41 57.03,126.41 56.01,127.42 52.5,127.42 51.48,126.41 44.79,126.41 44.35,126.89 44.35,130.24 45.34,131.23 78.2,131.23 78.51,130.92 78.51,125.37 77.01,123.9 77.01,121.4 77.16,121.25 76.27,120.37 72.62,120.37 72.06,120.93 69.29,120.93 69.05,120.69 69.05,116.81 68.99,116.74
+0.85VS_VCCIOP on TOP (solid shape): 42.86,133.64 42.86,128.63 42.77,128.54 41,128.54 40.61,128.92 40.61,129.73 40.36,129.99 38.28,129.99 37.9,130.37 37.9,132.91 38.25,133.26 41.07,133.26 41.5,133.69 42.81,133.69
+0.95V_PRIM on TOP (solid shape): 168.29,113.41 168.29,111.56 168.2,111.47 167.23,111.47 167.21,111.5 167.21,113.45 167.46,113.71 168,113.71
+0.95V_PRIM on TOP (solid shape): 38.46,96.59 38.46,95.8 38.13,95.47 36.25,95.47 36.17,95.54 36.17,96.64 36.27,96.74 38.3,96.74
+0.95V_PRIM on TOP (solid shape): 40.34,103.05 39.41,102.12 39.41,100.83 39.33,100.75 38.2,100.75 38.1,100.85 38.1,102.44 38.89,103.23 40.16,103.23
+0.95V_PRIM on TOP (solid shape): 171.82,113.83 171.82,113.4 171.3,113.4 171.3,113.38 171.29,113.38 171.29,112.87 171.3,112.87 171.3,112.85 171.82,112.85 171.82,112.6 171.3,112.6 171.3,112.58 171.29,112.58 171.29,112.07 171.3,112.07 171.3,112.05 171.82,112.05 171.82,111.7 171.46,111.34 170.42,111.34 170.28,111.48 170.28,113.64 170.57,113.93 171.72,113.93
+0.95V_PRIM on TOP (solid shape): 54.83,118.66 54.83,118.65 54.83,117.54 54.67,117.39 54.06,117.39 53.79,117.12 52.21,117.12 51.8,117.54 47.97,117.54 47.44,117.01 46.95,117.01 46.89,117.07 46.89,118.14 46.99,118.24 48.29,118.24 48.5,118.46 49.68,118.46 49.69,118.45 49.78,118.45 49.8,118.45 50.28,118.21 50.81,118.13 51.29,118.18 51.73,118.35 51.76,118.37 52.03,118.55 52.27,118.78 54.71,118.78
+0.95V_PRIM on VCC (solid shape): 51.86,118.04 51.86,117.54 51.68,117.37 49.55,117.37 49.4,117.52 49.4,118.03 49.48,118.11 51.79,118.11
+0.95V_PRIM on VCC: 35.03,93 34.82,93.21 34.82,97.98 37.98,101.13 39.26,101.13 39.67,100.72 39.67,99.87 36.86,97.05 36.86,93.24 36.62,93
+0.95V_PRIM on VCC: 166.42,111.52 166.14,111.8 166.14,113.6 166.37,113.83 171.49,113.83 171.6,113.71 171.6,111.78 171.34,111.52
+0.95V_PRIMP on TOP (solid shape): 177.44,113.6 177.44,109.95 176.94,109.44 173.51,109.44 173.25,109.18 173.25,108.06 173.11,107.92 171.42,107.92 171.42,111.04 171.95,111.56 171.95,112.18 171.42,112.18 171.42,112.47 171.95,112.47 171.95,112.98 171.42,112.98 171.42,113.27 171.95,113.27 171.95,114.06 172.14,114.25 176.8,114.25
+1.0V_APLL on VCC (solid shape): 65.45,115.34 65.45,114.69 65.28,114.52 64.81,114.52 64.73,114.44 64.09,114.44 63.9,114.55 63.71,114.44 63.51,114.44 63.31,114.55 63.11,114.44 63.11,114.43 62.51,113.83 62.47,113.83 62.4,113.86 62.37,113.93 62.14,114.14 61.91,113.93 61.88,113.86 61.81,113.83 57.12,113.83 57.05,113.91 57.05,115 57.15,115.1 61.42,115.1 61.75,115.44 65.36,115.44
+1.0V_MPHYGT on BOTTOM (solid shape): 57.53,115.74 57.53,114.06 57.81,113.78 60.63,113.78 60.63,113.78 60.74,113.82 60.83,113.88 60.93,113.88 61.02,113.8 61.02,113.66 60.92,113.58 60.88,113.47 60.87,113.45 60.75,113.33 60.7,113.29 60.66,113.24 60.48,113.06 60.3,113.06 60.13,112.89 57.72,112.89 57.57,113.05 57.56,113.05 57.51,113.1 57.23,113.1 56.83,113.49 56.68,113.49 56.57,113.6 56.57,114.59 56.69,114.72 56.69,115.84 56.74,115.89 57.38,115.89
+1.0V_MPHYGT on IN1 (solid shape): 63.14,114.62 63.17,114.55 63.14,114.48 63.09,114.27 63.23,114.11 63.22,113.95 63.29,113.81 63.54,113.71 63.77,113.85 64.27,113.85 64.36,113.76 64.39,113.72 64.46,113.66 64.53,113.63 64.57,113.62 64.57,113.34 64.52,113.29 64.29,113.29 64.23,113.3 64.16,113.29 64.05,113.29 63.82,113.06 62.08,113.06 61.97,113.17 61.92,113.17 61.84,113.21 61.82,113.3 61.52,113.67 61.23,113.3 61.21,113.21 61.13,113.17 61.05,113.17 61.04,113.18 60.9,113.21 60.76,113.18 60.75,113.17 60.63,113.17 60.25,112.79 59.33,112.79 59.03,113.1 59.03,113.68 60.22,114.87 62.88,114.87
+1.0V_MPHYPLL on TOP (solid shape): 55.91,106.16 55.91,100.6 55.81,100.5 54.96,100.5 54.8,100.66 54.8,106.02 55.02,106.24 55.83,106.24
+1.0V_PRIM on TOP (solid shape): 167.04,124.87 167.04,119.79 166.81,119.56 163.16,119.56 162.96,119.76 162.96,124.93 163.45,125.42 166.5,125.42
+1.0V_PRIM on TOP (solid shape): 55.52,111.39 55.52,106.44 55.47,106.39 54.84,106.39 54.79,106.44 54.79,107.35 54.81,107.36 54.94,107.58 54.81,107.8 54.79,107.82 54.79,109.77 54.55,110.01 52.67,110.01 52.48,110.2 52.48,111.6 52.65,111.78 55.14,111.78
+1.0V_PRIM on TOP (solid shape): 61.29,121.48 61.29,115.55 61.38,115.45 61.38,107.06 61.92,106.52 61.92,103.25 61.84,103.08 61.92,102.9 61.92,100.28 63.3,98.91 85.25,98.91 86.08,98.08 86.08,95.42 85.52,94.86 60.49,94.86 59.7,95.65 59.7,105.93 59.96,106.19 59.96,106.49 59.75,106.7 59.46,106.7 59.08,106.31 59.08,121.45 59.17,121.54 61.23,121.54
