# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_TXN_P0_CONN: length 10.4
  IN1 w0.109: v2(108.38,102.13) v1(108.38,101.8)
  IN2 w0.079: v2(108.38,102.13) 108.24,101.99 108.24,101.31 108.46,101.09 108.63,101.09 108.78,101.24 108.78,101.56 108.97,101.74 109.3,101.74 109.47,101.57 109.47,101.13 109.53,101.08 109.73,101.08 109.78,101.13 109.78,101.6 109.89,101.7 109.95,101.77 109.99,101.8 110.3,101.8 110.47,101.63 110.47,101.13 110.54,101.06 111.09,101.06 111.45,100.7 111.45,99.94 111.55,99.84 v2(111.63,99.84)
  IN3 w0.084: v7(111.68,98.9) 111.45,99.13 111.45,99.71 111.58,99.84 v2(111.63,99.84)
  BOTTOM w0.119: JEDP1.8 111.93,97.99 111.76,98.16 111.76,98.36 111.52,98.61 111.52,98.73 111.57,98.78 v7(111.68,98.9)
EDP_TXN_P0_R: length 1.2
  TOP w0.119: C152.2 108.21,104 108.21,103.44 108.38,103.27 L13.1
EDP_TXN_P1: length 43.4
  IN1 w0.109: v2(109.12,105.25) 109.14,105.25 109.29,105.1 109.29,105.1 109.4,104.99 109.4,104.8 109.32,104.73 v1(109.22,104.73)
  IN3 w0.06: 77.65,104.84 77.55,104.94 77.54,104.94 75.23,107.25 75.23,107.74 74.58,108.4 74.58,108.6 73.94,109.24 73.94,110.19 73.58,110.55 73.58,110.77 73.66,110.85 73.66,111.02 73.46,111.22 v10(73.46,111.43)
  IN3 w0.084: v2(109.12,105.25) 109.14,105.25 109.4,104.99 109.4,104.92 109.12,104.64 107.64,104.64 107.43,104.85 107.43,105.34 107.15,105.63 106.08,105.63 105.54,105.09 96.33,105.09 96.26,105.03 90.6,105.03 90.37,104.8 89.63,104.8 89.2,104.37 83.81,104.37 83.68,104.5 81.17,104.5 80.59,103.92 78.57,103.92 77.65,104.84
EDP_TXN_P1_CONN: length 8.1
  IN1 w0.109: v1(109.27,101.8) 109.27,102.08 v2(109.22,102.13)
  IN2 w0.079: v2(109.22,102.13) 109.39,102.3 109.39,102.52 109.63,102.77 109.74,102.77 110.21,102.77 112.68,100.3 112.68,99.99 v2(112.83,99.85)
  IN3 w0.084: v7(112.88,98.92) 112.85,98.92 112.74,99.04 112.74,99.76 v2(112.83,99.85)
  BOTTOM w0.119: JEDP1.4 113.13,97.97 112.96,98.14 112.96,98.43 112.88,98.51 v7(112.88,98.92)
EDP_TXN_P1_R: length 1.2
  TOP w0.119: L14.4 109.27,103.22 109.39,103.33 109.39,103.59 109.36,103.61 109.36,104 C153.2
EDP_TXP_P0: length 41.3
  IN1 w0.109: v1(107.8,104.73) 107.84,104.69 107.98,104.69 108.07,104.79 108.07,104.92 108.02,104.97 108.02,105.07 107.95,105.15 v2(107.82,105.15)
  IN3 w0.06: 78.59,105.11 78.58,105.11 78.56,105.13 78.47,105.13 78.23,104.89 77.8,104.89 75.39,107.3 75.39,107.9 74.84,108.45 74.84,108.71 74.2,109.34 74.2,110.39 73.9,110.69 v10(73.78,110.69)
  IN3 w0.084: v2(107.82,105.15) 108.07,105.39 108.07,105.98 108.01,106.03 107.87,106.03 107.7,105.86 107.49,105.86 107.31,106.03 105.89,106.03 105.34,105.48 96.17,105.48 96.1,105.42 92.4,105.42 91.82,106 91.02,106 90.25,105.23 89.5,105.23 88.99,104.73 84,104.73 83.84,104.89 82.29,104.89 82.13,104.74 80.68,104.74 80.61,104.81 80.03,104.81 79.95,104.74 79.12,104.74 78.75,105.11 78.59,105.11
EDP_TXP_P0_CONN: length 10.5
  IN1 w0.109: v1(107.88,101.8) 107.88,102.08 v2(107.83,102.13)
  IN2 w0.079: v2(107.83,102.13) 107.94,102.13 108.05,102.02 108.05,101.23 108.38,100.9 108.71,100.9 108.97,101.16 108.97,101.48 109.04,101.56 109.22,101.56 109.28,101.49 109.28,101.06 109.45,100.89 109.8,100.89 109.97,101.06 109.97,101.52 110.06,101.62 110.23,101.62 110.29,101.56 110.29,101.06 110.46,100.88 111.01,100.88 111.27,100.62 111.27,100.01 v2(111.1,99.84)
  IN3 w0.084: v7(111.08,98.9) 111.29,99.11 111.29,99.72 111.18,99.84 v2(111.1,99.84)
  BOTTOM w0.119: JEDP1.10 111.33,98 111.5,98.17 111.5,98.25 111.26,98.5 111.26,98.72 v7(111.08,98.9)
EDP_TXP_P0_R: length 1.2
  TOP w0.119: C151.2 107.95,103.99 107.95,103.43 107.88,103.35 L13.4
EDP_TXP_P1: length 43.4
  IN1 w0.109: v2(109.65,105.25) 109.65,104.85 v1(109.78,104.73)
  IN3 w0.06: 77.42,104.84 77.42,104.89 75.11,107.2 75.11,107.69 74.46,108.35 74.46,108.55 73.82,109.19 73.82,110.14 73.46,110.5 73.46,110.65 73.24,110.88 73.24,110.99 73.3,111.04 73.36,111.04 v10(73.46,110.94)
  IN3 w0.084: v2(109.65,105.25) 109.56,105.16 109.56,104.85 109.18,104.48 107.58,104.48 107.27,104.78 107.27,105.27 107.08,105.47 106.15,105.47 105.61,104.93 96.4,104.93 96.33,104.87 90.67,104.87 90.44,104.64 89.7,104.64 89.27,104.21 83.74,104.21 83.61,104.34 81.24,104.34 80.66,103.75 78.51,103.75 77.42,104.84
EDP_TXP_P1_CONN: length 8.1
  IN1 w0.109: v2(109.77,102.13) v1(109.77,101.8)
  IN2 w0.079: v2(112.29,99.85) 112.39,99.85 112.5,99.95 112.5,100.22 110.13,102.58 109.71,102.58 109.58,102.45 109.58,102.2 109.64,102.13 v2(109.77,102.13)
  IN3 w0.084: v2(112.29,99.85) 112.39,99.85 112.48,99.76 112.48,99.71 112.58,99.61 112.58,99.04 112.57,99.03 112.57,99.01 112.48,98.92 v7(112.28,98.92)
  BOTTOM w0.119: JEDP1.6 112.53,97.98 112.7,98.15 112.7,98.32 112.62,98.4 112.62,98.58 v7(112.28,98.92)
EDP_TXP_P1_R: length 1.2
  TOP w0.119: C154.2 109.63,103.99 109.63,103.72 109.65,103.7 109.65,103.34 109.77,103.22 L14.1
EMMC_RCOMP: length 4.3
  BOTTOM w0.381: UC1.BC1 60.52,121.72 59.5,121.72 58.93,122.29 58.11,122.29 57.89,122.52 57.33,122.52 RC41.2
EN: length 3.5
  BOTTOM w0.119: PU400.15 126.98,107.54 PC409.1 127.44,107.08 128.2,107.08 PR407.1 PR406.2
EN_0.6V: length 5.5
  TOP w0.254: PR709.2 128.52,116.84 v1(128.52,116.27)
  IN1 w0.254: v1(128.52,116.27) 128.4,116.14 v2(128.03,116.14)
  IN3 w0.254: v2(128.03,116.14) 128.03,115.97 v7(128.28,115.72)
  BOTTOM w0.254: v7(128.28,115.72) 128.27,115.73 PR707.1 128.28,116.62 PC714.1 127.83,117.5 127.47,117.86 PU700.16
EN_0.85VS_VCCIO: length 12.8
  TOP w0.254: PU808.13 37.96,138.97 37.12,138.97 36.83,138.67 36.83,136.97 36.25,136.39 34.52,136.39 33.6,135.47 33.6,133.33 33.08,132.81 32.56,132.81 32.16,132.41 PC800.1 32.16,131.36 PR804.1 32.13,130.44 PR803.2
EN_1.0V_PRIM:
  vias: v4(171.42,118.1) v4(171.42,117.82) v4(172.75,117.85) v4(172.75,117.57)
EN_1.2V: length 5.4
  TOP w0.119: PC718.1 126.53,118.82 v1(125.6,118.82) ; PC718.1 PR710.1 ; PC718.1 PR708.2
  IN1 w0.084: v1(125.6,118.82) 125.62,118.81 126.07,118.81 v2(126.1,118.84)
  IN3 w0.084: v2(126.1,118.84) 126.11,118.82 126.11,118.61 126.36,118.36 v7(127,118.36)
EN_CAM#: length 132.8
  TOP w0.119: v1(152.54,132.89) 152.54,131.46 152.17,131.09 152.17,129.43 150.7,127.96 R85.2 150.62,127.92 150.23,127.52 149.4,127.52 Q9.2
  IN1 w0.084: v1(152.54,132.89) 148.73,132.89 147.4,131.57 147.4,131.02 146.52,130.15 145.57,130.15 145.29,130.43 143.85,130.43 142.93,129.5 142.93,128.84 142.39,128.3 138.07,128.3 137.72,127.96 134.98,127.96 132.89,125.86 131.93,125.86 130.59,124.51 130.08,124.51 129.35,123.78 129.06,123.78 128.66,123.38 127.58,123.38 127.08,122.88 127.08,122.56 126.4,121.88 120.42,121.88 119.58,122.72 119.43,122.72 118.69,123.46 118.69,125.02 117.22,126.5 117.22,126.75 116.73,127.23 114.35,127.23 111.99,129.6 111.99,130.63 109.39,133.23 105.72,133.23 104.86,132.37 99.97,132.37 99.25,131.66 97.76,131.66 97.51,131.91 93.62,131.91 93.05,131.34 90.45,131.34 89.79,132 88.1,132 86.5,130.41 78.18,130.41 77.66,129.88 76.63,129.88 75.69,128.94 72.49,128.94 71.74,129.68 70.77,129.68 70.58,129.88 66.15,129.88 65.69,129.41 64.65,129.41 61.02,125.79 60.15,125.79 58.16,123.81 57.33,123.81 v2(56.59,124.55)
  IN3 w0.06: v10(64.45,121.53) 64.45,121.28 64.25,121.09 64.04,121.09 63.8,121.33 63.71,121.33 63.67,121.36 63.51,121.36 63.47,121.33 63.26,121.33 63.18,121.4 62.83,121.4 62.7,121.53 62.7,121.62 62.81,121.72 62.81,121.89 62.6,122.1 61.7,122.1 60.22,123.57 60.05,123.57 59.8,123.82 59.37,123.82 59.19,123.99 59.19,124.01 59.06,124.14 58.94,124.14 58.94,124.15 58.92,124.15 58.92,124.14 58.5,124.14 58.5,124.15 58.44,124.15 58.16,123.86 57.79,123.86 57.2,124.45 56.68,124.45 v2(56.59,124.55)
EN_INVPWR: length 102.5
  IN1 w0.084: v2(127.42,120.84) 127.46,120.8 132.19,120.8 133.92,122.53 134.5,122.53 135.61,123.64 137.23,123.64 137.71,124.12 141.26,124.12 146.11,128.97 v2(146.77,128.97) ; v1(190.3,133.9) 190.6,133.9 v2(190.65,133.85)
  IN3 w0.084: v2(190.65,133.85) 190.43,133.85 v7(190.32,133.74) 190.2,133.74 189.94,134 189.69,134 189.42,133.73 189.42,132.92 189.12,132.62 188.6,132.62 188.42,132.44 186.95,132.44 186.53,132.02 186.53,131.02 186.06,130.54 186.02,130.54 185.75,130.28 185.75,129.85 185.59,129.68 185.22,129.68 184.36,130.54 181.77,130.54 181.38,130.14 179.07,130.14 178.28,130.93 167.37,130.93 165.52,132.78 156.37,132.78 152.31,128.72 148.67,128.72 148.41,128.97 146.77,128.97 v2(146.77,128.97) ; v7(112.84,107.1) 113.02,106.92 119.95,106.92 120.17,107.14 120.17,111.78 122.43,114.04 126.47,114.04 127.57,115.13 127.57,120.7 v2(127.42,120.84)
  BOTTOM w0.119: v7(112.84,107.1) 113.23,107.5 113.23,108.27 113.57,108.6 U41.2
ENBKL: length 65.1
  IN1 w0.084: v2(60.07,107.79) 60.45,107.79 61.11,107.13 61.69,107.13 61.81,107.24 62.29,107.24 62.52,107.01 62.52,104.17 63.48,103.21 64.29,103.21 65.04,102.46 66.65,102.46 66.7,102.41 68.5,102.41 69.37,101.55 72.35,101.55 72.77,101.12 74.69,101.12 75.4,101.83 76.4,101.83 77.42,102.85 79.06,102.85 79.96,103.75 80.78,103.75 81.39,104.36 82.61,104.36 83.69,105.44 87.95,105.44 88.2,105.69 90.87,105.69 91.36,106.19 94.91,106.19 96.82,104.27 97.54,104.27 97.74,104.07 99.35,104.07 100.67,102.75 v2(101.28,102.75)
  IN3 w0.06: v3(60.1,108.12) 60.1,107.81 v2(60.07,107.79)
  IN3 w0.084: v2(101.28,102.75) 101.27,102.74 v3(101.72,102.74)
  IN4 w0.06: v3(60.1,108.12) 60.1,108.3 60.41,108.62 60.41,108.88 60.64,109.12 60.64,109.21 61.33,109.89 61.33,110.16 61.46,110.29 v5(61.47,110.29)
  IN4 w0.089: v4(111.53,104.71) 110.08,103.27 102.25,103.27 v3(101.72,102.74)
  BOTTOM w0.119: v4(111.53,104.71) 111,104.71 D37.2
ENLDO: length 2.9
  IN3 w0.254: v7(26.92,116.65) 26.92,115.55 28.17,114.3 v7(28.17,114.29)
ENVDD: length 84.1
  TOP w0.119: D16.1 101.83,103.22 102.25,102.8 R168.1 102.88,102.8 v1(103.2,103.11)
  IN1 w0.084: v1(103.2,103.11) 103.74,102.57 104.82,102.57 106.08,101.31 110.28,101.31 112.09,103.12 112.62,103.12 115.03,105.53 129.94,105.53 130.76,106.35 131.81,106.35 132.33,106.87 133.53,106.87 134.24,106.16 v2(134.24,106.03)
  IN3 w0.084: v2(134.24,106.03) 134.58,105.69 146.13,105.69 146.54,106.11 148.16,106.11 148.71,105.56 149.8,105.56 150.47,106.23 152.51,106.23 153.18,105.56 153.9,105.56 154.21,105.87 158.93,105.87 159.23,105.56 162.28,105.56 166.58,109.86 176.73,109.86 v7(178.06,108.53)
EXT_PWR_GATE#: length 73.2
  IN3 w0.084: v6(45.16,94.53) 44.99,94.7 44.99,100.98 43.61,102.36 43.61,107.96 44.22,108.57 44.22,110.25 44.4,110.43 44.4,116.36 43.62,117.14 43.62,120.13 42.98,120.76 v6(42.98,121.14)
  IN4 w0.06: 54.58,122.72 54.74,122.56 56.33,122.56 56.47,122.42 56.93,122.42 57.14,122.22 57.14,121.87 57.38,121.63 58.23,121.63 58.5,121.9 58.78,121.9 58.95,121.73 59.81,121.73 59.98,121.9 60.52,121.9 60.63,122.01 61.19,122.01 61.19,122.01 61.21,122.01 61.29,121.93 61.78,121.93 61.85,121.86 61.91,121.81 v5(62.11,121.81)
  IN4 w0.089: v6(45.16,94.53) 46.71,94.53 47.39,95.21 50.07,95.21 50.61,94.67 51.09,94.67 52.16,93.6 58.29,93.6 59.87,95.19 60.61,95.19 61.17,94.62 62.95,94.62 v4(63.45,95.13) ; 54.58,122.72 54.56,122.72 54.28,123 54.28,123 54.12,123.16 53.89,123.16 53.86,123.13 53.54,123.13 53.52,123.15 53.37,123.15 52.04,124.48 51.36,124.48 50.52,125.33 47.88,125.33 47.61,125.06 47.61,124.1 47.88,123.83 47.88,122.93 47.62,122.67 46.9,122.67 46.24,122.01 44.07,122.01 43.2,121.14 v6(42.98,121.14)
EXT_PWR_GATE#_R: length 64.2
  IN3 w0.084: v3(41.14,123.87) 41.05,123.79 41.05,116.99 42.64,115.4 42.64,111.34 42.45,111.15 42.45,110.48 42.07,110.1 42.07,98.45 42.07,98 43.26,96.82 43.26,94.37 v3(43.17,94.28)
  IN4 w0.089: v3(43.17,94.28) 43.87,94.98 46.89,94.98 47.63,95.72 48.62,95.72 48.84,95.95 49.6,95.95 50.66,94.89 51.17,94.89 51.6,94.46 58.87,94.46 60.91,96.5 62.12,96.5 62.41,96.21 62.95,96.21 v4(63.45,95.71) 64.48,95.71 64.65,95.87 64.65,96.67 v4(64.77,96.79) ; v3(41.14,123.87) 41.22,123.95 45.63,123.95 45.93,123.65 46.39,123.65 46.79,124.04 47.14,124.04 47.47,123.71 v4(47.47,122.99)
  BOTTOM w0.119: v4(64.77,96.79) 64.8,96.81 U50.5
F1_ISENN_GT: length 2.2
  BOTTOM w0.254: PU1101.F1 114.01,121.38 PC1131.2 PR1145.2
F4_VR_ON: length 6
  IN3 w0.06: 115.16,120.6 115.03,120.46 114.25,120.46 114.05,120.26 114.05,120.11 113.83,119.89 v7(113.83,119.7)
  IN3 w0.254: v7(116.71,121.78) 116.54,121.61 115.9,121.61 115.65,121.35 115.65,121.1 115.16,120.62 115.16,120.6
  BOTTOM w0.254: PR1107.2 118.39,121.78 v7(116.71,121.78)
F8_ISENN_IA: length 2.6
  BOTTOM w0.254: PU1101.F8 113.83,117.49 114.73,116.59 PR1148.1 115.09,116.16 PR1146.1
FB_1.8V: length 3.4
  TOP w0.254: PU1000.1 33.19,113.11 32.6,113.7 PC1002.2 PR1004.2 PR1005.1
FP_POA_EN: length 66.4
  IN3 w0.084: v3(198.61,131.08) 198.5,131.19 197.94,131.19 197.39,131.74 195.55,131.74 195.27,131.46 193.73,131.46 192.33,130.07 191.1,130.07 188.95,127.92 186.99,127.92 186.46,128.44 186.46,129.45 185.94,129.98 185.94,130.2 186.09,130.36 186.17,130.36 186.71,130.9 186.71,131.94 187.03,132.25 188.5,132.25 188.68,132.43 189.19,132.43 189.61,132.84 189.61,133.52 v7(189.82,133.74)
  IN4 w0.089: v3(198.61,131.08) 198.76,130.94 201.79,130.94 205.07,127.65 205.07,119.37 202.93,117.23 202.93,113.95 200.69,111.71 200.69,107.73 199.3,106.34 198.66,106.34 197.07,104.75 197.07,104.56 196.77,104.26 196.77,101.6 v4(196.76,101.59)
  BOTTOM w0.119: JUSH1.5 201.43,100.58 201.57,100.72 201.57,100.82 201.36,101.04 197.31,101.04 v4(196.76,101.59)
FP_POA_WAKE#: length 63.6
  IN3 w0.084: v3(198.17,131.79) 197.87,131.79 197.55,132.11 195.4,132.11 195.12,131.83 193.57,131.83 192.18,130.44 190.94,130.44 189.81,129.31 188.86,129.31 188.44,129.73 188.44,129.88 v7(188.37,129.95) 188.43,130.01 188.43,131.21 189.28,132.06 189.35,132.06 189.98,132.69 189.98,132.76 190.21,132.99 190.44,132.99 190.58,133.13 190.58,133.36 190.73,133.51 190.79,133.51 190.99,133.71 190.99,134.05 190.8,134.24 v7(190.32,134.24)
  IN4 w0.089: v4(197.19,101.6) 197.04,101.75 197.04,104.26 197.26,104.48 197.26,104.67 198.74,106.15 199.38,106.15 200.88,107.65 200.88,111.63 203.12,113.88 203.12,117.15 205.79,119.82 205.79,122.94 206.06,123.21 206.06,127.99 202.83,131.22 202.13,131.22 201.56,131.79 v3(198.17,131.79)
  BOTTOM w0.119: JUSH1.4 201.93,100.62 201.8,100.76 201.8,100.91 201.45,101.26 197.54,101.26 v4(197.19,101.6)
G1_ISENP_GT: length 11.1
  IN3 w0.254: v3(116.18,125.49) 116.18,124.86 114.76,123.44 114.76,122.07 114.72,122.04 v7(114.72,121.96)
  IN4 w0.254: v5(114.66,125.95) 114.96,125.95 115.42,125.49 v3(116.18,125.49)
  BOTTOM w0.254: PR1141.1 110.73,126.69 PR1155.2 112.48,125.95 PR1143.1 PC1127.1 v5(114.66,125.95) ; PU1101.G1 114.39,121.26 114.39,121.63 v7(114.72,121.96)
G2_FB_GT: length 4.7
  TOP w0.305: v9(115.65,122.52) 115.62,122.54 114.78,122.54 PR1130.2 PR1126.2
  GND1 w0.305: v9(115.65,122.52) 115.65,122.42 v2(115.98,122.09)
  IN3 w0.254: v7(114.33,120.7) 114.74,120.7 115.23,121.19 115.23,121.44 115.88,122.09 v2(115.98,122.09)
G3_COMP_SA: length 6.2
  IN3 w0.254: v7(117.7,123.28) 117.09,122.67 117.09,121.66 116.51,121.07 116.51,120.99 116.26,120.74 115.98,120.74 115.39,120.16 114.37,120.16 v7(114.33,120.2)
  BOTTOM w0.254: v7(117.7,123.28) 117.72,123.3 PR1118.1
G4_FB_SA: length 9.7
  TOP w0.254: PR1102.1 PR1100.1 120.27,118.07 120.52,117.82 120.52,116.61 PR1006.1
  IN1 w0.254: v2(117.66,118.47) 118.48,118.47 118.85,118.84 119.86,118.84 v1(119.88,118.82)
  IN3 w0.254: v2(117.66,118.47) 117.56,118.37 116.17,118.37 114.78,119.75 v6(114.78,119.83)
  IN4 w0.203: v6(114.78,119.83) 114.65,119.7 v4(114.33,119.7)
G6_CNFG: length 7
  IN4 w0.254: v4(114.33,118.7) 114.88,118.15 v4(117.56,118.15)
  BOTTOM w0.254: v4(117.56,118.15) 117.75,118.15 PR1122.1 PC1116.1 119.66,117.13 119.66,116.83 PR409.1
G8_ISENP_IA: length 11
  BOTTOM w0.254: PR1142.1 113.79,112.34 113.94,112.18 PR1153.2 115.09,112.18 115.42,112.51 115.42,113.33 PR1144.1 115.59,113.51 PC1129.1 116.87,113.51 116.99,113.63 116.99,115.67 PC1130.1 116.48,116.43 116.2,116.71 115.51,116.71 115.01,117.21 114.66,117.21 114.33,117.55 PU1101.G8
GNSS_IRQ: length 215.8
  TOP w0.119: v1(210.22,139.85) 210.23,139.85 210.23,138.25 R20.2
  IN1 w0.084: v1(45.39,118) 45.75,118 v2(45.82,118.07) 47,119.26 47,121.44 47.43,121.87 48.36,121.87 49.52,123.04 49.52,124.61 51.69,126.78 52.84,126.78 53.15,126.47 53.62,126.47 55.25,128.1 56.7,128.1 56.85,128.25 57.99,128.25 59.75,130.01 60.66,130.01 62.9,132.25 64.88,132.25 64.94,132.18 68.4,132.18 69.51,133.29 71.59,133.29 72.23,132.65 74.32,132.65 74.86,132.11 76.73,132.11 77.31,132.68 85.63,132.68 87.29,134.35 95,134.35 95.06,134.41 99.16,134.41 99.35,134.6 99.56,134.6 99.57,134.6 106.33,134.6 106.34,134.6 119.23,134.6 121.1,132.72 121.1,131.24 121.29,131.05 121.29,130.19 122.63,128.85 123.01,128.85 123.11,128.75 125.25,128.75 125.68,128.31 126.91,128.31 126.99,128.39 128.32,128.39 128.79,128.86 129.19,128.86 129.28,128.95 130.04,128.95 130.16,129.07 132.44,129.07 133.99,130.62 136.13,130.62 140.11,134.6 167.97,134.6 168.8,133.77 168.81,133.77 172.3,130.28 176.6,130.28 177.03,129.85 177.82,129.85 178.37,130.41 178.37,131.13 179.44,132.2 179.92,132.2 181.75,134.03 181.75,135.18 184.04,137.47 184.83,137.47 185.17,137.81 185.17,138.87 186.88,140.57 188.04,140.57 191.14,143.68 194.4,143.68 196.77,146.06 203.72,146.06 207.5,142.28 208.69,142.28 209.26,141.7 209.26,140.82 v1(210.22,139.85)
  IN3 w0.06: 56.6,119.14 57.41,118.33 60.01,118.33 60.2,118.14 60.24,118.14 62.05,118.14 62.17,118.26 v10(62.36,118.26)
  IN3 w0.084: v2(45.82,118.07) 46.28,118.54 47.98,118.54 48.76,117.76 52.05,117.76 53.14,118.86 53.17,118.86 53.5,119.19 53.98,119.19 54.1,119.06 54.48,119.06 54.73,118.81 55.38,118.81 55.5,118.93 55.75,118.93 55.96,119.14 56.6,119.14
GNSS_IRQ_L: length 0.8
  IN1 w0.084: v2(210.91,137.52) 210.86,137.47 210.82,137.47 v1(210.6,137.25)
  IN3 w0.084: v2(210.91,137.52) 210.85,137.46 v7(210.51,137.46)
GNSS_OFF#: length 218.8
  IN1 w0.084: v1(209.51,133.32) 209.21,133.62 208.75,133.62 207.43,132.3 207.43,130.37 v2(207.51,130.29) ; v2(129.18,114.24) 130.23,115.29 130.23,116.43 129.17,117.49 123.49,117.49 123.33,117.33 121.52,117.33 120.02,115.82 120.02,115.5 119.16,114.64 115.98,114.64 114.4,116.22 114.4,116.51 111.06,119.85 111.06,124.2 110.3,124.96 109.67,124.96 109.1,125.52 101.77,125.52 101.21,124.96 99.24,124.96 98.03,123.75 97.92,123.75 97.43,123.27 97.43,121.74 96.71,121.02 96.24,121.02 95.78,121.47 88.13,121.47 87.49,120.83 86.44,120.83 85.28,121.99 82.32,121.99 82.16,121.83 81.6,121.83 81.24,122.19 79.84,122.19 79.51,122.53 77.3,122.53 76.33,123.5 66.21,123.5 63.43,120.72 63.43,119.99 61.92,118.48 61.92,118.31 60.98,117.37 60.65,117.37 v2(60.3,117.72)
  IN2 w0.079: v2(207.51,130.29) 208.45,130.29 209.63,129.11 209.63,126.5 209.15,126.03 209.15,120.47 208.84,120.15 208.84,115.57 206.42,113.15 204.61,113.15 203.42,111.96 203.42,106.21 203.51,106.11 203.51,105.25 203.11,104.85 202.82,104.85 202.56,105.1 202.56,105.86 202.39,106.03 200.77,106.03 198.39,103.65 184.87,103.65 184.32,103.1 184.32,103.1 184.26,103.05 184.26,103.05 184.21,103 149.68,103 148.69,102.01 142.73,102.01 141.18,103.56 135.82,103.56 135.45,103.94 135.45,105.45 132.92,107.98 132.92,110.77 130.07,113.62 129.6,113.62 129.18,114.04 v2(129.18,114.24)
  IN3 w0.06: v10(63.35,118.26) 63.26,118.18 63.26,118.06 63.13,117.94 62.72,117.94 62.6,117.82 62.28,117.82 62.11,117.65 62.07,117.65 62.07,117.65 61.2,117.65 60.97,117.42 60.6,117.42 60.37,117.65 v2(60.3,117.72) 60.12,117.72 59.75,118.09 59.69,118.09 57.25,118.09 56.57,118.76
  IN3 w0.084: 56.57,118.76 56.11,118.76 55.9,118.55 55.66,118.55 55.09,117.98 v7(55.09,117.71)
GNSS_OFF#_R: length 16
  TOP w0.119: Q4.4 210.55,133.32 210.03,132.81 209.02,132.81 v1(209,132.82) 208.33,132.82 207.92,133.23 R31.2
  IN1 w0.084: v2(209.35,132.81) 209.02,132.81 v1(209,132.82)
  IN3 w0.084: v7(209.14,140.79) 209.18,140.75 209.18,139.6 209.35,139.43 v2(209.35,132.81)
  BOTTOM w0.119: v7(209.14,140.79) 209.12,140.81 209.12,141.75 209.33,141.96 JNGFF1.18
GNSS_SCL: length 200.9
  TOP w0.119: R14.2 210.73,139.27 210.73,140.76 v1(210.43,141.06)
  IN1 w0.109: v1(210.43,141.06) 210.54,141.18 210.54,145.81 v2(210.68,145.95)
  IN2 w0.079: v2(52.73,122.19) 52.73,122.82 51.35,124.2 51.35,126.56 51.47,126.68 51.47,127.9 51.71,128.15 51.72,128.15 51.85,128.28 51.85,128.58 53.04,129.76 55.59,129.76 55.74,129.62 56.27,129.62 56.75,130.1 56.75,130.65 57.74,131.65 58.74,131.65 59,131.38 59.54,131.38 62.56,134.41 64.27,134.41 64.35,134.49 64.48,134.49 64.76,134.77 72.54,134.77 72.95,135.18 94.44,135.18 95.03,135.78 95.7,135.78 96.19,135.29 97,135.29 110.55,135.29 111.2,135.94 120.12,135.94 121.73,134.34 124.46,134.34 126.55,132.25 130.15,132.25 130.7,131.7 131.37,131.7 131.84,132.18 134.03,132.18 137.53,135.68 137.53,135.68 137.8,135.95 137.88,136.03 169.49,136.03 173.78,131.74 176.9,131.74 177,131.83 177.6,131.83 179.67,133.9 179.88,133.9 180.42,134.43 180.42,134.86 182.18,136.62 182.89,136.62 188.27,142 193.17,142 197.81,146.64 209.99,146.64 v2(210.68,145.95)
  IN3 w0.06: v10(62.61,119.87) 62.18,119.87 62.11,119.95 61.68,119.95 61.43,120.2 60.93,120.2 60.04,121.09 59.82,121.09 59.6,121.09 58.81,121.88 56.27,121.88 55.79,122.36 55.32,122.36 55.12,122.15
  IN3 w0.084: v2(52.73,122.19) 53.38,122.19 53.86,122.66 54.93,122.66 55.08,122.51 v7(55.08,122.11) 55.12,122.15
GNSS_SCL_L: length 0.9
  IN1 w0.109: v1(210.63,138.58) 210.65,138.58 v2(210.92,138.32)
  IN3 w0.084: v2(210.92,138.32) 210.78,138.46 v7(210.51,138.46)
GNSS_SDA: length 205.9
  TOP w0.119: v1(211.15,141.05) 211.26,140.93 211.26,138.52 R19.2
  IN1 w0.109: v2(211.33,145.98) 211.15,145.79 v1(211.15,141.05)
  IN2 w0.079: v2(52.94,119.92) 52.94,119.92 52.94,120.61 50.64,122.91 50.64,123.74 49.95,124.42 49.95,125.56 51.19,126.8 51.19,127.68 51.02,127.85 51.02,128.77 51.59,129.34 51.59,130.29 51.94,130.64 52.97,130.64 53.39,130.22 54.7,130.22 55.15,130.68 56.13,130.68 57.55,132.11 59.07,132.11 62.21,135.24 68.66,135.24 68.8,135.38 72.5,135.38 72.76,135.64 94.25,135.64 94.84,136.24 95.89,136.24 96.38,135.75 96.96,135.75 110.36,135.75 111.01,136.4 120.32,136.4 121.92,134.8 124.66,134.8 126.75,132.71 133.91,132.71 137.69,136.49 169.68,136.49 173.86,132.31 177.32,132.31 179.49,134.48 179.49,134.58 181.98,137.08 182.15,137.08 182.19,137.12 182.75,137.12 184.28,138.65 184.28,139.38 187.16,142.26 187.75,142.26 187.96,142.47 192.98,142.47 197.62,147.1 210.21,147.1 v2(211.33,145.98)
  IN3 w0.06: v10(62.11,118.59) 61.71,118.99 61.28,118.99 61.28,118.99 61.03,119.24 60.54,119.24 59.67,120.11 59.1,120.11 58.08,119.09 57.24,119.09 57.02,119.3 57.02,119.45 56.64,119.83
  IN3 w0.084: v2(52.94,119.92) 52.97,119.89 54.49,119.89 54.67,119.7 54.82,119.7 v7(55.02,119.51) 55.2,119.69 55.62,119.69 55.75,119.83 56.64,119.83
GNSS_SDA_L: length 1.5
  IN1 w0.109: v1(211.21,137.89) 211.34,137.89 v2(211.54,138.09)
  IN3 w0.084: v2(211.54,138.09) 211.41,137.96 v7(210.51,137.96)
GNSS_SYSCLK: length 0.9
  IN1 w0.084: v2(211.02,137.02) 211.07,136.97 v1(211.4,136.97)
  IN3 w0.084: v2(211.02,137.02) 210.57,137.02 v7(210.51,136.96)
GPP_B18: length 16.4
  TOP w0.119: RC11.2 47.99,124.95 48.41,124.95 49.52,123.84 v1(50.19,123.84)
  IN1 w0.084: v1(50.19,123.84) 50.19,123.23 v2(50.29,123.13)
  GND3 w0.084: v12(51.16,123.64) 50.65,123.13 v2(50.29,123.13)
  IN4 w0.06: 55.81,121.71 56.25,121.27 58.38,121.27 58.45,121.2 59.78,121.2 60.13,121.54 60.94,121.54 61,121.48 v5(61.37,121.48)
  IN4 w0.089: 55.81,121.71 54.46,121.71 53.99,122.18 53.38,122.18 52.2,123.37 51.43,123.37 v12(51.16,123.64)
GPP_B22: length 17.2
  TOP w0.119: RC12.2 48.31,123.13 TC2.1 50.44,123.48 50.74,123.19 v1(50.76,123.19)
  IN1 w0.084: v1(50.76,123.19) 51.9,123.19 52.46,122.63 52.78,122.63 53.41,122 53.41,120.86 v2(53.39,120.84)
  IN3 w0.084: v2(53.39,120.84) 53.55,120.69 v3(53.84,120.69)
  IN4 w0.06: v5(62.36,120.84) 62.36,121.16 62.28,121.24 62.08,121.24 62,121.16 61.69,121.16 61.66,121.14 61.65,121.14 61.56,121.04 61.03,121.04 60.74,120.75 60.37,120.75 60.33,120.72 58.75,120.72 58.69,120.65 55.56,120.65 55.28,120.36 54.6,120.36
  IN4 w0.089: 54.6,120.36 54.45,120.36 54.13,120.69 v3(53.84,120.69)
GPP_D10: length 18.5
  IN4 w0.06: v5(62.11,113.43) 61.99,113.31 61.78,113.31 61.7,113.23 60.86,113.23 58.93,111.3 57.78,111.3 v4(57.63,111.45) 57.61,111.47 57.15,111.47 56.78,111.84 56.45,111.84 55.91,111.29 55.91,111.09 55.73,110.91 55.02,110.91 54.69,111.24 53.49,111.24 53.38,111.13 53.16,111.13
  IN4 w0.089: v4(52.21,104.8) 52.1,104.92 52.1,107.13 52.11,107.14 52.11,109.54 52.1,109.55 52.1,110.09 53.13,111.13 53.16,111.13
  BOTTOM w0.119: v4(52.21,104.8) 52.21,104.65 52.7,104.16 RH124.1
GPP_E1: length 13.2
  IN4 w0.06: 59.64,106.32 59.64,109.71 60.93,111 61.24,111 61.32,110.92 61.55,110.92 61.55,110.92 61.61,110.98 61.95,110.98 62.16,111.19 62.16,111.26 62.31,111.41 63.14,111.41 v5(63.16,111.43)
  IN4 w0.089: 59.64,106.32 59.64,105.37 59.72,105.29 v4(59.72,104.09)
  BOTTOM w0.119: RH133.1 61.63,104.02 61.29,103.67 60.14,103.67 v4(59.72,104.09) 59.68,104.13 59.66,104.13 59.45,104.35 59.45,104.38 RH119.1
GPP_F0: length 9
  IN3 w0.06: v10(63.1,119.87) 62.9,119.67 62.21,119.67 62.06,119.83 61.63,119.83 61.38,120.08 60.88,120.08 59.99,120.97 59.77,120.97 59.55,120.97 58.76,121.76 56.03,121.76 55.71,121.44 v7(55.19,121.44)
GPP_F1: length 5.9
  IN3 w0.06: v7(58.62,121.54) 58.62,121.51 58.96,121.18 59.28,120.85 59.72,120.85 59.72,120.85 59.94,120.85 60.83,119.96 61.33,119.96 61.58,119.71 61.78,119.71 62.01,119.71 62.16,119.55 62.95,119.55 62.95,119.55 63.27,119.55 v10(63.59,119.88)
GPP_F2: length 9.3
  IN3 w0.06: 56.01,121.55 57.6,121.55 58,121.15 58.82,121.15 59.24,120.73 59.89,120.73 60.78,119.84 61.28,119.84 61.53,119.59 61.96,119.59 62.11,119.43 62.9,119.43 v10(63.1,119.23)
  IN3 w0.084: 56.01,121.55 55.17,120.72 v7(55.09,120.72)
GPP_F3: length 5.9
  IN4 w0.06: v4(56.67,118.6) 57.06,118.99 57.42,118.99 57.67,119.24 58.63,119.24 59.15,119.76 60.31,119.76 60.4,119.67 61.42,119.67 v5(61.62,119.87)
  BOTTOM w0.119: v4(56.67,118.6) 56.44,118.37 TC44.1
GPP_F23: length 15.6
  TOP w0.119: v1(66.7,122.15) 66.7,122.6 65.37,123.93 TC1.1
  IN1 w0.084: v1(66.7,122.15) 67.2,121.65 67.2,120.48 66.92,120.2 66.92,118.88 66.39,118.34 65.93,118.34 65.9,118.32 65.88,118.32 65.71,118.14 65.71,117.64 65.93,117.42 65.93,116.32 65.67,116.05 64.83,116.05 v2(64.41,116.47)
  IN3 w0.06: v2(64.41,116.47) 64.31,116.57 v3(64.08,116.57)
  IN4 w0.06: v3(64.08,116.57) 64.24,116.73 64.24,117.23 64.27,117.26 64.27,117.42 64.02,117.68 63.58,117.68 63.42,117.83 63.27,117.83 63.18,117.74 63.01,117.74 62.94,117.82 62.75,117.82 62.55,117.62 v5(62.36,117.62)
H2_COMP_GT: length 3.6
  BOTTOM w0.254: PR1149.1 116.85,123.24 PC1143.1 116.73,122.39 116.05,121.72 115.78,121.72 115.25,121.19 115.25,121.12 114.83,120.7 PU1101.H2
H4_ISENP_SA: length 6.6
  BOTTOM w0.254: PR1116.1 120.09,120.85 PR1154.2 118.55,120.85 PC1112.1 117.07,121.15 PC1113.1 PR1119.1 115.58,120.58 115.58,120.4 114.88,119.7 PU1101.H4
H5_ISENN_SA: length 3.2
  BOTTOM w0.254: PR1124.1 PR1120.1 116.11,117.59 115.57,118.14 115.57,118.68 115.05,119.2 PU1101.H5
H6_IMON_SA: length 3.8
  TOP w0.254: PC1117.1 PR1123.1
  IN3 w0.254: v2(116.58,116.6) 116.37,116.6 115.49,117.47 115.49,117.58 114.83,118.24 v7(114.83,118.7)
  vias: v9(116.87,116.86) v9(117.1,116.7)
H7_COMP_IA: length 4.5
  BOTTOM w0.254: PU1101.H7 114.93,118.2 115.53,117.59 115.53,117.29 115.74,117.08 116.61,117.08 116.94,116.75 PC1145.1 117.98,116.75 PR1150.1
H_CATERR: length 7.1
  IN3 w0.06: v7(78.38,106.21) 77.16,106.21 75.89,107.48 75.89,108.22 75.49,108.62 75.49,109.02 75.07,109.44 v10(75.07,111.18)
H_CPUPWRGD_R: length 4.7
  BOTTOM w0.119: RH107.2 82.13,107.23 81.28,108.07 81.28,108.51 80.65,109.15 79.06,109.15 UC1.A62
H_PECI: length 221.8
  IN3 w0.084: v3(105.8,98.43) 103.25,98.43 v3(102.99,98.68)
  IN4 w0.06: v5(75.07,110.69) 75.07,110.69 75.17,110.6 75.17,110.39 75.38,110.18 75.46,110.18 75.52,110.11 75.58,110.05 75.58,110.05 75.6,110.04 75.6,109.87 75.52,109.79 75.52,109.51 75.97,109.06 75.97,109 76.84,108.13 76.84,107.74 76.98,107.59 76.98,105.94 77.58,105.34 77.58,104.77 77.62,104.73 77.62,103.42 77.47,103.27 77.47,103.04
  IN4 w0.089: v3(105.8,98.43) 105.8,98.26 106.21,97.86 106.21,97.59 107.37,96.43 115.8,96.43 117.2,97.83 120.48,97.83 121.06,97.24 132.12,97.24 132.58,96.78 132.93,96.78 133.58,96.13 134.54,96.13 135.09,96.67 141.2,96.67 v4(143.13,98.6) ; 77.47,103.04 77.47,102.93 76.89,102.35 76.89,101.92 77.1,101.71 77.1,99.87 76.78,99.56 76.78,98.08 78.38,96.48 80.24,96.48 80.58,96.83 85.55,96.83 86.05,97.34 93.87,97.34 95.52,98.99 102.69,98.99 v3(102.99,98.68) ; v4(186.26,98.01) 197.47,98.01 199.25,99.79 199.25,100.45 198.41,101.29 198.41,104.78 199.05,105.42 199.68,105.42 201.05,106.78 201.73,106.78 202.75,107.8 203.8,107.8 204.43,108.44 204.43,116.61 207.57,119.75 207.57,126.15 209.45,128.03 209.45,142.89 208.31,144.03 200.84,144.03 199.5,142.69 191.9,142.69 191.26,142.05 186.77,142.05 v4(185.78,141.06) ; v4(183.34,98.14) 183.24,98.23 178.53,98.23 176.09,95.79 173.52,95.79 173.04,96.26 166.66,96.26 165.44,95.04 151.11,95.04 v4(147.65,98.5)
  BOTTOM w0.119: v4(147.65,98.5) 147.55,98.6 v4(143.13,98.6) ; v4(183.34,98.14) 183.44,98.03 186.23,98.03 v4(186.26,98.01) ; R327.2 185.93,140.91 v4(185.78,141.06)
H_PROCHOT#: length 196.1
  TOP w0.119: PR1121.1 117.04,117.95 v1(116.28,117.19) ; R68.2 190.38,128.08 PQ202.1 190.37,127.78 v1(191.13,127.02) 191.95,127.02 193.01,125.95 193.01,120.77 192.63,120.39 186.2,120.39 185.01,119.2 PQ1501.6
  IN1 w0.109: v1(191.13,127.02) 191.54,127.02 v2(191.79,126.76) ; v1(116.28,117.19) 116.57,117.19 116.83,116.93 118.88,116.93 120.76,118.82 v2(120.76,119.04)
  IN3 w0.084: v3(120.3,114.09) 119.95,114.44 119.95,115.85 120.47,116.37 120.47,117.69 120.76,117.99 v2(120.76,119.04) ; v3(120.41,113.31) 120.96,113.87 120.96,114.25 121.27,114.55 122.52,114.55 123.84,115.86 123.84,119 126.77,121.94 v7(129.18,121.94) ; v3(132.79,119.57) 132.79,116.6 133.68,115.71 133.68,115.13 133.96,114.85 133.96,108.42 135.99,106.39 v7(141.82,106.39) 141.84,106.41 145.53,106.41 146.04,106.92 147.71,106.92 148.09,106.55 148.36,106.55 148.62,106.28 149.86,106.28 150.27,106.7 160.85,106.7 169.27,115.12 169.27,118.9 171.4,121.03 171.4,121.03 171.99,121.62 171.99,123.51 172.82,124.34 177.67,124.34 178.3,124.98 179.19,124.98 180.39,126.17 184.43,126.17 186.12,124.49 190.47,124.49 191.79,125.8 v2(191.79,126.76)
  IN4 w0.089: v3(120.3,114.09) 120.41,113.98 v3(120.41,113.31) 119.57,113.31 117.75,111.5 117.75,109.81 116.05,108.11 116.04,108.11 115.23,107.3 115.23,106.06 113.98,104.81 111.85,104.81 111.65,105.01 111.41,105.01 110.03,103.63 101.98,103.63 99.94,101.6 96.67,101.6 96.58,101.69 95.85,101.69 94.87,102.66 93.42,102.66 92.47,103.6 92.22,103.6 91.97,103.85 91.97,105.84 89.94,107.88 88.5,107.88 88.1,107.47 88.1,106.21 88.05,106.16 88.05,104.24 87.5,103.7 87.5,103.26 87.83,102.93 v4(87.91,102.93) ; v3(132.79,119.57) 132.79,120.06 132.28,120.56 131.39,120.56 130.02,121.94 v7(129.18,121.94)
  BOTTOM w0.119: RC118.2 RC117.1 81.33,102.48 81.89,103.04 87.21,103.04 87.32,102.93 v4(87.91,102.93) ; PR521.1 141.96,108.34 141.41,107.79 141.41,106.8 v7(141.82,106.39)
H_PROCHOT#_R: length 16.3
  IN4 w0.06: 78.98,103.04 78.98,103.47 79.2,103.68 79.2,103.86 78.75,104.32 78.75,106.38 78.45,106.68 78.45,107.37 78.01,107.81 78.01,108.84 77.77,109.08 77.18,109.08 77.18,109.08 76.84,109.08 76.48,109.44 76.48,109.64 76.36,109.75 76.36,109.91 76.12,110.15 76.05,110.15 75.74,110.45 75.67,110.45 75.48,110.64 75.41,110.64 75.16,110.89 75.04,110.89 74.95,110.98 74.95,111.02 74.75,111.22 v5(74.75,111.43)
  IN4 w0.089: v4(79.55,100.32) 78.95,100.92 78.95,102.8 78.98,102.84 78.98,103.04
  BOTTOM w0.119: RC117.2 80.97,101.08 80.22,100.33 79.56,100.33 v4(79.55,100.32)
H_SYS_PWROK: length 35
  IN1 w0.084: v2(51.11,114.94) 51.44,115.27 51.44,115.95 51.89,116.4 51.89,116.53 52.65,117.29 54.47,117.29 55.77,116 55.77,115.38 55.22,114.83 55.22,114.39 55.66,113.94 55.66,113.22 55.81,113.07 55.81,112.17 58.21,109.77 58.21,109.05 v2(58.24,109.02)
  IN2 w0.079: v2(47.09,116.7) 47.09,116.23 47.28,116.04 47.54,115.79 48.52,115.79 49.37,114.94 v2(51.11,114.94)
  IN3 w0.06: v2(58.24,109.02) 57.89,108.66 v7(57.89,108.3)
  IN3 w0.084: v3(46.62,116.56) 46.96,116.56 v2(47.09,116.7)
  IN4 w0.089: v3(46.62,116.56) 45.68,116.56 45.04,115.92 45.04,115.91 43.93,114.79 43.93,110.81 43.41,110.29 v4(42.63,110.29)
  BOTTOM w0.119: UC1.J1 60.28,111.5 59.15,110.37 59.15,110.12 58.7,109.67 58.7,109.11 v7(57.89,108.3)
H_THERMTRIP#: length 7.7
  IN3 w0.06: v7(74.43,111.18) 74.43,110.98 74.63,110.78 74.63,109.5 74.92,109.21 74.92,109.21 75.25,108.87 75.25,108.52 75.63,108.14 75.63,107.4 77.61,105.43 v7(78.26,105.43)
H_VCCST_PWRGD: length 8.5
  IN3 w0.06: v10(78.4,109.86) 78.6,109.86 78.9,109.56 v6(78.9,109.54)
  IN4 w0.06: v6(78.9,109.54) 78.93,109.54 78.97,109.5 78.97,108.85 79.04,108.78 v4(79.07,108.78)
  BOTTOM w0.119: RC72.2 84.1,106.26 T29.1 83.5,106.86 82.16,106.86 81.1,107.92 81.1,108.44 80.57,108.97 79.17,108.97 79.07,108.87 v4(79.07,108.78)
HDA_BIT_CLK: length 14.4
  IN1 w0.109: v1(55.82,130.55) 55.82,130.67 56.03,130.88 v2(56.03,131.08)
  IN3 w0.084: v3(56.82,131.18) 56.51,131.18 56.41,131.08 v2(56.03,131.08)
  IN4 w0.06: 57.6,130.38 58.04,129.95 58.04,128.69 59.97,126.75 62.67,126.75 62.74,126.69 64.46,124.97 64.46,124.31 65.09,123.68 v5(65.09,123.5)
  IN4 w0.066: v3(56.82,131.18) 57.24,131.18 57.6,130.82 57.6,130.38
HDA_BIT_CLK_L: length 71.9
  TOP w0.119: RH5.1 55.21,130.52 v1(54.64,130.52)
  IN1 w0.109: v1(54.64,130.52) 54.85,130.52 55.39,131.05 v2(55.47,131.05)
  IN3 w0.084: v2(55.47,131.05) 55.47,131.38 55.98,131.89 55.98,131.92 56.26,132.19 56.28,132.19 57.81,133.72 57.81,135.63 57.27,136.18 57.27,139.44 58.57,140.75 58.57,145.98 56.09,148.46 41.82,148.46 28.18,134.81 27.3,134.81 24.69,132.2 24.69,131.02 23.7,130.03 23.7,129.43 21.31,127.04 18.13,127.04 17.39,127.78 v7(17.12,127.78)
  BOTTOM w0.119: v7(17.12,127.78) 16.88,128.02 UA3.13
HDA_RST#: length 15.3
  TOP w0.119: RH4.2 55.83,131.13 v1(55.83,131.54)
  IN1 w0.109: v2(56.45,131.73) 56.37,131.65 55.95,131.65 v1(55.83,131.54)
  IN3 w0.084: v3(56.81,132.01) 56.81,132.01 56.54,131.73 v2(56.45,131.73)
  IN4 w0.06: v5(65.41,123.75) 64.72,124.44 64.72,125.05 62.84,126.93 62.77,126.99 60.07,126.99 58.52,128.54 58.52,128.87
  IN4 w0.089: v3(56.81,132.01) 56.95,131.87 57.43,131.87 58.04,131.26 58.04,130.6 58.52,130.11 58.52,128.87
HDA_RST#_L: length 72.5
  TOP w0.119: RH4.1 CH1.1 54.61,131.13 v1(54.2,131.54)
  IN1 w0.109: v1(54.2,131.54) 54.28,131.61 v2(54.53,131.61)
  IN3 w0.084: v2(54.53,131.61) 55.02,131.61 56.04,132.63 56.05,132.63 56.25,132.84 56.25,132.85 57.35,133.94 57.35,135.44 56.8,135.99 56.8,139.64 58.1,140.94 58.1,145.79 55.9,147.99 42.01,147.99 28.21,134.19 27.34,134.19 25.25,132.1 25.25,130.92 24.16,129.84 24.16,129.24 21.13,126.2 17.78,126.2 v7(17.22,126.76)
  BOTTOM w0.119: UA3.15 15.38,126.35 15.49,126.23 16.69,126.23 v7(17.22,126.76)
HDA_SDI0: length 73.8
  IN3 w0.084: v3(56.82,130.8) 56.61,130.59 54.49,130.59 53.38,131.69 52.78,131.69 50.22,134.25 50.22,134.53 49.91,134.84 49.91,143.26 46.88,146.29 46.42,146.29 45.91,146.8 42.65,146.8 28.45,132.6 28.13,132.6 27.42,131.89 27.42,131.09 25.56,129.23 24.74,129.23 21.12,125.61 v7(16.57,125.61)
  IN4 w0.06: v5(64.12,123.75) 64.04,123.83 64.04,123.91 63.98,123.97 63.98,124.31 63.49,124.8 63.35,124.8 61.87,126.28 59.77,126.28 58.94,127.11 58.64,127.11 58.36,127.39 58.36,127.86 57.68,128.54 57.68,128.74 56.82,129.6 v3(56.82,130.8)
  BOTTOM w0.119: v7(16.57,125.61) RA55.1
HDA_SDIN0_AUDIO: length 2.5
  BOTTOM w0.119: RA55.2 15.99,125.5 15.52,125.97 15.27,125.97 14.98,126.26 UA3.16
HDA_SDOUT: length 16
  TOP w0.119: RH11.2 54.48,129.35 54.75,129.62 RH8.2 55.04,129.94 55.14,129.83 v1(55.14,129.63)
  IN1 w0.109: v2(56.36,130.24) 56.36,129.95 56.34,129.93 56.34,129.74 56.08,129.47 55.3,129.47 v1(55.14,129.63)
  IN3 w0.084: v2(56.36,130.24) 57.07,130.24 v3(57.23,130.09)
  IN4 w0.06: v3(57.23,130.09) 57.22,130.09 57.34,129.97 57.34,129.6 57.8,129.14 57.8,128.59 58.48,127.9 58.48,127.44 58.69,127.23 58.99,127.23 59.82,126.4 61.92,126.4 63.4,124.92 63.54,124.92 64.1,124.36 64.1,124.07 64.44,123.72 v5(64.44,123.5)
HDA_SDOUT_L: length 62.7
  TOP w0.119: v1(53.43,129.94) RH8.1
  IN1 w0.109: v1(53.43,129.94) 53.64,130.15 53.64,130.67 v2(53.75,130.78)
  IN3 w0.084: v7(15.44,125.45) 15.55,125.34 21.15,125.34 24.83,129.01 25.64,129.01 27.63,131 27.63,131.8 28.22,132.39 28.6,132.39 42.8,146.59 45.83,146.59 46.34,146.08 46.79,146.08 49.7,143.17 49.7,134.75 50.01,134.44 50.01,134.16 52.69,131.48 53.23,131.48 53.75,130.96 v2(53.75,130.78)
  BOTTOM w0.119: v7(15.44,125.45) 15.38,125.45 14.58,126.25 UA3.17
HDA_SYNC: length 19.1
  IN1 w0.109: v1(53.4,131.1) 53.51,131.21 54.37,131.21 v2(54.5,131.08)
  IN3 w0.084: v3(54.46,132.17) 54.13,131.84 54.13,131.45 v2(54.5,131.08)
  IN4 w0.06: 58.3,129.09 58.3,128.59 60.02,126.87 62.72,126.87 62.79,126.81 64.58,125.02 64.58,124.36 65.21,123.73 65.21,123.67 65.41,123.47 v5(65.41,123.26)
  IN4 w0.089: v3(54.46,132.17) 54.56,132.27 55.6,132.27 56.27,131.59 56.57,131.59 56.62,131.65 57.32,131.65 57.81,131.16 57.81,130.42 58.3,129.93 58.3,129.09
HDA_SYNC_L: length 61.5
  TOP w0.119: v1(52.92,131.59) 52.82,131.49 RH3.1 52.84,131.08 CH3.1
  IN1 w0.109: v2(52.68,132.35) 52.92,132.11 v1(52.92,131.59)
  IN3 w0.084: v7(15.95,126.69) 16.64,125.99 21.21,125.99 24.66,129.44 25.48,129.44 27.21,131.17 27.21,131.98 28.05,132.81 28.24,132.81 42.45,147.01 46,147.01 46.51,146.5 46.96,146.5 50.12,143.34 50.12,134.93 50.44,134.61 50.44,134.34 52.43,132.35 v2(52.68,132.35)
  BOTTOM w0.119: UA3.14 16.72,127.62 16.89,127.45 16.89,127.04 16.57,126.72 15.99,126.72 v7(15.95,126.69)
HDMI_CLK: length 36.4
  TOP w0.119: JHDMI1.17 11.29,53.15 11.29,53.15 v14(15.77,53.15) 16.44,53.15 16.59,53.29 16.59,54.09 16.7,54.21 16.94,54.21 17.04,54.1 17.04,53.33 v1(17.22,53.15) ; v1(26.64,71.77) 26.69,71.82 U25.32
  IN1 w0.109: v1(17.22,53.15) 17.22,53.09 16.93,52.8 16.7,52.8 16.61,52.89 16.61,54.54 17.19,55.13 v2(17.19,55.67) 18.19,56.67 18.19,66.2 22.53,70.54 24.46,70.54 25.17,71.25 25.17,71.25 25.53,71.61 26.48,71.61 v1(26.64,71.77)
  IN3 w0.084: v7(17.63,55.95) 17.47,55.95 v2(17.19,55.67)
  BOTTOM w0.119: v7(17.63,55.95) 17.71,55.95 17.96,56.2 RX1.1
HDMI_CTRLCLK: length 59.9
  TOP w0.119: v1(29.36,71.54) 29.09,71.81 U25.38
  IN1 w0.109: v1(29.36,71.54) 29.55,71.35 29.96,71.35 32.07,73.46 32.07,74.82 31.78,75.11 31.78,78.51 32.07,78.8 32.07,81.49 31.78,81.77 31.78,83.21 30.99,84 30.99,85.5 31.18,85.69 31.18,87.38 30.95,87.61 30.95,87.93 30.95,88.64 31.46,89.16 31.47,89.16 32.12,89.81 34.06,89.81 39.15,94.9 40.04,94.9 v2(40.32,94.62)
  IN3 w0.084: v2(40.32,94.62) v3(40.32,94.2)
  IN4 w0.089: v3(40.32,94.2) 40.33,94.21 42.22,94.21 42.69,94.67 43.28,94.67 44.29,95.67 47.13,95.67 47.93,96.48 49.34,96.48 50.74,95.08 51.25,95.08 51.68,94.65 58.79,94.65 60.83,96.69 62.07,96.69 62.24,96.85 62.24,98.23 61.87,98.59 61.84,98.59 v4(61.68,98.75)
HDMI_CTRLCLK_R: length 4.4
  BOTTOM w0.119: U47.26 60.45,98.62 60.55,98.52 60.87,98.52 R450.1 61.33,98.51 61.33,98.5 61.43,98.41 61.94,98.41 62.13,98.59 R453.1 63.04,99.16 R447.1
HDMI_CTRLDAT: length 60
  TOP w0.119: U25.39 29.49,71.82 29.67,71.64 v1(29.79,71.64)
  IN1 w0.109: v1(29.79,71.64) 31.65,73.5 31.65,74.36 31.23,74.78 31.23,78.26 31.85,78.88 31.85,81.26 31.17,81.94 31.17,83.38 30.78,83.77 30.78,85.61 30.97,85.8 30.97,87.29 30.74,87.53 30.74,88.02 30.74,88.73 31.38,89.37 31.38,89.37 32.03,90.02 33.97,90.02 39.08,95.12 40.12,95.12 40.26,94.99 40.58,94.99 v2(40.64,95.05)
  IN3 w0.084: v2(40.64,95.05) 40.74,95.15 40.82,95.15 41.06,94.91 41.06,94.76 40.93,94.63 v3(40.77,94.63)
  IN4 w0.089: v3(40.77,94.63) 40.77,94.5 40.84,94.43 42.18,94.43 42.61,94.86 43.17,94.86 44.2,95.89 47.07,95.89 47.85,96.67 49.42,96.67 50.82,95.27 51.36,95.27 51.79,94.84 58.72,94.84 60.75,96.88 61.95,96.88 62.02,96.94 62.02,98.14 61.8,98.36 61.46,98.36 61.42,98.33 61.42,98.25 v4(61.68,97.98)
HDMI_CTRLDAT_R: length 3.8
  BOTTOM w0.119: U47.27 60.46,98.22 60.53,98.29 60.79,98.29 R454.1 61.33,97.75 61.33,97.74 61.43,97.64 62.1,97.64 R455.1 62.31,96.84 R459.1
HDMI_DAT: length 36.5
  TOP w0.119: v1(27.09,71.81) U25.33
  IN1 w0.109: v2(16.61,55.18) 16.61,55.7 17.97,57.06 17.97,66.28 22.44,70.75 24.37,70.75 24.72,71.09 24.72,71.53 25.53,72.34 26.56,72.34 v1(27.09,71.81)
  IN3 w0.084: v2(16.61,55.18) v7(17.04,55.18)
  BOTTOM w0.119: RX2.1 18.16,55.18 v7(17.04,55.18) 14,55.18 v14(12.9,54.09) 12.24,53.43 8.31,53.43 8.22,53.35 JHDMI1.18
HDMI_EQ: length 5.5
  TOP w0.119: R206.2 26.49,80.69 27.3,80.69 R207.2 28.25,79.74 28.25,78.56 28.14,78.45 28.07,78.45 27.84,78.23 27.64,78.23 27.49,78.08 U25.17
HDMI_HPD: length 42.9
  TOP w0.119: v1(31.24,73.98) 31.17,74.05 U25.3
  IN1 w0.084: v2(41.88,95.43) 41.87,95.44 39.11,95.44 33.89,90.22 31.95,90.22 30.53,88.8 30.53,87.41 30.77,87.17 30.77,85.89 30.58,85.7 30.58,82.15 31.5,81.23 31.5,78.81 30.59,77.9 30.59,74.63 v1(31.24,73.98)
  IN3 w0.084: v3(42.4,95.05) 42.36,95.05 41.99,95.43 v2(41.88,95.43)
  IN4 w0.089: v4(52.26,97.1) 50.03,97.1 49.8,96.86 47.24,96.86 46.57,96.19 44.02,96.19 43.07,95.24 42.59,95.24 v3(42.4,95.05)
  BOTTOM w0.119: v4(52.26,97.1) U47.48
HDMI_HPLUG: length 40
  TOP w0.119: v1(24.43,74.01) 24.48,74.05 U25.28 ; v1(8.25,49.95) 9.75,49.95 JHDMI1.1 ; R212.2 25.12,71.77 24.84,72.05 v1(24.49,72.05)
  TOP w0.127: v1(24.43,71.21) R212.2
  IN1 w0.084: v1(24.43,74.01) 24.02,73.59 24.02,72.49 24.46,72.05 v1(24.49,72.05) ; v1(8.25,49.95) 9.45,49.95 10.08,50.59 14.81,50.59 15.93,51.7 15.93,55.38 17.75,57.21 17.75,66.35 22.62,71.21 v1(24.43,71.21)
HDMI_ID: length 5.3
  TOP w0.119: U25.23 24.55,76.05 v1(24.51,76.01)
  IN1 w0.084: v1(26.01,79.26) 25.96,79.26 24.1,77.41 24.1,76.42 v1(24.51,76.01)
HDMI_ISET: length 2.2
  TOP w0.119: R213.2 R214.2 27.56,71.5 27.49,71.57 U25.34
HDMI_LANE_N0: length 46.3
  IN1 w0.109: v1(33.21,72.61) 33.32,72.5 33.5,72.5 v2(33.61,72.61)
  IN2 w0.079: v2(33.61,72.61) 33.76,72.46 34.16,72.46 34.42,72.2 34.42,71.7 33.92,71.2 33.07,71.2 32.59,71.69 32.59,72.85 30.19,75.25 30.19,84.47 39.79,94.07 40.42,94.07 41.3,94.94 41.98,94.94 43.05,96.01 51.25,96.01 51.8,95.46 51.8,95.32 51.8,95.26 v2(51.92,95.14)
  IN3 w0.084: v2(51.92,95.14) 51.79,95.27 51.79,95.44 v7(51.87,95.52)
  BOTTOM w0.119: U47.49 51.86,95.53 v7(51.87,95.52)
HDMI_LANE_N0_C: length 2.6
  TOP w0.119: CX11.2 32.46,72.44 32.31,72.44 32.25,72.51 32.25,72.66 31.33,73.58 31.1,73.58 31.03,73.65 U25.2
HDMI_LANE_N1: length 42.1
  IN1 w0.109: v1(33.21,73.75) 33.21,73.61 33.3,73.51 33.46,73.51 33.65,73.71 v2(33.65,73.75)
  IN2 w0.079: v2(52.74,94.71) 52.6,94.57 52.6,94.4 52.28,94.08 50.12,94.08 48.95,95.24 43.69,95.24 42.35,93.91 41.47,93.91 40.87,93.31 40.1,93.31 30.97,84.18 30.97,75.7 33.11,73.56 33.49,73.56 33.65,73.73 v2(33.65,73.75)
  IN3 w0.084: v2(52.74,94.71) 52.56,94.89 52.56,95 52.68,95.11 52.78,95.11 v7(53.06,95.39)
  BOTTOM w0.119: v7(53.06,95.39) U47.46
HDMI_LANE_N1_C: length 2.7
  TOP w0.119: CX9.2 32.51,73.63 32.26,73.63 31.78,74.11 31.78,74.37 31.37,74.78 31.1,74.78 31.03,74.85 U25.5
HDMI_LANE_N2: length 41
  IN1 w0.109: v1(33.21,74.89) 33.21,74.81 33.33,74.69 33.47,74.69 v2(33.68,74.89)
  IN2 w0.079: v2(33.68,74.89) 33.48,74.69 33.15,74.69 31.58,76.25 31.58,83.99 40.29,92.69 41.09,92.69 41.75,93.34 42.6,93.34 43.92,94.66 48.54,94.66 49.69,93.51 53,93.51 53.54,94.05 53.54,94.49 v2(53.81,94.76)
  IN3 w0.084: v7(53.86,95.57) 53.68,95.39 53.68,95.24 53.68,95.1 53.59,95.02 53.59,94.93 53.62,94.9 53.62,94.86 53.72,94.76 v2(53.81,94.76)
  BOTTOM w0.119: U47.44 v7(53.86,95.57)
HDMI_LANE_N2_C: length 2.4
  TOP w0.119: U25.7 31.04,75.65 31.1,75.58 31.55,75.58 32.34,74.79 32.52,74.79 CX7.2
HDMI_LANE_N3: length 40.3
  IN1 w0.109: v1(33.21,76.01) 33.21,75.9 33.36,75.75 33.47,75.75 33.68,75.96 v2(33.68,76.01)
  IN2 w0.079: v2(33.68,76.01) 33.68,75.99 33.5,75.81 33.19,75.81 32.16,76.85 32.16,83.75 40.48,92.08 41.31,92.08 42.01,92.77 42.43,92.77 42.43,92.77 42.86,92.77 44.16,94.07 46.14,94.07 47.28,92.94 53.96,92.94 54.64,93.61 54.64,94.33 v2(54.84,94.53)
  IN3 w0.084: v7(55.12,95.54) 54.97,95.39 54.97,95.09 54.69,94.81 54.69,94.68 v2(54.84,94.53)
  BOTTOM w0.119: U47.41 55.06,95.6 v7(55.12,95.54)
HDMI_LANE_N3_C: length 2.5
  TOP w0.119: CX5.2 32.47,75.86 32.31,75.86 31.4,76.78 31.17,76.78 31.11,76.85 U25.10
HDMI_LANE_P0: length 46.3
  IN1 w0.109: v1(33.21,72.05) 33.21,72.2 33.28,72.26 33.45,72.26 33.47,72.25 33.65,72.25 33.73,72.17 33.73,71.9 v2(33.63,71.8)
  IN2 w0.079: v2(51.38,95.12) 51.41,95.12 51.61,95.32 51.61,95.38 51.17,95.82 43.12,95.82 42.06,94.76 41.37,94.76 40.5,93.88 39.87,93.88 30.38,84.39 30.38,75.33 32.77,72.93 32.77,71.76 33.15,71.38 33.84,71.38 34.24,71.78 34.24,72.13 34.09,72.28 33.77,72.28 33.76,72.26 33.61,72.26 33.46,72.11 33.46,71.97 v2(33.63,71.8)
  IN3 w0.084: v7(51.47,95.52) 51.53,95.52 51.61,95.44 51.61,95.32 51.41,95.12 v2(51.38,95.12)
  BOTTOM w0.119: v7(51.47,95.52) 51.6,95.65 51.6,95.76 51.46,95.9 U47.50
HDMI_LANE_P0_C: length 2.6
  TOP w0.119: U25.1 30.99,73.25 31.06,73.32 31.22,73.32 31.98,72.55 31.98,72.4 32.2,72.18 32.49,72.18 CX12.2
HDMI_LANE_P1: length 42.1
  IN1 w0.109: v1(33.21,73.19) 33.3,73.28 33.57,73.28 v2(33.65,73.19)
  IN2 w0.079: v2(33.65,73.19) 33.65,73.22 33.5,73.37 33.03,73.37 30.78,75.62 30.78,84.25 40.03,93.49 40.79,93.49 41.39,94.1 42.27,94.1 43.61,95.43 49.03,95.43 50.2,94.26 52.2,94.26 52.42,94.48 52.42,94.58 52.31,94.69 v2(52.21,94.69)
  IN3 w0.084: v2(52.21,94.69) 52.4,94.88 52.4,95.09 52.66,95.35 v7(52.66,95.39)
  BOTTOM w0.119: v7(52.66,95.39) U47.47
HDMI_LANE_P1_C: length 2.7
  TOP w0.119: U25.4 31.05,74.45 31.12,74.52 31.26,74.52 31.52,74.26 31.52,74.01 32.16,73.37 32.45,73.37 CX10.2
HDMI_LANE_P2: length 41
  IN1 w0.109: v2(33.68,74.34) 33.56,74.46 33.33,74.46 v1(33.21,74.34)
  IN2 w0.079: v2(53.27,94.76) 53.36,94.67 53.36,94.12 52.92,93.69 49.77,93.69 48.62,94.84 43.84,94.84 42.53,93.53 41.67,93.53 41.02,92.87 40.21,92.87 31.4,84.06 31.4,76.18 33.07,74.51 33.54,74.51 33.68,74.36 v2(33.68,74.34)
  IN3 w0.084: v7(53.46,95.57) 53.52,95.51 53.52,95.17 53.43,95.09 53.43,94.95 53.43,94.95 53.43,94.88 53.3,94.76 v2(53.27,94.76)
  BOTTOM w0.119: U47.45 v7(53.46,95.57)
HDMI_LANE_P2_C: length 2.4
  TOP w0.119: U25.6 31.08,75.25 31.15,75.32 31.44,75.32 32.23,74.52 32.44,74.52 CX8.2
HDMI_LANE_P3: length 40.3
  IN1 w0.109: v1(33.21,75.45) 33.28,75.52 33.61,75.52 v2(33.68,75.45)
  IN2 w0.079: v2(33.68,75.45) 33.51,75.62 33.12,75.62 31.97,76.77 31.97,83.83 40.4,92.26 41.24,92.26 41.93,92.96 42.36,92.96 42.78,92.96 44.08,94.26 46.22,94.26 47.36,93.12 53.88,93.12 54.45,93.69 54.45,94.41 v2(54.3,94.55)
  IN3 w0.084: v2(54.3,94.55) 54.52,94.77 54.52,94.88 54.81,95.16 54.81,95.4 v7(54.66,95.54)
  BOTTOM w0.119: U47.42 v7(54.66,95.54)
HDMI_LANE_P3_C: length 2.5
  TOP w0.119: U25.9 31.12,76.45 31.19,76.52 31.29,76.52 32.21,75.6 32.48,75.6 CX6.2
HDMI_PRE: length 6.3
  TOP w0.119: R204.2 26.52,81.7 27.28,81.7 R205.2 28.47,80.51 28.47,78.47 28.23,78.23 28.22,78.23 28.19,78.2 28.18,78.2 28.03,78.05 28.03,78.04 27.89,77.9 U25.16
HOME_KEY#: length 78.5
  IN3 w0.084: v3(214.43,140.4) 214.63,140.4 217,138.03 217,124.98 219.08,122.9 219.08,117.57 220.2,116.44 v7(221.53,116.44) ; v3(182.39,133.84) 182.63,134.09 186.43,134.09 v7(187.13,133.39)
  IN4 w0.089: v3(214.43,140.4) 214.4,140.38 213.36,140.38 208.78,144.96 200.31,144.96 199.44,144.08 198.66,144.08 198.2,143.63 192,143.63 191.52,143.14 190.53,143.14 190.3,143.37 186.11,143.37 185.04,142.3 185.04,140.22 184.46,139.65 184.46,139.12 184.33,138.99 184.33,137.77 183.78,137.21 183.78,136.92 182.39,135.53 v3(182.39,133.84) ; v4(189.32,134.24) 188.58,134.24 188.58,134.24 188.35,134.24 188.35,134.24 187.49,134.24 187.13,133.89 v7(187.13,133.39)
  BOTTOM w0.119: v7(221.53,116.44) 221.49,116.48 JIO1.19
HOST_DEBUG_TX: length 14.2
  IN3 w0.084: v7(196.13,146.6) 195.21,145.68 193.46,145.68 v7(191.36,143.58) 191.36,143.34 190.08,142.06 190.08,138.21 190.82,137.47 v10(190.82,136.74)
  BOTTOM w0.119: v7(191.36,143.58) R312.2
HOST_SD_WP#: length 206.3
  IN1 w0.084: v2(56.16,112.46) 56.16,112.15 58.85,109.46 58.85,108.18 59.88,107.16 60.54,107.16 61.31,106.38 61.37,106.33 61.37,105.67 60.84,105.14 60.84,103.48 62.1,102.22 62.43,102.22 62.78,101.87 63.39,101.87 64.26,100.99 64.26,100.39 65.16,99.49 67.56,99.49 68.35,100.28 72.12,100.28 72.56,99.84 76.83,99.84 77.03,100.04 77.88,100.04 78.59,100.75 79.83,100.75 81.12,102.04 83.26,102.04 84.82,103.59 87.12,103.59 87.2,103.51 88.47,103.51 88.81,103.85 93.72,103.85 94.86,102.71 95.81,102.71 96.17,102.34 96.17,102.04 96.3,101.91 99.32,101.91 100.17,101.06 104.19,101.06 106.25,99 113.24,99 114.71,100.48 118.45,100.48 119.15,101.18 120.88,101.18 121.95,100.12 135.57,100.12 136.32,99.37 138.33,99.37 139.82,97.89 158.22,97.89 159.54,99.2 168.94,99.2 169.24,98.9 169.24,98.63 169.43,98.44 169.75,98.44 169.77,98.46 170.53,98.46 171.41,99.34 178.55,99.34 181.25,102.04 189.99,102.04 190.51,101.52 192.67,101.52 193.3,102.16 196.48,102.16 197.28,101.36 202.78,101.36 203.21,101.79 211.32,101.79 v2(211.71,102.18)
  IN2 w0.079: v2(213.92,117.46) 213.92,114.95 214.86,114.01 214.86,103.98 213.58,102.7 212.23,102.7 v2(211.71,102.18)
  IN3 w0.06: v10(63.35,115.04) 63.18,115.04 62.91,114.78 62.75,114.78 62.68,114.7 61.61,114.7 61.61,114.7 61.53,114.7 61.52,114.72 61.51,114.72 60.74,114.72 59.62,113.6 59.12,113.6 58.99,113.48 58.22,113.48 57.94,113.2 ; 56.18,112.49 56.76,113.06 v7(56.76,113.2)
  IN3 w0.084: 56.18,112.49 v2(56.16,112.46) ; v7(56.76,113.2) 57.94,113.2 ; v7(217.91,116.45) 217.18,116.45 216.79,116.85 215.35,116.85 214.73,117.46 v2(213.92,117.46)
  BOTTOM w0.119: RH99.1 56.3,113.2 v7(56.76,113.2)
HP2_D_L: length 15.9
  IN3 w0.254: v7(8.33,128.82) 8.52,128.82 8.56,128.77
  IN3 w0.381: 8.56,128.77 9.28,128.77 9.7,129.19 9.7,131.71 9,132.41 9,139.13 9.85,139.98 9.85,141.75 v7(9.7,141.9)
  BOTTOM w0.203: v7(8.33,128.82) UA3.32
HP2_D_L_C: length 5.8
  IN3 w0.381: v7(11.9,143.32) 12.56,143.98 JHP1.1
  BOTTOM w0.381: L16.2 10.3,142.79 RA40.1 CA34.1 11.04,142.63 DA6.1 11.79,143.21 v7(11.9,143.32)
HP2_D_L_R: length 0.9
  BOTTOM w0.381: L16.1 8.82,141.93 RA42.2
HP2_D_R: length 14.1
  IN1 w0.381: v2(8.89,129.28) 8.01,129.28 6.64,130.65 6.64,135.27 7.25,135.88 7.25,139.35 v1(6.6,139.99)
  IN3 w0.305: v7(8.38,129.22) 8.83,129.22 v2(8.89,129.28)
  BOTTOM w0.203: v7(8.38,129.22) UA3.33
HP2_D_R_C: length 29.6
  TOP w0.381: L3.2 6.69,141.02 RA2.1 CA3.1 6.69,142.87 DA2.1
  IN1 w0.381: v2(11.38,143.2) 11.35,143.2 11.28,143.27 9.02,143.27 8.51,142.76 6.73,142.76 v1(6.55,142.94)
  IN2 w0.381: v2(11.38,143.2) 11.4,143.17 11.84,143.17 15.19,146.52 15.19,154.32 13.21,156.3 8,156.3 JHP1.2
