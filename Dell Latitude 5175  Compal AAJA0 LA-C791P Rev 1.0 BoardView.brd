# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Nets (continued)
DS4_VSYNC: C353.1 C354.1 JCAM3.8 R45.1 R69.1
DSW_ON: R169.2 R347.1 U22.3 U34.J2
DTDK2_ACOK: R499.2 R500.1 U34.B4
DTDK_ACOK: JIO4.41 PD506.2 PU151.1
DTDK_PLUG#: RA53.2 RA54.2 UA3.8
DWL_REQ: JNFC1.6 R199.2 UC1.BC3
E1_IMON_GT: PC1144.1 PR1151.1 PU1101.E1
E2_FCCM_SA: PU1100.7 PU1101.E2
E3_PWM_SA: PU1100.3 PU1101.E3
E4_LG: PR1112.1 PU1101.E4
E8_IMON_IA: PC1138.1 PR1152.1 PU1101.E8
EC_ALWON: R2.1 U34.E1
EC_GPIO222: R359.1 U34.M7
EC_IN_VOLUMEDOWN#: C123.1 R124.1 R339.1 U34.E12
EC_IN_VOLUMEUP#: C31.1 R21.1 R336.1 U34.E11
EC_PROCHOT#: Q6.2 U34.K8
EC_SLP_S0IX#: R348.2 R349.2 U34.J12
EC_VR_ON: U34.G3 UH1.1
EDP_AUXN: C149.1 UC1.J42
EDP_AUXN_CONN: JEDP1.14 L12.3
EDP_AUXN_R: C149.2 L12.4
EDP_AUXP: C150.1 UC1.G42
EDP_AUXP_CONN: JEDP1.12 L12.2
EDP_AUXP_R: C150.2 L12.1
EDP_CAB_DET#: JEDP1.2 RH91.1 UC1.AB7
EDP_DISP: RC71.2 TC56.1(TP-1) UC1.A40
EDP_HPD: JEDP1.18 RC74.2 UC1.A7
EDP_TXN_P0: C152.1 UC1.H45
EDP_TXN_P0_CONN: JEDP1.8 L13.2
EDP_TXN_P0_R: C152.2 L13.1
EDP_TXN_P1: C153.1 UC1.J44
EDP_TXN_P1_CONN: JEDP1.4 L14.3
EDP_TXN_P1_R: C153.2 L14.4
EDP_TXP_P0: C151.1 UC1.F45
EDP_TXP_P0_CONN: JEDP1.10 L13.3
EDP_TXP_P0_R: C151.2 L13.4
EDP_TXP_P1: C154.1 UC1.G44
EDP_TXP_P1_CONN: JEDP1.6 L14.2
EDP_TXP_P1_R: C154.2 L14.1
EMMC_RCOMP: RC41.2 UC1.BC1
EN: PC409.1 PR406.2 PR407.1 PU400.15
EN_0.6V: PC714.1 PR705.2 PR707.1 PR709.2 PU700.16
EN_0.85VS_VCCIO: PC800.1 PR803.2 PR804.1 PU808.13
EN_0.95V_PRIM: PC913.1 PR910.2 PU901.13
EN_1.0V_PRIM: PC809.1 PR813.1 PU801.1
EN_1.2V: PC718.1 PR708.2 PR710.1 PU700.15
EN_CAM#: Q9.2 R85.2 UC1.BB16
EN_INVPWR: R38.2 R416.1 U34.J10 U41.2
ENBKL: D37.2 UC1.D4
ENLDO: PR610.2 PU601.12
ENVDD: D16.1 R168.1 U43.4
EXT_PWR_GATE#: R482.1 UC1.BC7
EXT_PWR_GATE#_R: R387.2 R482.2 U50.5
F1_ISENN_GT: PC1131.2 PR1145.2 PU1101.F1
F4_VR_ON: PR1107.2 PU1101.F4
F8_ISENN_IA: PR1146.1 PR1148.1 PU1101.F8
FB_1.8V: PC1002.2 PR1004.2 PR1005.1 PU1000.1
FP_POA_EN: JUSH1.5 U34.J11
FP_POA_WAKE#: JUSH1.4 R361.2 U34.H10
G1_ISENP_GT: PC1127.1 PC1128.1 PR1141.1 PR1143.1 PR1155.2 PU1101.G1
G2_FB_GT: PR1126.2 PR1129.2 PR1130.2 PU1101.G2
G3_COMP_SA: PC1114.1 PR1118.1 PU1101.G3
G4_FB_SA: PR1006.1 PR1100.1 PR1102.1 PU1101.G4
G6_CNFG: PC1116.1 PR409.1 PR1122.1 PU1101.G6
G8_ISENP_IA: PC1129.1 PC1130.1 PR1142.1 PR1144.1 PR1153.2 PU1101.G8
GNSS_IRQ: R20.2 RH38.1 UC1.AL8
GNSS_IRQ_L: JNGFF1.36 R20.1
GNSS_OFF#: Q4.3 RH88.1 UC1.AL12
GNSS_OFF#_R: JNGFF1.18 Q4.4 R31.2
GNSS_SCL: R14.2 RH85.1 UC1.AT9
GNSS_SCL_L: JNGFF1.32 R14.1
GNSS_SDA: R19.2 RH86.1 UC1.AM7
GNSS_SDA_L: JNGFF1.34 R19.1
GNSS_SYSCLK: JNGFF1.38 T1.1(TP-1)
GPP_B18: RC11.2 TC35.1(TP-1) UC1.BB4
GPP_B22: RC12.2 TC2.1(TP-1) UC1.AW8
GPP_D10: RH124.1 TC47.1(TP-1) UC1.T7
GPP_E1: RH119.1 RH133.1 UC1.J11
GPP_F0: TC42.1(TP-1) UC1.AT11
GPP_F1: TC41.1(TP-1) UC1.AT13
GPP_F2: TC43.1(TP-1) UC1.AP11
GPP_F3: TC44.1(TP-1) UC1.AT5
GPP_F23: TC1.1(TP-1) UC1.AJ8
H2_COMP_GT: PC1143.1 PR1149.1 PU1101.H2
H4_ISENP_SA: PC1112.1 PC1113.1 PR1116.1 PR1119.1 PR1154.2 PU1101.H4
H5_ISENN_SA: PR1120.1 PR1124.1 PU1101.H5
H6_IMON_SA: PC1117.1 PR1123.1 PU1101.H6
H7_COMP_IA: PC1145.1 PR1150.1 PU1101.H7
H_CATERR: TC65.1(TP-1) UC1.H49
H_CPUPWRGD_R: RH107.2 UC1.A62
H_PECI: R327.2 UC1.F49
H_PROCHOT#: PQ202.1 PQ1501.6 PR521.1 PR701.1 PR1114.2 PR1121.1 R68.2 RC117.1 RC118.2
H_PROCHOT#_R: RC117.2 UC1.J48
H_SYS_PWROK: UC1.J1 UH4.4
H_THERMTRIP#: R423.2 UC1.H47
H_VCCST_PWRGD: RC72.2 T29.1(TP-1) UC1.B61
HDA_BIT_CLK: RH5.2 UC1.BK18
HDA_BIT_CLK_L: CH2.1 RH5.1 UA3.13
HDA_RST#: RH4.2 UC1.BL19
HDA_RST#_L: CH1.1 RH4.1 UA3.15
HDA_SDI0: RA55.1 UC1.BL15
HDA_SDIN0_AUDIO: RA55.2 UA3.16
HDA_SDOUT: RH8.2 RH11.2 UC1.BK16
HDA_SDOUT_L: CH4.1 RH8.1 UA3.17
HDA_SYNC: RH3.2 UC1.BJ19
HDA_SYNC_L: CH3.1 RH3.1 UA3.14
HDMI_CLK: JHDMI1.17 RX1.1 U25.32
HDMI_CTRLCLK: R450.2 U25.38
HDMI_CTRLCLK_R: R447.1 R450.1 R453.1 U47.26
HDMI_CTRLDAT: R454.2 U25.39
HDMI_CTRLDAT_R: R454.1 R455.1 R459.1 U47.27
HDMI_DAT: JHDMI1.18 RX2.1 U25.33
HDMI_EQ: R206.2 R207.2 U25.17
HDMI_HPD: U25.3 U47.48
HDMI_HPLUG: JHDMI1.1 R212.2 U25.28
HDMI_ID: R208.2 U25.23
HDMI_ISET: R213.2 R214.2 U25.34
HDMI_LANE_N0: CX11.1 U47.49
HDMI_LANE_N0_C: CX11.2 U25.2
HDMI_LANE_N1: CX9.1 U47.46
HDMI_LANE_N1_C: CX9.2 U25.5
HDMI_LANE_N2: CX7.1 U47.44
HDMI_LANE_N2_C: CX7.2 U25.7
HDMI_LANE_N3: CX5.1 U47.41
HDMI_LANE_N3_C: CX5.2 U25.10
HDMI_LANE_P0: CX12.1 U47.50
HDMI_LANE_P0_C: CX12.2 U25.1
HDMI_LANE_P1: CX10.1 U47.47
HDMI_LANE_P1_C: CX10.2 U25.4
HDMI_LANE_P2: CX8.1 U47.45
HDMI_LANE_P2_C: CX8.2 U25.6
HDMI_LANE_P3: CX6.1 U47.42
HDMI_LANE_P3_C: CX6.2 U25.9
HDMI_PRE: R204.2 R205.2 U25.16
HOME_KEY#: JIO1.19 R345.1 U34.H12
HOST_DEBUG_TX: JDEG1.8 R312.2 U34.C9
HOST_SD_WP#: JIO1.20 RH99.1 UC1.AA12
HP2_D_L: RA42.1 UA3.32
HP2_D_L_C: CA34.1 DA6.1 JHP1.1 L16.2 RA40.1
HP2_D_L_R: L16.1 RA42.2
HP2_D_R: RA4.1 UA3.33
HP2_D_R_C: CA3.1 DA2.1 JHP1.2 L3.2 RA2.1
HP2_D_R_R: L3.1 RA4.2
HP_AMP_EN: R172.2 R173.2 RA23.2 RA26.2 U21.13
HP_IN_L_N: RA27.2 U21.1
HP_IN_L_P: RA25.1 U21.2
HP_IN_R_N: RA22.2 U21.4
HP_IN_R_P: RA24.1 U21.3
HP_OUT_L: RA29.1 U21.16
HP_OUT_R: RA20.1 U21.5
HP_PLUG#: RA45.1 RA46.1
HPVDD: C158.1 U21.12
HPVSS: C144.1 U21.8
HSYNC: JEDP1.16 JTS1.4
HW_RST#: D1.1 U1.5
I2C0_SCL: Q17.3 RH132.1 UC1.AB3
I2C0_SCL_AMP: RA32.2 UA3.12
I2C0_SCL_AMP_R: RA31.1 RA32.1 RA33.1 UA2.4
I2C0_SCL_AUD: Q17.4 UA1.7
I2C0_SCL_AUD_SW: RA33.2 RA65.1 UA1.6
I2C0_SCL_AUD_SW_R: QA2.4 RA65.2 UA1.4
I2C0_SDA: Q17.6 RH131.1 UC1.AD11
I2C0_SDA_AMP: RA35.2 UA3.11
I2C0_SDA_AMP_R: RA34.1 RA35.1 RA36.1 UA2.3
I2C0_SDA_AUD: Q17.1 UA1.9
I2C0_SDA_AUD_SW: RA34.2 RA64.1 UA1.10
I2C0_SDA_AUD_SW_R: QA2.1 RA64.2 UA1.2
I2C1_CLK_PD: R263.2 R489.2 U32.D2
I2C1_DAT_PD: R253.2 R488.2 U32.D1
I2C1_INT#_PD: R268.2 R490.2 U32.C1
I2C2_CLK_PD: R487.2 R492.2 U32.B5
I2C2_DAT_PD: R486.2 R491.2 U32.A5
I2C2_INT#_PD: R275.2 R493.2 U32.B6
I2S_DATA_OUT: RA10.2 UA2.10
I2S_DATA_OUT_R: RA10.1 UA3.5
I2S_LRCK: CA7.1 RA14.2 UA2.7
I2S_LRCK_R: RA14.1 UA3.1
I2S_OUT: CA5.1 RA12.2 UA2.8
I2S_OUT_R: RA12.1 UA3.3
I_ADP: C266.1 PR513.1 U34.M2
I_BATT: C264.1 PR517.1 U34.M4
ILEDA: R480.1 U6.B2
ILEDB: R481.1 U6.B3
ILMT_1.0V: PR819.2 PR821.1 PU801.3
INV_PWM: D12.1 MC2.1 PR403.1 R150.1
IRQ_SERIRQ: RH65.1 U34.L5 UC1.BN8
ISH_I2C0_SCL: JIO1.26 RH114.1 UC1.P5
ISH_I2C0_SDA: JIO1.28 RH120.1 UC1.P7
ISH_I2C1_SCL: RH101.1 UC1.T3
ISH_I2C1_SDA: RH102.1 UC1.T9
ISH_UART_CTS#: RC58.1 U4.10 UC1.V9
ISH_UART_CTS#_LS: JNGFF3.62 U4.3
ISH_UART_RTS#: RC59.1 U4.9 UC1.U6
ISH_UART_RTS#_LS: JNGFF3.64 U4.4
ISH_UART_RXD: RC60.1 U4.12 UC1.U10
ISH_UART_RXD_LS: JNGFF3.58 U4.1
ISH_UART_TXD: RC62.1 U4.11 UC1.U4
ISH_UART_TXD_LS: JNGFF3.60 U4.2
ITP_PMODE: RC75.1 UC1.A60
JACK_PLUG#: CA35.1 RA43.2 RA44.2 RA46.2 UA3.9
JTAG_CLK: JDEG1.4 R313.2 U34.D9
JTAG_RST#: C233.1 R324.1 R329.2 U34.B10
JTAG_TDI: JDEG1.2 R309.2 U34.D10
JTAG_TDO: JDEG1.5 R314.2 U34.C10
JTAG_TMS: JDEG1.3 R315.2 U34.A10
JUSBC1_GND: CT1.1 CT2.2 CT3.2 CT4.2 JUSBC1.G1 JUSBC1.G2 JUSBC1.G3 JUSBC1.G4 LT1.1
LAN_WAKE#: RH18.1 U34.C12
LAN_WAKE#_R: RH17.2 RH18.2 UC1.BE15
LCD_TST: D16.3 JEDP1.24 U34.B12
LDO2-CAP: CA59.1 CA66.1 RA58.2 UA3.22
LDO_3V: PC821.1 PU801.5
LDO_IN: PC121.1 PD102.1 PD103.1 PD104.1 PD105.1 PR132.1 PU101.1
LED_IFB1: JEDP1.32 PC413.1 PU400.7
LED_IFB2: JEDP1.33 PC414.1 PU400.8
LED_IFB3: JEDP1.34 PC415.1 PU400.9
LED_IFB4: JEDP1.35 PC416.1 PU400.12
LED_IFB5: JEDP1.36 PC417.1 PU400.13
LED_IFB6: JEDP1.37 PC418.1 PU400.14
LID_CL_SIO#: JIO1.17 R338.2 U34.J1
LINE1_L: CA51.2 RA27.1 RA28.1
LINE1_L_AMP: CA12.1 JIO4.35 RA28.2 RA29.2
LINE1_R: CA52.2 RA21.1 RA22.1
LINE1_R_AMP: CA11.1 JIO4.33 RA20.2 RA21.2
LINE_AMP_EN: RA15.1 RA16.2 RA26.1
LINE_L: CA51.1 UA3.35
LINE_PLUG#: JIO4.38 RA43.1
LINE_R: CA52.1 UA3.34
LP_0.95V: PR907.2 PR908.2 PR909.1 PU901.14
LPC_AD0: JLPDE1.3 U34.K6 UC1.BK11
LPC_AD1: JLPDE1.4 U34.L6 UC1.BJ8
LPC_AD2: JLPDE1.5 U34.M6 UC1.BG10
LPC_AD3: JLPDE1.6 U34.K7 UC1.BP5
LPC_FRAME#: JLPDE1.7 U34.K5 UC1.BP7
LPM_0.85VS_VCCIO: PR800.2 PR801.2 PR802.1 PU808.14
LSTX: R282.2 U32.L4
LX_0.85VS_VCCIO: PL802.1 PR805.1 PU808.2 PU808.3
LX_0.95V: PL904.1 PR912.1 PU901.2 PU901.3
LX_1.0V: PC811.2 PL804.1 PR815.1 PU801.10
LX_1.8V: PL1001.1 PR1003.1 PU1000.6
M_A_CA_0_0: U35.L2 UC1.AW59
M_A_CA_0_1: U35.L3 UC1.AW55
M_A_CA_0_2: U35.L4 UC1.BF62
M_A_CA_0_3: U35.K2 UC1.AV56
M_A_CA_0_4: U35.K3 UC1.AW57
M_A_CA_0_5: U35.G3 UC1.AV58
M_A_CA_0_6: U35.G4 UC1.BA56
M_A_CA_0_7: U35.F2 UC1.BD59
M_A_CA_0_8: U35.F3 UC1.BD61
M_A_CA_0_9: U35.F4 UC1.BG61
M_A_CA_1_0: U35.B5 UC1.BK59
M_A_CA_1_1: U35.C5 UC1.BL62
M_A_CA_1_2: U35.D5 UC1.BJ61
M_A_CA_1_3: U35.B6 UC1.AV60
M_A_CA_1_4: U35.C6 UC1.BN62
M_A_CA_1_5: U35.C9 UC1.BB61
M_A_CA_1_6: U35.D9 UC1.BL61
M_A_CA_1_7: U35.B10 UC1.BM59
M_A_CA_1_8: U35.C10 UC1.BN58
M_A_CA_1_9: U35.D10 UC1.AV62
M_A_CK_DDR0_DN: U35.C8 UC1.BC62
M_A_CK_DDR0_DP: U35.B8 UC1.BC60
M_A_CK_DDR1_DN: U35.H2 UC1.BA60
M_A_CK_DDR1_DP: U35.H3 UC1.BA62
M_A_CKE0: U35.C7 UC1.BB57
M_A_CKE1: U35.D7 UC1.BC58
M_A_CKE2: U35.J3 UC1.BE57
M_A_CKE3: U35.J4 UC1.AW61
M_A_CS0_N: U35.D6 U35.K4 UC1.AW63
M_A_CS1_N: U35.B7 U35.J2 UC1.BJ57
M_A_DQ_0: U35.L16 UC1.AG61
M_A_DQ_1: U35.K15 UC1.AH60
M_A_DQ_2: U35.J16 UC1.AK62
M_A_DQ_3: U35.J15 UC1.AK60
M_A_DQ_4: U35.K16 UC1.AH62
M_A_DQ_5: U35.L15 UC1.AG63
M_A_DQ_6: U35.K13 UC1.AL61
M_A_DQ_7: U35.K14 UC1.AL63
M_A_DQ_8: U35.C16 UC1.AM60
M_A_DQ_9: U35.B16 UC1.AM62
M_A_DQ_10: U35.C13 UC1.AT60
M_A_DQ_11: U35.C14 UC1.AR61
M_A_DQ_12: U35.C15 UC1.AN61
M_A_DQ_13: U35.B15 UC1.AN63
M_A_DQ_14: U35.B14 UC1.AR63
M_A_DQ_15: U35.B13 UC1.AT62
M_A_DQ_16: U35.F14 UC1.AT56
M_A_DQ_17: U35.D13 UC1.AR55
M_A_DQ_18: U35.E13 UC1.AN57
M_A_DQ_19: U35.E14 UC1.AN55
M_A_DQ_20: U35.F15 UC1.AR57
M_A_DQ_21: U35.F16 UC1.AT58
M_A_DQ_22: U35.E15 UC1.AM58
M_A_DQ_23: U35.E16 UC1.AM56
M_A_DQ_24: U35.M13 UC1.AL55
M_A_DQ_25: U35.L13 UC1.AL57
M_A_DQ_26: U35.N16 UC1.AH58
M_A_DQ_27: U35.N15 UC1.AH56
M_A_DQ_28: U35.M14 UC1.AK58
M_A_DQ_29: U35.N14 UC1.AK56
M_A_DQ_30: U35.P15 UC1.AG55
M_A_DQ_31: U35.P16 UC1.AG57
M_A_DQ_32: U35.R5 UC1.BE55
M_A_DQ_33: U35.N4 UC1.BC55
M_A_DQ_34: U35.T6 UC1.BG53
M_A_DQ_35: U35.R6 UC1.BE53
M_A_DQ_36: U35.N5 UC1.BC53
M_A_DQ_37: U35.T5 UC1.BG55
M_A_DQ_38: U35.P5 UC1.BD52
M_A_DQ_39: U35.P6 UC1.BF52
M_A_DQ_40: U35.N11 UC1.BC51
M_A_DQ_41: U35.N12 UC1.BE51
M_A_DQ_42: U35.R13 UC1.BC49
M_A_DQ_43: U35.P13 UC1.BE49
M_A_DQ_44: U35.P12 UC1.BG51
M_A_DQ_45: U35.T13 UC1.BG49
M_A_DQ_46: U35.T14 UC1.BF48
M_A_DQ_47: U35.R14 UC1.BD48
M_A_DQ_48: U35.N2 UC1.BJ55
M_A_DQ_49: U35.P2 UC1.BL55
M_A_DQ_50: U35.P3 UC1.BJ53
M_A_DQ_51: U35.R2 UC1.BL53
M_A_DQ_52: U35.R3 UC1.BN55
M_A_DQ_53: U35.T3 UC1.BN53
M_A_DQ_54: U35.N3 UC1.BM52
M_A_DQ_55: U35.T2 UC1.BK52
M_A_DQ_56: U35.T10 UC1.BL51
M_A_DQ_57: U35.T9 UC1.BJ51
M_A_DQ_58: U35.T11 UC1.BL49
M_A_DQ_59: U35.R9 UC1.BJ49
M_A_DQ_60: U35.R11 UC1.BN49
M_A_DQ_61: U35.R10 UC1.BN51
M_A_DQ_62: U35.N10 UC1.BK48
M_A_DQ_63: U35.P10 UC1.BM48
M_A_DQS_DN_0: U35.J13 UC1.AJ61
M_A_DQS_DN_1: U35.D15 UC1.AP62
M_A_DQS_DN_2: U35.G13 UC1.AP56
M_A_DQS_DN_3: U35.M15 UC1.AJ57
M_A_DQS_DN_4: U35.N7 UC1.BD54
M_A_DQS_DN_5: U35.R12 UC1.BF50
M_A_DQS_DN_6: U35.R4 UC1.BM54
M_A_DQS_DN_7: U35.N9 UC1.BK50
M_A_DQS_DP_0: U35.J14 UC1.AJ63
M_A_DQS_DP_1: U35.D16 UC1.AP60
M_A_DQS_DP_2: U35.G14 UC1.AP58
M_A_DQS_DP_3: U35.M16 UC1.AJ55
M_A_DQS_DP_4: U35.P7 UC1.BF54
M_A_DQS_DP_5: U35.T12 UC1.BD50
M_A_DQS_DP_6: U35.T4 UC1.BK54
M_A_DQS_DP_7: U35.P9 UC1.BM50
M_A_ODT0: U35.H13 U35.N8 UC1.BN61
M_B_CA_0_0: U33.B5 UC1.BK30
M_B_CA_0_1: U33.C5 UC1.BN31
M_B_CA_0_2: U33.D5 UC1.BM32
M_B_CA_0_3: U33.B6 UC1.BL37
M_B_CA_0_4: U33.C6 UC1.BG31
M_B_CA_0_5: U33.C9 UC1.BN37
M_B_CA_0_6: U33.D9 UC1.BJ37
M_B_CA_0_7: U33.B10 UC1.BJ35
M_B_CA_0_8: U33.C10 UC1.BM34
M_B_CA_0_9: U33.D10 UC1.BN35
M_B_CA_1_0: U33.L2 UC1.BG37
M_B_CA_1_1: U33.L3 UC1.BE37
M_B_CA_1_2: U33.L4 UC1.BC37
M_B_CA_1_3: U33.K2 UC1.BF34
M_B_CA_1_4: U33.K3 UC1.BC33
M_B_CA_1_5: U33.G3 UC1.BF30
M_B_CA_1_6: U33.G4 UC1.BD36
M_B_CA_1_7: U33.F2 UC1.BG35
M_B_CA_1_8: U33.F3 UC1.BC31
M_B_CA_1_9: U33.F4 UC1.BF36
M_B_CK_DDR0_DN: U33.H2 UC1.BK36
M_B_CK_DDR0_DP: U33.H3 UC1.BM36
M_B_CK_DDR1_DN: U33.C8 UC1.BD32
M_B_CK_DDR1_DP: U33.B8 UC1.BF32
M_B_CKE0: U33.J3 UC1.BN33
M_B_CKE1: U33.J4 UC1.BK32
M_B_CKE2: U33.C7 UC1.BG33
M_B_CKE3: U33.D7 UC1.BH30
M_B_CS0_N: U33.D6 U33.K4 UC1.BM30
M_B_CS1_N: U33.B7 U33.J2 UC1.BJ33
M_B_DQ_0: U33.D13 UC1.BC41
M_B_DQ_1: U33.E13 UC1.BC39
M_B_DQ_2: U33.E15 UC1.BG41
M_B_DQ_3: U33.E14 UC1.BE39
M_B_DQ_4: U33.F15 UC1.BF42
M_B_DQ_5: U33.F16 UC1.BD42
M_B_DQ_6: U33.F14 UC1.BG39
M_B_DQ_7: U33.E16 UC1.BE41
M_B_DQ_8: U33.N15 UC1.BC43
M_B_DQ_9: U33.M14 UC1.BD46
M_B_DQ_10: U33.M13 UC1.BG43
M_B_DQ_11: U33.N16 UC1.BG45
M_B_DQ_12: U33.N14 UC1.BC45
M_B_DQ_13: U33.L13 UC1.BE43
M_B_DQ_14: U33.P15 UC1.BE45
M_B_DQ_15: U33.P16 UC1.BF46
M_B_DQ_16: U33.N4 UC1.BM28
M_B_DQ_17: U33.P5 UC1.BN27
M_B_DQ_18: U33.N5 UC1.BK28
M_B_DQ_19: U33.R6 UC1.BL25
M_B_DQ_20: U33.T5 UC1.BN25
M_B_DQ_21: U33.P6 UC1.BL27
M_B_DQ_22: U33.T6 UC1.BJ25
M_B_DQ_23: U33.R5 UC1.BJ27
M_B_DQ_24: U33.N11 UC1.BM24
M_B_DQ_25: U33.R13 UC1.BK24
M_B_DQ_26: U33.P13 UC1.BN21
M_B_DQ_27: U33.R14 UC1.BJ23
M_B_DQ_28: U33.P12 UC1.BL23
M_B_DQ_29: U33.N12 UC1.BN23
M_B_DQ_30: U33.T14 UC1.BJ21
M_B_DQ_31: U33.T13 UC1.BL21
M_B_DQ_32: U33.K15 UC1.BN45
M_B_DQ_33: U33.K14 UC1.BM46
M_B_DQ_34: U33.K13 UC1.BL43
M_B_DQ_35: U33.L15 UC1.BK46
M_B_DQ_36: U33.J15 UC1.BN43
M_B_DQ_37: U33.K16 UC1.BL45
M_B_DQ_38: U33.L16 UC1.BJ45
M_B_DQ_39: U33.J16 UC1.BJ43
M_B_DQ_40: U33.C16 UC1.BM42
M_B_DQ_41: U33.C15 UC1.BN41
M_B_DQ_42: U33.C13 UC1.BJ41
M_B_DQ_43: U33.C14 UC1.BN39
M_B_DQ_44: U33.B16 UC1.BK42
M_B_DQ_45: U33.B15 UC1.BL41
M_B_DQ_46: U33.B14 UC1.BL39
M_B_DQ_47: U33.B13 UC1.BJ39
M_B_DQ_48: U33.P3 UC1.BF28
M_B_DQ_49: U33.N3 UC1.BD28
M_B_DQ_50: U33.T2 UC1.BG25
M_B_DQ_51: U33.N2 UC1.BC27
M_B_DQ_52: U33.R3 UC1.BG27
M_B_DQ_53: U33.P2 UC1.BE27
M_B_DQ_54: U33.R2 UC1.BE25
M_B_DQ_55: U33.T3 UC1.BC25
M_B_DQ_56: U33.P10 UC1.BF24
M_B_DQ_57: U33.T9 UC1.BD24
M_B_DQ_58: U33.T10 UC1.BG21
M_B_DQ_59: U33.R11 UC1.BC23
M_B_DQ_60: U33.R10 UC1.BE23
M_B_DQ_61: U33.R9 UC1.BG23
M_B_DQ_62: U33.T11 UC1.BC21
M_B_DQ_63: U33.N10 UC1.BE21
M_B_DQS_DN_0: U33.G13 UC1.BD40
M_B_DQS_DN_1: U33.M15 UC1.BD44
M_B_DQS_DN_2: U33.N7 UC1.BK26
M_B_DQS_DN_3: U33.R12 UC1.BM22
M_B_DQS_DN_4: U33.J13 UC1.BK44
M_B_DQS_DN_5: U33.D15 UC1.BM40
M_B_DQS_DN_6: U33.R4 UC1.BD26
M_B_DQS_DN_7: U33.N9 UC1.BF22
M_B_DQS_DP_0: U33.G14 UC1.BF40
M_B_DQS_DP_1: U33.M16 UC1.BF44
M_B_DQS_DP_2: U33.P7 UC1.BM26
M_B_DQS_DP_3: U33.T12 UC1.BK22
M_B_DQS_DP_4: U33.J14 UC1.BM44
M_B_DQS_DP_5: U33.D16 UC1.BK40
M_B_DQS_DP_6: U33.T4 UC1.BF26
M_B_DQS_DP_7: U33.P9 UC1.BD22
M_B_ODT0: U33.H13 U33.N8 UC1.BC35
ME_FWP#: Q7.5 R344.2 R346.1 U34.J13
MEC_XTAL1: C236.1 U34.A1 Y2.1
MEC_XTAL2: C235.1 U34.B1 Y2.2
MEM_CONFIG0: RH31.1 RH32.2 UC1.AN12
MEM_CONFIG1: RH29.1 RH30.2 UC1.AP9
MEM_CONFIG2: RH34.1 RH35.2 UC1.AN10
MEM_CONFIG3: RH33.2 RH36.1 UC1.AJ10
MIC1-VREFO_L: RA3.1 UA3.38
MIC1-VREFO_R: RA1.1 UA3.39
MONO_IN: CA67.2 UA3.23
MSCLK: JDEG1.6 R310.2 U34.C11
MSDATA: JDEG1.7 R311.2 R316.1 U34.E10
MUX_DP_AUXN: R276.2 R479.1 RV30.1 UV2.27
MUX_DP_AUXP: R277.2 R478.1 RV31.1 UV2.28
MUX_DP_N0: CV42.2 U31.15
MUX_DP_N0_C: CV42.1 UV2.23
MUX_DP_N1: CV40.2 U31.18
MUX_DP_N1_C: CV40.1 UV2.20
MUX_DP_N2: CV38.2 U31.20
MUX_DP_N2_C: CV38.1 UV2.17
MUX_DP_N3: CV44.2 U31.23
MUX_DP_N3_C: CV44.1 UV2.14
MUX_DP_P0: CV41.2 U31.16
MUX_DP_P0_C: CV41.1 UV2.22
MUX_DP_P1: CV39.2 U31.19
MUX_DP_P1_C: CV39.1 UV2.19
MUX_DP_P2: CV37.2 U31.21
MUX_DP_P2_C: CV37.1 UV2.16
MUX_DP_P3: CV43.2 U31.24
MUX_DP_P3_C: CV43.1 UV2.13
MUX_RFU1: R277.1 U31.13
MUX_RFU2: R276.1 U31.14
NB_MUTE#: DA4.2 U34.C6
NFC_DET#: JNFC1.3 RC42.2 UC1.BD8
NFC_EN: R162.2 U18.3 U18.5 UC1.T5
NFC_IRQ: JNFC1.16 R195.2 RH109.1 T31.1(TP-1) UC1.B8
NFC_RST#: JNFC1.8 R198.2 UC1.L8
NGFF1_CONFIG_0: JNGFF1.13 R343.2 U34.G13
NGFF1_CONFIG_1: JNGFF1.61 R353.2 U34.N13
NGFF1_CONFIG_2: JNGFF1.67 R60.2 U34.G10
NGFF1_CONFIG_3: JNGFF1.1 R360.2 U34.L9
NGFF_COEX1: JNGFF1.56 JNGFF3.48
NGFF_COEX2: JNGFF1.54 JNGFF3.46
NGFF_COEX3: JNGFF1.52 JNGFF3.44
NGFF_WWAN_PWREN: D6.2 UC1.BN4
OSC_IN: C83.1 R72.1 U6.B1 Y1.1
OSC_OUT: C82.1 R72.2 U6.A1 Y1.3
OTG_ID: R300.2 RH90.1 UC1.AF7
OUT1_CA_DET: R469.1 U47.43
P_SENSOR_ACT#: JIO1.11 U34.D4
P_SYS: C265.1 PR522.1 PU1101.E7 U34.M1
PANEL_BKEN_EC: D37.3 U34.F2
PBAT_PRES#_CHR: PQ150.3 PR151.2 PR531.1
PBAT_SMBCLK: PR106.2 R330.1 U34.C7
PBAT_SMBDAT: PR108.2 R328.1 U34.D7
PBTN_OUT#_R: RH20.2 RH22.1 UC1.BF14
PC10: R448.2 R449.2 U47.56
PC11: R451.2 R452.2 U47.55
PC20: R456.2 R457.2 U47.54
PC21: R460.2 R461.2 U47.53
PCH_DDI1_AUXN: CV34.1 UC1.H41
PCH_DDI1_AUXN_C: CV34.2 UV2.29
PCH_DDI1_AUXP: CV36.1 UC1.F41
PCH_DDI1_AUXP_C: CV36.2 UV2.30
PCH_DDI1_CLK: RC89.2 UC1.L6
PCH_DDI1_DAT: RC85.2 UC1.H6
PCH_DDI1_N0: CV31.1 UC1.A46
PCH_DDI1_N0_C: CV31.2 UV2.38
PCH_DDI1_N1: CV29.1 UC1.C48
PCH_DDI1_N1_C: CV29.2 UV2.41
PCH_DDI1_N2: CV27.1 UC1.B45
PCH_DDI1_N2_C: CV27.2 UV2.44
PCH_DDI1_N3: CV25.1 UC1.B47
PCH_DDI1_N3_C: CV25.2 UV2.47
PCH_DDI1_P0: CV32.1 UC1.C46
PCH_DDI1_P0_C: CV32.2 UV2.39
PCH_DDI1_P1: CV30.1 UC1.A48
PCH_DDI1_P1_C: CV30.2 UV2.42
PCH_DDI1_P2: CV28.1 UC1.D45
PCH_DDI1_P2_C: CV28.2 UV2.45
PCH_DDI1_P3: CV26.1 UC1.D47
PCH_DDI1_P3_C: CV26.2 UV2.48
PCH_DDI2_AUXN: C330.1 UC1.J40
PCH_DDI2_AUXN_C: C330.2 U47.25
PCH_DDI2_AUXP: C328.1 UC1.G40
PCH_DDI2_AUXP_C: C328.2 U47.24
PCH_DDI2_CLK: RC124.2 U47.22 UC1.H4
PCH_DDI2_DAT: RC128.2 U47.23 UC1.F4
PCH_DDI2_HPD: RH129.2 U47.3 UC1.L10
PCH_DDI2_N0: C314.1 UC1.A42
PCH_DDI2_N0_C: C314.2 U47.7
PCH_DDI2_N1: C312.1 UC1.A44
PCH_DDI2_N1_C: C312.2 U47.10
PCH_DDI2_N2: C310.1 UC1.B41
PCH_DDI2_N2_C: C310.2 U47.13
PCH_DDI2_N3: C308.1 UC1.B43
PCH_DDI2_N3_C: C308.2 U47.16
PCH_DDI2_P0: C315.1 UC1.C42
PCH_DDI2_P0_C: C315.2 U47.6
PCH_DDI2_P1: C313.1 UC1.C44
PCH_DDI2_P1_C: C313.2 U47.9
PCH_DDI2_P2: C311.1 UC1.D41
PCH_DDI2_P2_C: C311.2 U47.12
PCH_DDI2_P3: C309.1 UC1.D43
PCH_DDI2_P3_C: C309.2 U47.15
PCH_DPWROK: RH16.1 T10.1(TP-1) U34.A5
PCH_DPWROK_R: C74.2 RH9.2 RH16.2 RH19.2 UC1.BN15
PCH_ENVDD: D16.2 UC1.D3
PCH_GPD11: RH59.2 UC1.BC15
PCH_GPIOA7: RC38.1 TC36.1(TP-1) UC1.BF3
PCH_INV_PWM: D12.3 UC1.B6
PCH_JTAG_TCK: RC84.2 RC111.1 UC1.B53
PCH_JTAG_TDI: RC98.2 RC110.1 UC1.C50
PCH_JTAG_TDO: RC94.2 RC115.1 UC1.B51
PCH_JTAG_TMS: RC106.1 RC120.2 UC1.A52
PCH_JTAG_TRST#: RC100.1 UC1.C52
PCH_JTAGX: RC69.2 RC86.1 UC1.B49
PCH_MUTE#: DA4.3 UC1.AA8
PCH_OPIRCOMP: RC36.1 UC1.BP16
PCH_PLTRST#: RH73.2 RH81.1 RH82.2 UC1.BB8 UH3.1 UH3.2
PCH_PWR_EN: PR813.2 PR910.1 PR915.1 PR1000.2 U34.H13
PCH_PWROK: RH64.2 T25.1(TP-1) UC1.BP14 UH5.4
PCH_RSMRST#: RC122.1 RH21.1 RH24.2 T12.1(TP-1) U34.N12
PCH_RSMRST#_R: RH19.1 RH21.2 UC1.BJ12
PCH_RTCX1: CH9.1 RH60.1 UC1.BN19 YH1.1
PCH_RTCX2: CH10.1 RH60.2 UC1.BP18 YH1.2
PCH_SPI1_CLK: RC27.2 UC1.P9
PCH_SPI1_CS#: RC31.2 UC1.N6
PCH_SPI1_IO2: RC25.2 UC1.W12
PCH_SPI1_IO3: RC32.2 UC1.V7
PCH_SPI1_MISO: RC28.2 UC1.N8
PCH_SPI1_MOSI: RC30.2 UC1.P3
PCH_SPI_CLK: C9.1 CH7.1 JSPI1.8 R9.1 RC6.1 RC16.1
PCH_SPI_CLK_R: RC16.2 UC1.AU10
PCH_SPI_CS0#: JSPI1.10 RC3.1 UC1.AU4
PCH_SPI_CS1#: JSPI1.2 RC8.1 UC1.AU6
PCH_SPI_CS2#: R10.1 R12.1 R103.1 UC1.AU8
PCH_SPI_CS2#_R: R12.2 U2.20
PCH_SPI_IO2: JSPI1.12 RC4.1 RC13.1 UC1.AV11
PCH_SPI_IO3: JSPI1.14 RC1.1 UC1.AV13
PCH_SPI_SCLK: R9.2 U2.19
PCH_SPI_SI: JSPI1.4 R18.1 RC5.1 RC49.1 UC1.AT3
PCH_SPI_SI_MOSI: R18.2 U2.21
PCH_SPI_SO: JSPI1.6 R25.1 RC7.1 UC1.AU12
PCH_SPI_SO_R: R25.2 U2.24
PCH_SRTCRST#: CH5.1 RH23.2 T13.1(TP-1) UC1.BH18
PCH_STROBE_OUT: R126.1 RH116.1 UC1.N4
PCH_WWAN_WAKE#: R4.1 RH87.1 UC1.AJ12
PCIE_DE1: R134.2 R135.2 U14.3
PCIE_DE2: R147.2 R153.2 U14.16
PCIE_ENRXD: R137.2 U14.5
PCIE_EQ1: R132.2 R136.2 U14.2
PCIE_EQ2: R148.2 R154.2 U14.17
PCIE_OS1: R133.2 R138.2 U14.4
PCIE_OS2: R146.2 R152.2 U14.15
PCIE_PRX_DTX_N6: C134.1 UC1.B27
PCIE_PRX_DTX_N6_C: C134.2 U14.12
PCIE_PRX_DTX_N6_RP: JIO1.27 U14.19
PCIE_PRX_DTX_N7: JNGFF2.43 RH121.1
PCIE_PRX_DTX_N7_R: RH121.2 UC1.C26
PCIE_PRX_DTX_N8: JNGFF2.29 UC1.B25
PCIE_PRX_DTX_N9: JNGFF3.43 UC1.C28
PCIE_PRX_DTX_P6: C132.1 UC1.D27
PCIE_PRX_DTX_P6_C: C132.2 U14.11
PCIE_PRX_DTX_P6_RP: JIO1.25 U14.20
PCIE_PRX_DTX_P7: JNGFF2.41 RH125.1
PCIE_PRX_DTX_P7_R: RH125.2 UC1.A26
PCIE_PRX_DTX_P8: JNGFF2.31 UC1.D25
PCIE_PRX_DTX_P9: JNGFF3.41 UC1.A28
PCIE_PS: R151.2 U14.14
PCIE_PTX_DRX_N6: CH18.1 U14.9
PCIE_PTX_DRX_N6_C: CH18.2 UC1.F27
PCIE_PTX_DRX_N6_RP: C130.2 JIO1.33
PCIE_PTX_DRX_N6_RP_C: C130.1 U14.22
PCIE_PTX_DRX_N7: CH23.1 JNGFF2.47
PCIE_PTX_DRX_N7_C: CH23.2 UC1.G26
PCIE_PTX_DRX_N8: CH20.1 JNGFF2.35
PCIE_PTX_DRX_N8_C: CH20.2 UC1.F25
PCIE_PTX_DRX_N9: CH16.1 JNGFF3.37
PCIE_PTX_DRX_N9_C: CH16.2 UC1.G28
PCIE_PTX_DRX_P6: CH19.1 U14.8
PCIE_PTX_DRX_P6_C: CH19.2 UC1.H27
PCIE_PTX_DRX_P6_RP: C129.2 JIO1.31
PCIE_PTX_DRX_P6_RP_C: C129.1 U14.23
PCIE_PTX_DRX_P7: CH22.1 JNGFF2.49
PCIE_PTX_DRX_P7_C: CH22.2 UC1.J26
PCIE_PTX_DRX_P8: CH21.1 JNGFF2.37
PCIE_PTX_DRX_P8_C: CH21.2 UC1.H25
PCIE_PTX_DRX_P9: CH17.1 JNGFF3.35
PCIE_PTX_DRX_P9_C: CH17.2 UC1.J28
PCIE_RCOMPN: RC66.2 UC1.A9
PCIE_RCOMPP: RC66.1 UC1.B10
PCIE_RP_RST#: U14.7 U52.4
PCIE_WAKE_I#: JNGFF1.46 JNGFF3.55 R342.1 R408.2 U34.G11
PCIE_WAKE_O#: RH62.2 RH74.1 T18.1(TP-1) U34.G12
PD_AUX_N: R479.2 U32.J2
PD_AUX_P: R478.2 U32.J1
PD_DEBUG1: R265.2 R273.2 U32.L2
PD_DEBUG2: R266.2 R272.2 U32.K2
PD_DEBUG3: R280.2 U32.L3
PD_DEBUG4: R278.2 U32.K3
PD_EE_CLK: TC15.1(TP-1) U28.6 U32.A3
PD_EE_CS#: R267.2 TC20.1(TP-1) U28.1 U32.B3
PD_EE_MISO: R271.2 TC21.1(TP-1) U28.2 U32.A4
PD_EE_MOSI: TC16.1(TP-1) U28.5 U32.B4
PD_EE_WP#: R244.2 U28.3
PD_GPIO0: R255.1 U32.B2
PD_GPIO1: R257.1 U32.C2
PD_GPIO2: R303.1 U32.D10
PD_GPIO3: R308.1 U32.G11
PD_GPIO4: R302.1 U32.C10
PD_GPIO5: R300.1 R485.1 U32.E10
PD_GPIO6: R301.1 U32.G10
PD_GPIO8: R260.1 U32.H6
PD_HOLD#: R239.2 U28.7
PD_SBU1: R284.1 U32.K8
PD_SBU2: R281.1 U32.L8
PECI_EC: R327.1 U34.A12
PEDET: R470.1 R471.1 RH115.1 RH133.2 UC1.G11
PEQ: R433.2 R434.2 U47.8
PEWAKE#: JNGFF2.54 R407.1 R408.1
PI0: R443.2 U47.60
PI1: R439.2 R440.2 U47.1
PLL_COMP1: C100.1 R99.1 U6.A3
PLL_COMP2: C110.2 R114.1 U6.A4
PLL_VDD: C112.2 U6.A5
PLT_RST#: JIO1.16 JLPDE1.8 JNGFF1.42 JNGFF2.50 Q16.2 R30.1 R166.1 RH67.1 RH82.1 T14.1(TP-1) U2.17 U6.H2 U8.1 U19.1 U19.2 U34.K3 UH3.4
PM_SYS_RESET#: JAPS2.6 RC34.1 RH111.1 T34.1(TP-1)
PME#: TC37.1(TP-1) UC1.BF7
PMU_VCC: JNFC1.14 R196.2 R197.2
POGO_DET#: PD502.1 PD503.1 PR303.2 PR549.2 PU200.1 PU300.4
POGO_DET#_L: JIO4.30 PR300.2 PR303.1 PU300.1 R332.1 U34.B9
POGO_DET#_R: PQ300.1 PR301.2 PU300.2 R354.2 U34.F10
POGO_DET_R: JIO4.32 PQ300.2 PR302.1
PWR_BTN_DOCK1#: R259.1 U32.D7
PWR_BTN_DOCK#: QT1.6 R333.1
PWR_LED#: JIO1.14 U34.B3
PWR_SW_IN#: C231.1 D35.1 R334.2 R494.2 U1.3 U34.C2
PWRBTN#: JIO1.21 PU1500.1 R325.1 R494.1 SW3.1 SW3.3
PWRGD_XDP: JXDP1.39 RC122.2
REM_DIODE1_N: C126.2 C128.1 C242.2 Q11.3 Q12.1 Q12.2 U34.E13
REM_DIODE1_P: C126.1 C128.2 C242.1 Q11.1 Q11.2 Q12.3 U34.F13
REM_DIODE2_N: C239.2 C341.2 C352.1 Q20.3 Q21.1 Q21.2 U34.D13
REM_DIODE2_P: C239.1 C341.1 C352.2 Q20.1 Q20.2 Q21.3 U34.C13
REM_DIODE3_N: C19.1 C238.2 C257.2 Q3.1 Q3.2 Q14.3 U34.A13
REM_DIODE3_P: C19.2 C238.1 C257.1 Q3.3 Q14.1 Q14.2 U34.B13
REXT: R435.1 U47.20
RING2: CA2.1 DA9.3 DA10.1 JHP1.4 L2.2
RING2_L: L2.1 RA3.2 UA3.36
RP_CEXT: CV10.1 UV1.2
RP_CFG0: RV10.2 RV11.2 UV1.5
RP_CFG1: RV1.2 RV2.2 UV1.40
RP_DP_CBL_DET: RV15.1 RV16.1 UV1.10
RP_DP_CLK_AUXP: D11.1 JIO4.54 RV12.1 UV1.28
RP_DP_DAT_AUXN: D13.1 JIO4.56 RV14.1 UV1.27
RP_DP_HPD: JIO4.44 RV17.1 UV1.11
RP_DP_N0: CV17.2 D17.1 JIO4.62
RP_DP_N0_C: CV17.1 UV1.22
RP_DP_N1: CV21.2 D21.1 JIO4.68
RP_DP_N1_C: CV21.1 UV1.19
RP_DP_N2: CV15.2 D14.1 JIO4.74
RP_DP_N2_C: CV15.1 UV1.16
RP_DP_N3: CV19.2 D19.1 JIO4.80
RP_DP_N3_C: CV19.1 UV1.13
RP_DP_P0: CV18.2 D18.1 JIO4.60
RP_DP_P0_C: CV18.1 UV1.23
RP_DP_P1: CV22.2 D22.1 JIO4.66
RP_DP_P1_C: CV22.1 UV1.20
RP_DP_P2: CV16.2 D15.1 JIO4.72
RP_DP_P2_C: CV16.1 UV1.17
RP_DP_P3: CV20.2 D20.1 JIO4.78
RP_DP_P3_C: CV20.1 UV1.14
RP_PEQ: RV8.2 RV9.2 UV1.4
RPDP_CBL_DET: RV21.1 UV2.10
RTC_RST#: CH11.2 CLRP2.2 JAPS2.10 R400.1 RH25.2 T20.1(TP-1) UC1.BN12
RTCRST_ON: Q15.2 R395.2 U34.E2
RUN_ON: R337.1 U34.D1
RUN_ON_EC: PR709.1 PR803.1 R140.1 R167.2 R171.1 R181.1 R337.2 R366.2 U7.3 U13.3 U22.5 U26.3 U38.2 UH1.2 UH4.2 UV3.3
RUNPWROK: D3.2 R24.2 R35.1 R139.1 R143.1 R164.1 R364.1 R388.1 R391.1 U34.F1
RX_DE_0: R223.2 R225.2 U27.3
RX_DE_1: R233.2 R234.2 U27.6
RX_EQ_0: R219.2 R222.2 U27.2
RX_EQ_1: R227.2 R229.2 U27.4
SAR_DPR: Q1.1 U34.C5
SAR_DPR_R: JNGFF1.17 Q1.3 R1.2
SCLK: PR1117.2 PU1101.F5
SD_PWR_EN: R111.2 R483.2 U12.5 UC1.BL4
SDA: PR1113.2 PU1101.F6
SDIO_RCOMP: RC39.2 UC1.BF1
SIM_VCC: JNFC1.4 R177.2 R188.2
SIO_EXT_SCI#: RH130.1 U34.C4 UC1.AW12
SIO_EXT_SMI#: R355.1 RC82.2 UC1.E11
SIO_EXT_SMI#_R: R355.2 U34.N5
SIO_EXT_WAKE#: RC113.2 U34.L7 UC1.AD3
SIO_PWRBTN#: JAPS2.8 RC121.1 RH22.2 T11.1(TP-1) U34.M13
SIO_RCIN#: RH61.1 U34.D11 UC1.BL10
SIO_SLP_A#: JAPS2.13 T5.1(TP-1) U34.N1 UC1.BE17
SIO_SLP_S0#: JAPS2.4 PR801.1 PR829.1 PR908.1 R176.1 R348.1 R358.1 RH71.2
SIO_SLP_S0IX#: R463.1 R464.1 U24.1 UH2.4
SIO_SLP_S3#: JAPS2.17 R366.1 T8.1(TP-1) U34.L2 UC1.AY14
SIO_SLP_S4#: JAPS2.14 R23.1 T16.1(TP-1) U34.A4 UC1.BF16
SIO_SLP_S5#: JAPS2.15 T17.1(TP-1) UC1.BH14
SIO_SLP_SUS#: RH68.2 U34.M3
SIO_SLP_SUS#_L: RH68.1 UC1.BN10
SIO_SLP_WLAN#: D4.2 T15.1(TP-1) U34.A8 UC1.BH16
SKTOCC#: RC64.1 UC1.B62
SKYCAM_CSI0_D: L18.4 R376.1 UC1.F29
SKYCAM_CSI0_D#: L18.1 R377.1 UC1.H29
SKYCAM_CSI0_D#_L: JWFC.6 L18.2 R377.2
SKYCAM_CSI0_D_L: JWFC.8 L18.3 R376.2
SKYCAM_CSI1_D: L17.4 R374.1 UC1.H33
SKYCAM_CSI1_D#: L17.1 R375.1 UC1.F33
SKYCAM_CSI1_D#_L: JWFC.2 L17.2 R375.2
SKYCAM_CSI1_D_L: JWFC.4 L17.3 R374.2
SKYCAM_CSI2_D: L20.4 R380.1 UC1.G30
SKYCAM_CSI2_D#: L20.1 R381.1 UC1.J30
SKYCAM_CSI2_D#_L: JWFC.14 L20.2 R381.2
SKYCAM_CSI2_D_L: JWFC.16 L20.3 R380.2
SKYCAM_CSI3_D: L19.4 R378.1 UC1.G32
SKYCAM_CSI3_D#: L19.1 R379.1 UC1.J32
SKYCAM_CSI3_D#_L: JWFC.18 L19.2 R379.2
SKYCAM_CSI3_D_L: JWFC.20 L19.3 R378.2
SKYCAM_CSI_CLK_D: L21.4 R382.1 UC1.F31
SKYCAM_CSI_CLK_D#: L21.1 R383.1 UC1.H31
SKYCAM_CSI_CLK_D#_L: JWFC.10 L21.2 R383.2
SKYCAM_CSI_CLK_D_L: JWFC.12 L21.3 R382.2
SKYCAM_I2C_CLK: RH6.1 U6.G5 UC1.AP7
SKYCAM_I2C_DATA: RH10.1 U6.F5 UC1.AP3
SKYCAM_USER_CSI0_D: L9.4 R82.1 UC1.B35
SKYCAM_USER_CSI0_D#: L9.1 R83.1 UC1.D35
SKYCAM_USER_CSI0_D#_L: JUFC.22 L9.2 R83.2
SKYCAM_USER_CSI0_D_L: JUFC.20 L9.3 R82.2
SKYCAM_USER_CSI1_D: L7.1 R79.1 UC1.A36
SKYCAM_USER_CSI1_D#: L7.4 R78.1 UC1.C36
SKYCAM_USER_CSI1_D#_L: JUFC.14 L7.3 R78.2
SKYCAM_USER_CSI1_D_L: JUFC.12 L7.2 R79.2
SKYCAM_USER_CSI_CLK_D: L8.1 R81.1 UC1.A34
SKYCAM_USER_CSI_CLK_D#: L8.4 R80.1 UC1.C34
SKYCAM_USER_CSI_CLK_D#_L: JUFC.18 L8.3 R80.2
SKYCAM_USER_CSI_CLK_D_L: JUFC.16 L8.2 R81.2
SLEEVE: CA1.1 DA9.2 DA11.1 JHP1.3 L1.2
SLEEVE_L: L1.1 RA1.2 UA3.37
SLP_S0#: RH71.1 UC1.BC9
SM_INTRUDER#: RH7.2 UC1.BG19
SM_PG_CTRL: PR705.1 RC14.2 UC2.4
SMBALERT#: RH98.2 UC1.W8
SMBCLK: JXDP1.53 RH95.1 UC1.AC12
SMBDATA: JXDP1.51 RH97.1 UC1.W6
SML0ALERT#: RH128.2 UC1.AA6
SML0CLK: JNFC1.10 R501.2 RH54.1 UC1.W4
SML0DATA: JNFC1.12 R502.2 RH53.1 UC1.AC10
SML1_SMBCLK: RH123.1 U34.D3 UC1.AA4
SML1_SMBDAT: RH117.1 U34.A7 UC1.W10
SML1ALERT#: RH80.1 RH83.1 UC1.BB6
SNB_1.0V: PC810.1 PR815.2
SOC_SATALED#: TC61.1(TP-1) UC1.H8
SOC_SVID_ALERT#: RC79.1 UC1.B58
SOC_SVID_CLK: RC80.1 UC1.A56
SOC_SVID_DAT: RC78.1 UC1.A58
SPDIF_IN: TC14.1(TP-1) UA2.9
SPI1_INT#: RC88.2 UC1.M7
SPI_CLK_ROM1: RH93.1 U39.6
SPI_CLK_ROM2: RH52.1 U16.6
SPI_IO2_ROM1: RH112.1 U39.3
SPI_IO2_ROM2: RH55.1 U16.3
SPI_IO3_ROM1: RH92.1 U39.7
SPI_IO3_ROM2: RH50.1 U16.7
SPI_PCH_CLK: JSPI1.7 RC6.2 RH52.2 RH93.2
SPI_PCH_CS0#: JSPI1.9 RC3.2 U39.1
SPI_PCH_CS1#: JSPI1.1 RC8.2 U16.1
SPI_PCH_IO2: JSPI1.11 RC4.2 RH55.2 RH56.2 RH112.2
SPI_PCH_IO3: JSPI1.13 RC1.2 RH48.2 RH49.2 RH50.2 RH92.2
SPI_PCH_SI: JSPI1.3 RC5.2 RH51.2 RH94.2
SPI_PCH_SO: JSPI1.5 RC7.2 RH57.2 RH113.2
SPI_SI_ROM1: RH94.1 U39.5
SPI_SI_ROM2: RH51.1 U16.5
SPI_SO_ROM1: RH113.1 U39.2
SPI_SO_ROM2: RH57.1 U16.2
SPK_L+: CA69.1 DA8.2 JSPKL.1 LA13.2
SPK_L+_L: CA30.1 LA8.2 LA13.1 UA2.23
SPK_L-: CA70.1 DA8.3 JSPKL.2 LA14.2
SPK_L-_L: LA14.1 RA60.2 UA2.22
SPK_L-_R: CA31.1 LA9.2 RA60.1 UA2.21
SPK_R+_L: CA19.1 JIO1.54 JIO1.56 JIO1.58 JIO1.60 LA6.2 UA2.26
SPK_R-_L: JIO1.51 UA2.25
SPK_R-_R: CA17.1 JIO1.53 JIO1.55 JIO1.57 JIO1.59 LA4.2 UA2.24
SPKR: RA59.1 RC43.2 UC1.AV3
SS_0.95V_PRIM: PC921.1 PR916.1 PU901.7
SSD_PEDET: JNGFF2.69 R470.2 U51.2
SSD_PWR_EN: R180.1 UC1.AF9
SSD_PWR_EN_R: R179.2 R180.2 R181.2 U20.3
SSD_RST#: RH42.1 UC1.AG12
STROBE_IN: R126.2 U6.D2
SUS_ON: R33.1 U34.L8
SUS_ON_EC: JUSH1.3 PR708.1 R23.2 R33.2 R63.2 R465.1 U7.5 U23.1
SUSACK#: RH79.1 T21.1(TP-1) U34.L1
SUSACK#_R: RH78.2 RH79.2 UC1.BF9
SUSCLK: C59.1 C118.1 C295.1 MC1.2 R51.2 R121.2 R409.2 RH26.2
SUSCLK_L: JNGFF1.60 R51.1
SUSWARN#: RH77.1 T19.1(TP-1) U34.H2
SUSWARN#_R: RH70.2 RH77.2 RH78.1 UC1.BL6
SVID_ALERT#: PR1108.2 PR1115.1 RC79.2 RC90.2
SVID_CLK: PR1111.2 PR1117.1 RC80.2
SVID_DAT: PR1106.2 PR1113.1 RC78.2 RC96.1
SW: PD400.2 PL1105.2 PR401.1 PU400.2
SWP: JNFC1.20 R200.2
SYS_PRES#: JT100.7 PR1510.1 PU1500.5
SYS_PWROK: RH105.2 T27.1(TP-1) U34.N7 UH4.1
SYS_RESET#: RH106.2 RH111.2 UC1.H2
TBAT_3V3: JT100.6 PD101.2 PR109.1
TMDS_L_TX0N: CX21.1 JHDMI1.11 LX2.3
TMDS_L_TX0P: CX22.1 JHDMI1.9 LX2.2
TMDS_L_TX1N: CX23.1 JHDMI1.8 LX3.3
TMDS_L_TX1P: CX24.1 JHDMI1.6 LX3.2
TMDS_L_TX2N: CX25.1 JHDMI1.5 LX4.3
TMDS_L_TX2P: CX26.1 JHDMI1.3 LX4.2
TMDS_L_TXCN: CX19.1 JHDMI1.14 LX1.3
TMDS_L_TXCP: CX20.1 JHDMI1.12 LX1.2
TMDS_TX0N: LX2.4 U25.24
TMDS_TX0P: LX2.1 U25.25
TMDS_TX1N: LX3.4 U25.26
TMDS_TX1P: LX3.1 U25.27
TMDS_TX2N: LX4.4 U25.29
TMDS_TX2P: LX4.1 U25.30
TMDS_TXCN: LX1.4 U25.21
TMDS_TXCP: LX1.1 U25.22
TP_DDR_DRAM_RST_N: TC29.1(TP-1) UC1.BP20
TPM_GPIO0: R358.2 U2.29
TPM_GPIO2: R53.2 R54.1 U2.3
TPM_GPIO4: R10.2 U2.13
TPM_IRQ#: RH96.1 U2.18 UC1.N10
TS_EN: R436.2 U46.3 UC1.AW4
TS_I2C_SCL: R190.1 RC52.1 UC1.AB11
TS_I2C_SCL_R: DI2.3 JTS1.10 R190.2
TS_I2C_SDA: R191.1 RC53.1 UC1.AB9
TS_I2C_SDA_R: DI2.2 JTS1.11 R191.2
TS_ID1: JTS1.9 RH72.1 UC1.BJ1
TS_ID2: JTS1.8 RH76.1 UC1.BJ4
TS_ID3: JTS1.2 RH75.1 UC1.BJ3
TS_INT#: R194.1 RH100.1 UC1.T11
TS_INT#_R: DI1.3 JTS1.7 R194.2
TS_PD#: R201.1 RC76.2 UC1.M9
TS_PD#_R: JTS1.12 R201.2
TS_RST#: DI1.2 JTS1.6 RH118.1 UC1.H10
TX_BLANKING: JNGFF1.40 T2.1(TP-1)
TX_DE_0: R226.2 R228.2 U27.16
TX_DE_1: R218.2 R220.2 U27.18
TX_EQ_0: R221.2 R224.2 U27.17
TX_EQ_1: R230.2 R232.2 U27.15
UART2_CTS#: RC112.2 TC74.1(TP-1) UC1.AD9
UART2_RXD: RC54.2 U29.2 UC1.AD5
UART2_TXD: RC55.2 U29.1 UC1.AD7
UF_HCLK: C49.1 JUFC.6 L26.1
UF_HCLK_R: C41.1 L26.2 U6.C5
UF_I2C_CLK: JUFC.10 RH2.1 UC1.AN6
UF_I2C_DATA: JUFC.9 RH1.1 UC1.AN4
UF_SENSOR_RST#: JUFC.11 R40.2 R41.2 R56.1
UF_SENSOR_RST#_R: R56.2 U6.C6
UIM_CLK: JIO1.47 JNGFF1.24
UIM_DATA: JIO1.43 JNGFF1.26
UIM_DET: JIO1.48 R43.2
UIM_DET#: JNGFF1.58 R43.1
UIM_RESET: JIO1.46 JNGFF1.22
UPD_I2C_ALERT#: R61.2 R490.1 R493.1 U34.L10
UPD_TD_SMBCLK: R265.1 R352.1 R489.1 R492.1 U34.L12
UPD_TD_SMBDAT: R266.1 R363.1 R488.1 R491.1 U34.M12
USB2_COMP: RC61.1 UC1.N2
USB3RN1: C192.2 UC1.C16
USB3RN1_C: C192.1 U27.23
USB3RN1_RP: R236.1 U31.27
USB3RN1_RP_C: R236.2 U27.8
USB3RN2: ML1.1 R6.1 UC1.B15
USB3RN2_CON: JNGFF1.21 ML1.2 R6.2
USB3RN3: JIO4.98 UC1.C18
USB3RN4: ML4.1 R96.1 UC1.B17
USB3RN4_CON: JCAM3.2 MD1.1 MD1.9 ML4.2 R96.2
USB3RN5: ML12.4 R475.1 UC1.C20
USB3RN5_CON: JUSB1.5 MD2.1 ML12.3 R475.2
USB3RP1: C193.2 UC1.A16
USB3RP1_C: C193.1 U27.22
USB3RP1_RP: R237.1 U31.28
USB3RP1_RP_C: R237.2 U27.9
USB3RP2: ML1.4 R8.1 UC1.D15
USB3RP2_CON: JNGFF1.23 ML1.3 R8.2
USB3RP3: JIO4.96 UC1.A18
USB3RP4: ML4.4 R86.1 UC1.D17
USB3RP4_CON: JCAM3.3 MD1.2 MD1.8 ML4.3 R86.2
USB3RP5: ML12.1 R474.1 UC1.A20
USB3RP5_CON: JUSB1.6 MD2.2 ML12.2 R474.2
USB3TN1: C194.1 UC1.G16
USB3TN1_C: C194.2 U27.20
USB3TN1_RP: C196.2 U31.25
USB3TN1_RP_C: C196.1 U27.11
USB3TN2: C14.1 UC1.F15
USB3TN2_CON: JNGFF1.27 ML2.2 R11.2
USB3TN2_R: C14.2 ML2.1 R11.1
USB3TN3: JIO4.92 UC1.G18
USB3TN4: C84.1 UC1.F17
USB3TN4_C: C84.2 ML5.1 R97.1
USB3TN4_CON: JCAM3.5 MD1.4 MD1.7 ML5.2 R97.2
USB3TN5: C347.1 UC1.G20
USB3TN5_C: C347.2 ML11.4 R473.1
USB3TN5_CON: JUSB1.8 MD2.3 ML11.3 R473.2
USB3TP1: C195.1 UC1.J16
USB3TP1_C: C195.2 U27.19
USB3TP1_RP: C197.2 U31.26
USB3TP1_RP_C: C197.1 U27.12
USB3TP2: C18.1 UC1.H15
USB3TP2_CON: JNGFF1.29 ML2.3 R13.2
USB3TP2_R: C18.2 ML2.4 R13.1
USB3TP3: JIO4.90 UC1.J18
USB3TP4: C80.1 UC1.H17
USB3TP4_C: C80.2 ML5.4 R88.1
USB3TP4_CON: JCAM3.6 MD1.5 MD1.6 ML5.3 R88.2
USB3TP5: C346.1 UC1.J20
USB3TP5_C: C346.2 ML11.1 R472.1
USB3TP5_CON: JUSB1.9 MD2.4 ML11.2 R472.2
USB20_N1: ML6.4 R270.1 UC1.AJ6
USB20_N1_R: ML6.3 R270.2 U32.K5
USB20_N2: ML3.4 R39.1 UC1.AM3
USB20_N2_R: JNGFF3.5 ML3.3 R39.2
USB20_N3: L22.1 R394.1 UC1.AL6
USB20_N3_CONN: JNGFF1.9 L22.2 R394.2
USB20_N5: JIO4.86 UC1.AH5
USB20_N7: JUSH1.8 UC1.AF5
USB20_N9: UC1.AG6 US1.2
USB20_N9_CONN: JUSB1.2 MD2.6 ML13.2 R477.2
USB20_N9_PS: R252.1 U29.4 US1.11
USB20_N9_SW: ML13.1 R252.2 R477.1 U29.7
USB20_P1: ML6.1 R269.1 UC1.AJ4
USB20_P1_R: ML6.2 R269.2 U32.L5
USB20_P2: ML3.1 R46.1 UC1.AM5
USB20_P2_R: JNGFF3.3 ML3.2 R46.2
USB20_P3: L22.4 R398.1 UC1.AL4
USB20_P3_CONN: JNGFF1.7 L22.3 R398.2
USB20_P5: JIO4.84 UC1.AH3
USB20_P7: JUSH1.9 UC1.AF3
USB20_P9: UC1.AG4 US1.3
USB20_P9_CONN: JUSB1.3 MD2.5 ML13.3 R476.2
USB20_P9_PS: R248.1 U29.3 US1.10
USB20_P9_SW: ML13.4 R248.2 R476.1 U29.8
USB_DET#: JUSB1.10 R22.2 U34.B6
USB_ILIM_SEL1: R243.2 US1.4
USB_OC0#: R260.2 RH122.1 T32.1(TP-1) UC1.N12
USB_OC1#: RH126.1 T35.1(TP-1) UC1.M11 US1.13
USB_OC2#: RH110.1 T30.1(TP-1) UC1.F8
USB_PWR_SHR_EN#: U34.D6 US1.6
USB_PWR_SHR_VBUS_EN: R241.2 U34.D5 US1.5
USBC_AMSEL: R280.1 R285.2 R295.1 U31.8
USBC_BOT_N: R306.2 U32.L7
USBC_BOT_N_R: D33.1 JUSBC1.B7 R306.1
USBC_BOT_P: R307.2 U32.K7
USBC_BOT_P_R: D34.1 JUSBC1.B6 R307.1
USBC_CC1: C219.1 D39.1 JUSBC1.A5 U32.K9 U32.L9
USBC_CC2: C221.1 D42.1 JUSBC1.B5 U32.K10 U32.L10
USBC_DIS#: U30.2 U34.M9
USBC_EN: R278.1 R495.2 U30.1
USBC_EN_R: R231.1 R242.1 R264.2 R495.1 U30.4
USBC_HPD: R302.2 RV20.1 UV2.11
USBC_MUX_EN: R261.1 R262.2 R264.1 U31.17
USBC_POL: R255.2 R286.2 R296.1 U31.3
USBC_RX1N: D24.1 JUSBC1.B10 U31.2
USBC_RX1P: D23.1 JUSBC1.B11 U31.1
USBC_RX2N: D30.1 JUSBC1.A10 U31.10
USBC_RX2P: D29.1 JUSBC1.A11 U31.9
USBC_SBU1: D40.1 JUSBC1.A8 R283.1 R284.2
USBC_SBU1_R: R283.2 U31.11
USBC_SBU2: D41.1 JUSBC1.B8 R279.1 R281.2
USBC_SBU2_R: R279.2 U31.12
USBC_TOP_N: R304.1 U32.L6
USBC_TOP_N_R: D31.1 JUSBC1.A7 R304.2
USBC_TOP_P: R305.1 U32.K6
USBC_TOP_P_R: D32.1 JUSBC1.A6 R305.2
USBC_TX1N: D26.1 JUSBC1.A3 U31.5
USBC_TX1P: D25.1 JUSBC1.A2 U31.4
USBC_TX2N: D28.1 JUSBC1.B3 U31.7
USBC_TX2P: D27.1 JUSBC1.B2 U31.6
USH_DET#: JUSH1.26 RH39.1 UC1.AL10
USH_I2C_ALERT#: JUSH1.13 R357.2 U34.E4
USH_PS_SMBCLK: JIO1.13 JUSH1.11 QA2.3 R323.1 U34.B7
USH_PS_SMBDAT: JIO1.15 JUSH1.12 QA2.6 R322.1 U34.D2
USH_PWR_STATE#: JUSH1.22 RZ3.2 U34.C3
USH_RST#: R326.1 U34.A11
USH_RST#_R: JUSH1.21 R166.2 R326.2 RZ1.2 RZ2.2 U19.4
VCORE_PG: PR1105.2 PU1101.F3 UH5.2
VDOCKPOGOPIN: C262.1 PR540.2 U34.N2
VOLUME_DOWN#: D8.1 R124.2 SW2.2
VOLUME_UP#: D2.1 R21.2 SW1.2
VR_ON: PR1107.1 R412.1 R498.1 UH1.4 UH5.1
VSET_1641: C241.1 R335.1 U34.D12
WAKE#: RH74.2 UC1.BP9
WC_I2C_ALERT#: JIO4.42 R369.1 U34.L3
WF_HCLK: C43.1 JWFC.30 L25.1
WF_HCLK_R: C70.1 L25.2 U6.D5
WF_I2C_CLK: JWFC.33 RH13.1 U6.F6
WF_I2C_DATA: JWFC.32 RH12.1 U6.D6
WF_SENSOR_RST#: JWFC.27 R42.2 R44.1 R49.2
WF_SENSOR_RST#_R: R44.2 U6.E4
WIN7_DEBUG#: R245.2 U29.9 UC1.AH11
WL_OFF#_R: D5.1 JNGFF3.56 R101.1
WLAN_EN: D4.1 R34.2 U3.3
WLAN_ON: D5.3 UC1.BB2
WLAN_PWR_EN: TC39.1(TP-1) UC1.AW10
WLAN_RST#: RC87.2 U8.2 UC1.F6
WLAN_RST#_Q: JNGFF3.52 R67.1 U8.4
WLAN_WIGIG60GHZ_DIS#: D5.2 U34.M11
WWAN_EN: D6.1 R105.2 U12.3
WWAN_OFF#: Q4.1 RH41.1 UC1.AG8
WWAN_OFF#_R: JNGFF1.8 Q4.6 R27.2
WWAN_PWR_OFF#: R7.2 UC1.AM11
WWAN_PWR_OFF#_R: C8.1 JNGFF1.6 R5.2 R7.1
WWAN_RST#: R29.1 RH127.1 UC1.AC8
WWAN_RST#_Q: JNGFF1.59 Q5.1 R52.2
WWAN_WAKE#: JNGFF1.15 R4.2
XCLK_BIASREF: RH103.1 UC1.P1
XDP_BPM#0: RC126.1 UC1.H51
XDP_BPM#1: RC125.1 UC1.J50
XDP_BPM#2: TC50.1(TP-1) UC1.F51
XDP_BPM#3: TC64.1(TP-1) UC1.G50
XDP_DBRESET#: CC90.1 JXDP1.48 RC34.2
XDP_HOOK3: JXDP1.47 RC49.2 RC114.2
XDP_OBS0: JXDP1.21 RC126.2
XDP_OBS1: JXDP1.23 RC125.2
XDP_PIN1: JXDP1.1 RC63.2
XDP_PRDY#: JXDP1.5 T36.1(TP-1) UC1.D51
XDP_PREQ#: JXDP1.3 RC123.2 T37.1(TP-1) UC1.B55
XDP_PRSENT: U23.2 U24.2 U44.4
XDP_PRSENT#: JXDP1.60 RC13.2 RC107.2 U44.2
XDP_PWRBTN#: CC123.1 JXDP1.41 RC121.2
XDP_RST#: JXDP1.46 RC75.2 RC77.2
XDP_TCK0: JXDP1.57 RC86.2 RC92.2
XDP_TCK1: JXDP1.55 RC111.2
XDP_TDI: JXDP1.56 RC109.2 RC110.2
XDP_TDO: JXDP1.52 RC115.2 RC116.2
XDP_TMS: JXDP1.58 RC105.2 RC106.2
XDP_TRST#: JXDP1.54 RC100.2 RC101.2
XTAL24_IN: CH14.1 RH104.2 UC1.M1 YH2.3
XTAL24_OUT: CH15.1 RH104.1 UC1.L2 YH2.1
N1728290: PC1108.2 PL1102.1 PQ1100.9 PR1109.1 PR1154.1 PU1100.8
N1728978: PQ1100.8 PR1112.2 PU1100.5
N1925285: PC1120.1 PR1131.1 PR1132.1 PU1101.G7
N16334024: PD500.1 PD501.1 PD504.1 PR504.1
N16334844: PL500.1 PR500.4
N16335894: PC540.1 PR530.1 PU500.17
N16335926: PC523.1 PC525.2 PR501.2 PU500.2
N16335934: PC523.2 PC524.1 PR502.2 PU500.1
N16336052: PR509.2 PR512.2 PR516.1 PU500.5
N16336068: PC534.1 PR517.2 PU500.8
N16336072: PC533.1 PR513.2 PU500.7
N16336110: PR522.2 PR525.1 PU500.9
N16336166: PR521.2 PU500.10
N16336190: PR531.2 PU500.15
N16336228: PR526.1 PU500.18
N16336338: PC528.2 PQ512.1 PR505.2 PR506.2 PR541.2 PU500.6
N16336480: PR523.1 PU500.21
N16337211: PC530.1 PC531.1 PC532.1 PQ503.1 PQ503.2 PQ503.3 PR511.4 PR515.1
N16337658: PQ500.1 PQ500.2 PQ500.3 PQ502.1 PQ502.2 PQ502.3 PR518.1 PR519.1
N16337829: PC539.1 PQ502.4 PR524.1
N16338400: PQ504.2 PQ505.1 PR519.2 PR527.1 PR528.1
N16338670: PQ500.4 PR520.1
N16338676: PR518.2 PR520.2 PR524.2 PR536.1
N16339095: PD502.2 PQ506.3
N16339107: PQ506.1 PR528.2
N16355483: PQ509.1 PQ509.2 PQ509.3 PQ510.1 PQ510.2 PQ510.3 PR534.1
N16355542: PC544.1 PQ509.4 PR537.1
N16355618: PQ511.1 PR534.2 PR537.2 PR538.1
N16355677: PD503.2 PQ511.3
N16355838: PQ510.4 PR538.2
N16356132: PR539.2 PR540.1 PR547.1 PR548.1
N16369124: PQ202.2 PU200.4
N16777906: C156.1 U21.11
N16777910: C156.2 U21.9
N16784816: Q5.6 R29.2 R30.2
N16784922: CA67.1 CA68.1 R389.1 RA57.2 RA59.2
N17205976: JDEG1.1 R317.2
N17240153: R160.1 U20.8 U20.9
N17240183: C146.1 U20.10
N17242608: R98.1 U7.8 U7.9
N17242618: C104.1 U7.10
N17243834: R93.1 U12.13 U12.14
N17243850: C97.1 U12.12
N17302212: C163.1 U22.12
N17302218: R183.1 U22.13 U22.14
N17303773: R115.1 U12.8 U12.9
N17303797: C106.1 U12.10
N17544228: CA28.1 UA2.19
N17544867: CA16.1 UA2.2
N17545095: CA32.1 UA2.28
N17545649: RA39.2 UA2.30
N17587387: LA9.1 UA2.39
N17587389: LA8.1 UA2.40
N17587465: LA6.1 UA2.45
N17587467: LA4.1 UA2.46
N18800960: RA18.1 UA3.10
N18930710: PC1120.2 PR1127.1
N18930749: PC1119.2 PR1126.1
N18963961: PC1125.2 PR1137.1
N18964596: PC1122.1 PR1132.2
N18975678: PH1101.1 PR1141.2
N19013762: PC1149.1 PR1149.2
N19014058: PC1150.1 PR1150.2
N19043300: PQ1100.1 PU1100.1
N19043343: PR1103.1 PU1100.2
N19063627: PC1126.1 PR1138.2
N19378285: JNGFF1.51 T3.1(TP-1)
N19378292: JNGFF1.53 T4.1(TP-1)
N19378299: JNGFF1.55 T7.1(TP-1)
N19378306: JNGFF1.57 T6.1(TP-1)
N19388147: RH26.1 UC1.BA15
N19643413: R432.1 U46.7 U46.8
N19643415: C318.1 U46.6
N20063017: Q6.1 R68.1
N20421956: PC403.2 PQ400.2 PR400.2 PR402.1
N20422037: PR402.2 PU400.16
N20422092: PC412.1 PU400.6
N20422143: PC404.1 PD401.1 PL1105.1 PQ400.1
N20422163: PC410.1 PR404.2 PU400.3
N20422204: PC407.1 PR401.2
N20422218: PR408.1 PU400.5
N20604762: R171.2 UH2.1
N20604774: R176.2 R186.2 UH2.2
N21063245: R26.1 U2.27
N21234656: R165.1 U22.8 U22.9
N21235869: R438.1 U50.8 U50.9
N21436900: JNGFF2.68 R409.1
N21485395: PC122.1 PR136.1 PU101.5
N21485499: PC123.1 PQ112.1 PR132.2 PR134.1 PU101.4
N21528803: PC116.2 PQ104.4 PR116.2 PR122.1
N21534226: PC538.1 PR514.2
N21616168: PR817.2 PR820.1 PR823.1 PR831.2 PU801.4
N21616317: PC811.1 PR816.2
N21618504: PC603.2 PL601.1 PR604.1 PU600.7
N21618541: PC611.1 PR604.2
N21620615: PR606.2 PU600.12
N21622450: PR603.1 PU600.8
N21622453: PC603.1 PR603.2
N21624147: PC615.2 PL603.1 PR609.1 PU601.7
N21624161: PC614.1 PR609.2
N21624470: PC635.1 PR618.2 PU601.9
N21624512: PC615.1 PR617.2
N21624514: PR617.1 PU601.8
N21628470: PC704.1 PR703.2
N21628480: PC705.2 PL701.1 PR703.1 PU700.9
N21628490: PC720.2 PR704.2 PR706.1 PU700.13
N21628589: PC700.1 PC702.1 PC703.1 PL700.2 PU700.1
N21630461: PC719.1 PR712.2 PR722.1 PU700.3
N21632067: PC715.1 PU700.7
N21636274: PC1001.1 PL1000.2 PU1000.3
N21636311: PC1005.1 PR1003.2
N21637474: PR711.1 PU700.10
N21637478: PC705.1 PR711.2
N21669783: PQ105.1 PR122.2
N21685380: R240.1 US1.7 US1.8
N21685485: R249.1 US1.16
N21700377: PC920.1 PR912.2
N21700486: PR914.2 PR922.1 PU901.8
N21703150: PC118.1 PR125.2 PR126.1 PU100.6
N21703157: PC119.1 PR121.2 PR127.1 PR138.1 PU100.5
N21708061: PR822.2 PR825.2 PR826.1 PU808.9
N21768495: PC120.1 PQ107.2 PR128.1 PR129.1
N21768525: PQ108.2 PQ109.5 PR131.2 PR133.2
N21768527: PQ109.6 PR133.1
N21768616: PC114.2 PQ109.2 PR130.2
N21768629: PQ109.3 PR129.2
N21778821: PR1121.2 PU1101.E6
N21803574: R425.1 U43.1
N21803687: R417.1 U41.8
N21803688: C301.2 R417.2 R421.1 U41.9
N21803690: R410.1 U41.7
N21803695: C301.1 U41.1
N21976735: R209.1 U25.18
N22181898: R174.1 U17.7 U17.8
N22181900: C166.1 U17.6
N22436994: R250.1 U32.F2
N22437505: R256.1 U32.F1
N22440570: R298.1 U32.E11
N22441485: C203.1 U32.H7
N22441497: R297.1 R484.1 R496.1 U32.F10
N22441511: R258.1 U32.G2
N22442963: R301.2 TC23.1(TP-1)
N22443085: R257.2 TC19.1(TP-1)
N22450757: C113.2 R114.2
N22450864: C94.1 R99.2
N22451929: R110.1 U6.B7
N22451931: R57.1 U6.H4
N22451933: R89.1 U6.D7
N22452420: R109.1 U6.C7
N22452424: R117.1 U6.A6
N22483897: C61.2 R50.2 R65.1 U9.2
N22483924: R59.1 U9.1
N22734897: R108.1 U7.13 U7.14
N22869055: TC4.1(TP-1) UC1.U12
N22869056: TC6.1(TP-1) UC1.U8
N22869057: TC45.1(TP-1) UC1.V3
N22869058: TC5.1(TP-1) UC1.V11
N22873097: R412.2 U45.2
N22924832: R15.1 U3.7 U3.8
N22924834: C12.1 U3.6
N23227151: PR807.2 PR827.2 PR828.1 PU808.8
N23229153: PR920.2 PR921.1 PU901.9
N23229941: PC1501.1 PR1006.2
N23234515: PC1121.2 PR1129.1
N23244273: RC68.1 UC1.AA26 UC1.AC26
N23256891: R392.1 U35.B11
N23436283: R178.1 U24.4
N23436874: R170.1 U23.4
N23552678: JXDP1.9 RC127.2
N23877759: Q8.2 R84.1 R95.2 R480.2 R481.2
N23878175: Q8.5 R84.2 R87.1 R94.2
N23878217: Q8.6 R87.2
N23948092: CV24.1 UV2.2
N23948138: RV22.1 UV2.7
N23949763: R235.1 U27.7
N24004976: PR156.2 PU150.2 PU151.2
N24005002: PQ151.1 PR152.2 PU151.3
N24005016: PR152.1 PR157.2 PU150.3
N24005089: PC150.1 PR154.2 PU150.7
N24005136: PQ150.2 PR153.1 PU150.5 PU151.5
N24005175: PC151.1 PR155.2 PU151.7
N24036540: R231.2 U27.5
N24036598: R242.2 UV2.26
N24116145: R69.2 U6.C1
N24124597: PC823.1 PQ800.2 PR824.2 PR829.2 PR830.1
N24124612: PQ800.1 PR823.2
N24228571: R445.1 U50.13 U50.14
N24309746: Q15.1 R400.2
N24314377: T22.1(TP-1) UC1.BD6
N24314941: TC7.1(TP-1) UC1.P11
N24394551: JHDMI1.15 RX3.2
N24397508: C23.1 U1.1
N24402677: TC17.1(TP-1) U32.G4
N24402691: TC18.1(TP-1) U32.F4
N24403083: R250.2 U32.E2
N24433868: R187.1 U18.13 U18.14
N24433875: R192.1 U18.8 U18.9
N24433899: C171.1 U18.12
N24433917: C170.1 U18.10
N24468854: TC22.1(TP-1) U32.K4
N24544896: PC901.2 PL901.1 PR904.1 PU900.7
N24544907: PC911.1 PR904.2
N24545121: PR911.2 PU900.12
N24545155: PC915.1 PR905.2 PU900.9
N24545187: PR903.1 PU900.8
N24545189: PC901.1 PR903.2
N24580839: TC81.1(TP-1) UC1.AE12
N24700151: PC1108.1 PR1103.2
N24707410: PC1123.2 PR1134.1
N24707520: PC1124.1 PR1135.2
N24907719: PC1115.1 PR1120.2
N24910627: PC1131.1 PR1147.2
N24919089: PC1132.1 PR1148.2
N25217210: PC630.1 PU600.9
N25374813: JUSH1.17 R193.2
N25375076: JUSH1.2 R189.2
N25377540: C342.1 UV3.6
N25410508: PQ1500.1 PR1501.2 PU1500.3
N25410589: PD1500.1 PR1501.1 PR1502.1 PR1503.1 PU1500.8
N25410601: PC1500.1 PR1503.2 PU1500.7
N25410879: PR1502.2 PU1500.2
N25411106: PQ1500.2 PR1500.2 PR1504.1
N25438298: RC27.1 TC9.1(TP-1)
N25438312: RC28.1 TC8.1(TP-1)
N25438359: RC30.1 TC11.1(TP-1)
N25438360: RC32.1 TC12.1(TP-1)
N25438361: RC25.1 TC10.1(TP-1)
N25438362: RC31.1 TC13.1(TP-1)
N25610586: DA7.1 RA54.1
N25857439: QT1.2 R238.2
N25857459: QT1.1 R247.2 R259.2
N25860632: PQ504.1 PR536.2
N25863019: R53.1 U5.4
N25865128: PQ150.5 PQ150.6 PR158.2
N25920196: PC1110.1 PR1109.2
N25958709: PR718.1 PU700.14
N25961580: PQ1502.5 PR1413.2 PR1416.2 PU1501.7
N25961582: PC1408.1 PR1416.1 PR1419.2 PR1425.1 PU1501.5
N25961915: PQ1502.4 PR1417.2 PR1421.2 PU1501.1
N25961992: PQ1502.3 PR1424.2 PU1404.1
N25961994: PU1403.4 PU1404.2
N25962000: PC1411.2 PR1420.1 PU1403.1 PU1403.2
N25962026: PC1415.1 PR1414.1 PR1417.1 PR1418.2 PU1501.3
N25962054: PC1411.1 PQ1501.2 PU1404.4
N25991293: TC84.1(TP-1) UC1.AW6
N25991324: TC38.1(TP-1) UC1.BD4
N26073159: JWFC.28 R45.2
N26074196: JUFC.39 R62.2
N26142017: TC82.1(TP-1) UC1.AV9
N26188269: PQ512.2 PQ513.1 PR542.2 PR545.1
N26188538: PD505.1 PD506.1 PQ513.2 PR543.1
N26388185: TC34.1(TP-1) UC1.BJ6
N26390068: Q18.2 U38.4
N26391418: Q18.1 R406.2
N26425179: R103.2 U5.2
N26519107: R163.2 UV1.26
N26559031: PQ106.5 PQ106.6 PR137.2
N26666068: DA5.1 JHP1.5 RA45.2
N26874176: D35.2 R325.2
N26874221: D35.3 R333.2
N26878757: RA15.2 UA3.40
N26920051: LED1.2 R411.2
N26920096: LED1.1 Q16.1
N26961307: PC1118.1 PR1118.2
N26963152: PC1103.1 PR1102.2
N26965088: PH1102.1 PR1142.2
N27328203: R471.2 U51.4
N27718925: PD505.2 PR546.2 PR550.1
N28606576: TC78.1(TP-1) UC1.BA17
N29359678: PC816.2 PR831.1
N29853050: PH1100.1 PR1116.2
N30221004: C369.2 Q22.2 R513.2 R514.1
N30221093: Q23.1 R514.2
N30221403: C369.1 Q22.3 R511.2 R513.1
N30221460: Q23.2 R515.2
N30221480: Q22.1 R512.1
N42233415: JNGFF3.50 R121.1
N44370994: C145.1 U20.12
N45346942: C159.1 U22.10
N50930159: RV13.1 UV1.7
N51581707: R217.1 U26.7 U26.8
N51581718: C189.1 U26.6
N51584481: R161.1 U20.13 U20.14
N51592314: Q9.1 R58.1
N51600655: R149.1 U15.13 U15.14
N51600691: R142.1 U15.8 U15.9
N51600744: C137.1 U15.12
N51600766: C136.1 U15.10
N53869491: C261.1 R356.2
N54227584: R365.1 U33.E2
N54227586: R341.1 U33.B11
N54714783: R367.1 U35.E2
N55958256: CA40.1 CA46.1 UA3.43
N55958521: CA58.1 CA65.1 UA3.21
N55958533: CA37.1 UA3.44
N55958539: CA41.1 UA3.41
N55958618: CA43.1 LA11.2 UA3.46
N55958653: CA45.1 LA12.2 UA3.51
N56067860: CA57.1 CA61.1 UA3.18
N56068412: CA64.1 UA3.29
N56068450: CA53.1 UA3.31
N56068743: CA55.1 UA3.25
N56068745: CA55.2 UA3.26
N56068751: CA54.2 UA3.28
N56068753: CA54.1 UA3.27
N56194338: C124.2 R125.1
N56194376: C86.2 R102.1
N56194392: C76.2 R77.1
N57436918: R116.1 U13.7 U13.8
N57436928: C98.1 U13.6
N57439320: C325.1 U50.12
N57439346: C326.1 U50.10
N57468046: R441.1 U48.6
N57468968: R442.1 U49.6
N57645414: C109.1 U7.12
N118179758: PC807.1 PR805.2
N125160725: TC80.1(TP-1) UC1.AG10
N125160734: TC79.1(TP-1) UC1.AH9
N125162616: TC83.1(TP-1) UC1.BB10
N125184377: CC5.1 UC1.AT18 UC1.AV18
N125185663: TC68.1(TP-1) UC1.B4
N125185665: TC69.1(TP-1) UC1.B3
N125185667: TC53.1(TP-1) UC1.F3
N125185669: TC62.1(TP-1) UC1.F1
N125185671: TC57.1(TP-1) UC1.L36
N125185842: TC66.1(TP-1) UC1.D49
N125185844: TC59.1(TP-1) UC1.M21
N125185848: TC67.1(TP-1) UC1.M19
N125185850: TC76.1(TP-1) UC1.L26
N125185953: TC40.1(TP-1) UC1.BL64
N125186153: TC58.1(TP-1) UC1.R12
N125186155: TC46.1(TP-1) UC1.P13
N125186157: TC70.1(TP-1) UC1.M15
N125186159: TC71.1(TP-1) UC1.L16
N125186161: TC73.1(TP-1) UC1.L18
N125186163: TC60.1(TP-1) UC1.M17
N125186165: TC72.1(TP-1) UC1.K12
N125186167: TC63.1(TP-1) UC1.H12
N125186171: TC31.1(TP-1) UC1.BN3
N125186173: TC32.1(TP-1) UC1.BP3
N125186177: TC54.1(TP-1) UC1.M23
N125186179: TC3.1(TP-1) UC1.AY20
N125186183: TC33.1(TP-1) UC1.BN1
N125186366: RC37.1 UC1.BB14
N125186425: TC75.1(TP-1) UC1.L28
N125186427: TC77.1(TP-1) UC1.M27
N125186463: TC30.1(TP-1) UC1.BJ17
N126490868: Q7.2 Q7.3 R28.1
N126490934: Q7.1 RH11.1
N126505111: RC72.1 RH108.2 U45.4
N126538537: RH107.1 TC55.1(TP-1)

Pads without a net: DA7 3; FD1 1; FD2 1; FD3 1; FD4 1; JAPS2 1 2 3; JEDP1 1 5 9 13 31 38 43 45; JHDMI1 2; JIO4 39; JNGFF1 10 12 14 16 20 30 33 35 39 41 44 45 47 48 50; JNGFF2 5 6 7 8 10 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JNGFF3 6 16 17 19 20 21 22 25 26 27 28 31 32 34 59 61 65 66 67 68 70 71 73; JPWR2 2; JSPI1 17; JTS1 1; JUFC 4 13 17 21 35 36 37 38; JWFC 3 7 11 15 19 22; JXDP1 45; PD101 3; PQ1501 3 4 5; PQ1502 1 2 6; PU100 1 2 3; PU101 3; PU500 4 13 14; PU600 4; PU601 4; PU900 4; PU1000 5; Q5 3 4 5; QT1 3 4 5; R511 1; R512 2; R515 1; U1 4; U2 2 4 5 6 7 10 11 12 15 25 26 28 30 31; U5 1; U6 C2 C3 D3 D4 E1 E2 E3 E5 E6 F1 F2 F3 G1 G2 G3 H1 H3; U9 3 6 7; U16 9; U25 8 13 36; U27 14 24; U32 A9 B9 F11; U33 A1 A17 C11 D8 D11 E3 E4 H4 J12 M9 U1 U17; U35 A1 A17 C11 D8 D11 E3 E4 H4 J12 M9 U1 U17; U38 1; U39 9; U43 3; U44 1; U45 1; U47 4 14; U51 1; U52 1; UA2 1 27 29 31 32 33 34 35 36 37 48; UA3 47 48 49 50; UC1 A22 A24 A30 A32 A38 AH7 AM9 AN8 AP5 AT7 AY18 AY22 B19 B21 B23 B29 B31 B33 B37 B39 BA19 BA21 BA23 BB18 BB63 BC5 BC19 BD18 BD30 BD34 BE19 BF18 BG47 BG57 BJ15 BJ31 BK14 BK34 BL12 BL17 BL57 BM56 BP11 C22 C24 C30 C32 C38 D19 D21 D23 D29 D31 D33 D37 D39 F19 F21 F23 F35 F39 F43 G22 G24 G46 H19 H21 H23 H35 H39 H43 J22 J24 J46 L20 L22 L24 L38 M25 V5; UC2 1; US1 9 15; UV1 15 21 37 43 46; UV2 8 15 21 33 34 37 43 46

## Via types
v1: diameter 0.254, hole 0.102, TOP to IN1, 1530 vias
v2: diameter 0.406, hole 0.203, GND1 to GND3, 2074 vias
v3: diameter 0.254, hole 0.102, IN3 to IN4, 538 vias
v4: diameter 0.254, hole 0.102, IN4 to BOTTOM, 726 vias
v5: diameter 0.22, hole 0.102, IN4 to BOTTOM, 590 vias
v6: diameter 0.22, hole 0.102, IN3 to IN4, 107 vias
v7: diameter 0.254, hole 0.102, IN3 to BOTTOM, 1438 vias
v8: diameter 0.254, hole 0.102, GND3 to IN4, 130 vias
v9: diameter 0.254, hole 0.102, TOP to GND1, 2785 vias
v10: diameter 0.22, hole 0.102, IN3 to BOTTOM, 545 vias
v11: diameter 0.254, hole 0.102, GND1 to IN1, 69 vias
v12: diameter 0.22, hole 0.102, GND3 to BOTTOM, 490 vias
v13: diameter 0.457, hole 0.203, TOP to BOTTOM, 713 vias
v14: diameter 0.305, hole 0.152, TOP to BOTTOM, 92 vias
v15: diameter 0.254, hole 0.102, GND3 to BOTTOM, 1959 vias
v16: diameter 0.406, hole 0.203, TOP to BOTTOM, 49 vias
v17: diameter 0.508, hole 0.254, TOP to BOTTOM, 6 vias
v18: diameter 0.254, hole 0.102, TOP to VCC, 386 vias
v19: diameter 0.254, hole 0.102, VCC to GND1, 49 vias
v20: diameter 0.22, hole 0.102, VCC to IN1, 7 vias
v21: diameter 0.254, hole 0.102, VCC to IN1, 291 vias
v22: diameter 0.22, hole 0.102, IN3 to GND3, 211 vias
v23: diameter 0.254, hole 0.102, IN3 to GND3, 1 via

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.85V_VCCIO_PG: length 3.8
  TOP w0.254: R35.2 PR806.1 41.81,135.27 41.12,135.96 40.61,135.96 40.26,136.3 40.26,136.67 PU808.4
0.85VS_MODE: length 2.9
  TOP w0.254: PC808.1 42.32,140.58 PR809.1 41.83,139.2 41.83,138.81 41.49,138.47 PU808.7
0.95VCC_SENSE_R: length 1.6
  TOP w0.254: PU901.5 171.54,104.73 PR917.1
0.95VSS_SENSE_R: length 1.7
  TOP w0.254: PU901.6 173.03,104.23 172.32,104.23 172.04,103.96 PR918.1
1.0V_PRIM_PG:
  vias: v4(172.69,120.31) v4(172.97,120.31) v4(174.29,116.58) v4(174.57,116.58)
