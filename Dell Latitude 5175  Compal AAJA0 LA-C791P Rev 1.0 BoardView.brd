# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQS_DN_5: length 25.3
  IN3 w0.06: 76.83,125.63 76.83,125.37 76.79,125.34 76.79,125.22 75.87,124.3 75.87,123.76 75.4,123.28 v10(75.4,122.52)
  IN3 w0.091: 76.83,125.63 76.83,126.68 76.96,126.81 77.22,126.81 77.38,126.98 77.38,127.23 77.48,127.33 77.71,127.33 77.78,127.33 78,127.55 78,127.66 78,127.66 78,127.85 83.92,133.77 84.23,133.77 84.5,133.5 84.92,133.5 85.09,133.66 85.09,133.8 85.17,133.87 85.6,133.87 85.7,133.77 85.7,133.68 85.89,133.5 86.52,133.5 86.66,133.64 86.66,133.8 86.74,133.87 87.31,133.87 87.42,133.76 87.42,133.56 87.61,133.37 88.2,133.37 88.37,133.54 88.67,133.54 88.76,133.45 88.76,133.26 88.93,133.09 89.29,133.09 89.37,133.01 89.37,132.92 89.32,132.88 89.32,132.77 89.43,132.66 89.54,132.66 89.56,132.68 89.67,132.68 89.77,132.58 89.77,132.48 89.7,132.41 89.7,132.29 89.79,132.19 89.93,132.19 89.94,132.21 90.11,132.21 90.21,132.1 90.21,131.45 90.15,131.39 90.15,131.18 90.39,130.94 v10(90.39,130.79)
M_A_DQS_DN_6: length 15.2
  IN3 w0.091: v10(86.39,130.79) 86.56,130.79 86.61,130.85 86.61,130.98 86.55,131.04 86.2,131.04 86.11,130.94 86.11,130.49 85.88,130.27 84.35,130.27 84.24,130.17 v6(84.24,130.05)
  IN4 w0.06: v5(76.68,124) 76.68,124 76.68,124.4 76.85,124.56 76.96,124.56 77.4,125 77.4,125.48 77.92,126 79.35,126 79.37,126.02
  IN4 w0.069: 79.37,126.02 80.19,126.02 81.74,127.58 81.96,127.58 82.12,127.73 82.12,128.31 81.91,128.51 81.91,128.95 82.1,129.14 82.83,129.14 83.61,129.92 83.83,129.92 84.07,130.16 84.13,130.16 v6(84.24,130.05)
M_A_DQS_DN_7: length 22.8
  IN3 w0.091: v10(88.89,129.79) 88.89,129.8 88.72,129.97 88.19,129.97 87.89,130.27 87.89,131.58 87.83,131.64 87.83,132.21 v6(87.76,132.28)
  IN4 w0.06: 77.23,127.09 77.23,127.04 75.51,125.32 75.51,124.2 75.52,124.19 75.52,124.16 75.62,124.06 75.62,123.93 75.4,123.71 v5(75.4,123.5)
  IN4 w0.069: v6(87.76,132.28) 87.83,132.35 87.83,132.6 87.3,133.14 84.08,133.14 83.18,132.25 82.42,131.48 82.06,131.48 80.53,129.95 80.53,128.42 79.6,127.5 78.86,127.5 78.59,127.77 78.59,127.96 78.51,128.03 78.18,128.03 77.23,127.09
M_A_DQS_DP_0: length 28.4
  IN3 w0.091: v6(93.9,127.45) 93.75,127.45 93.55,127.24 92.86,127.24 92.37,127.73 91.74,127.73 91.46,127.45 91.31,127.45 91.24,127.52 91.24,127.66 91.37,127.79 v10(91.39,127.79)
  IN4 w0.06: 79.93,117.57 79.93,117.58 79,117.58 v5(78.96,117.62)
  IN4 w0.069: v6(93.9,127.45) 93.9,127.31 94.04,127.17 94.04,127.08 94.08,127.04 94.26,127.04 94.39,127.17 94.82,127.17 95.12,126.86 95.12,121.8 93.78,120.46 93.78,120.46 91.87,120.46 91.69,120.28 91.69,119.88 90.23,118.41 85.01,118.41 84.47,117.87 83.39,117.87 83.39,117.87 83.29,117.87 83.29,117.87 81.06,117.87 80.76,117.57 79.93,117.57
M_A_DQS_DP_1: length 19.7
  IN4 w0.06: 80.23,119.39 80.08,119.39 80.02,119.45 79.68,119.45 79.63,119.4 79.63,119.22 79.52,119.11 78.95,119.11 78.88,119.11 78.86,119.09 78.86,119.09 78.8,119.03 78.8,119.03 78.63,119.03 78.55,119.11 78.34,119.11 v5(78.22,119.23)
  IN4 w0.069: 80.23,119.39 80.24,119.39 81.74,119.39 81.86,119.52 81.86,119.67 81.92,119.73 81.99,119.73 82.09,119.63 82.09,119.52 82.24,119.37 84,119.37 84.34,119.71 88.95,119.71 91.71,122.47 91.71,123.27 91.8,123.35 92.11,123.35 92.2,123.26 92.52,123.26 92.8,123.54 92.8,124.87 92.64,125.03 92.46,125.03 92.39,125.1 v5(92.39,125.29)
M_A_DQS_DP_2: length 25.3
  IN3 w0.06: v10(77.73,119.23) 79.64,119.23
  IN3 w0.091: 79.64,119.23 81.72,119.23 81.94,119.45 88.07,119.45 90.74,122.11 91.36,122.11 91.44,122.19 91.44,122.3 91.33,122.42 91.33,122.54 91.33,122.7 91.37,122.74 91.52,122.89 91.76,122.89 91.96,122.68 92.03,122.68 v6(92.17,122.82)
  IN4 w0.069: v5(91.39,126.79) 91.56,126.79 91.67,126.69 91.67,126.19 91.8,126.05 92.02,126.05 92.15,126.18 92.15,126.41 92.28,126.54 92.53,126.54 92.67,126.4 92.67,126.14 92.79,126.01 92.87,126.01 92.93,126.07 93.34,126.07 93.46,125.95 93.46,125.87 93.38,125.79 93.04,125.79 92.96,125.71 92.96,125.56 93.04,125.49 93.38,125.49 93.46,125.41 93.46,125.28 93.14,124.96 93.14,123.06 93.14,122.78 92.88,122.52 92.66,122.52 92.48,122.7 92.29,122.7 v6(92.17,122.82)
M_A_DQS_DP_3: length 29.4
  IN3 w0.06: v10(76.99,117.62) 77.2,117.62 77.28,117.54 77.4,117.42 77.57,117.42 77.64,117.49 77.64,117.5 77.81,117.5 77.82,117.48 77.87,117.48 77.88,117.49 77.92,117.49
  IN3 w0.091: v10(92.39,129.29) 92.4,129.3 93.94,129.3 95.02,128.22 95.02,126.9 95.2,126.72 95.2,122.49 92.71,120.01 91.33,120.01 88.94,117.62 83.08,117.62 82.88,117.41 79.8,117.41 79.73,117.49 77.92,117.49
M_A_DQS_DP_4: length 21.2
  IN3 w0.06: v10(76.68,122.52) 76.68,122.9 76.69,122.91 78.13,124.35 78.29,124.51 78.39,124.61 78.39,125.73 79.55,126.89
  IN3 w0.091: 79.55,126.89 81.7,129.04 82.07,129.04 82.14,129.12 82.14,129.29 82.28,129.43 83.16,129.43 83.25,129.52 83.25,129.65 83.17,129.73 82.87,129.73 82.7,129.9 82.7,130.23 82.7,130.23 82.7,130.35 82.87,130.52 82.97,130.52 82.97,130.52 83.1,130.52 83.19,130.43 83.32,130.43 83.39,130.5 83.39,131.09 83.49,131.19 v6(83.96,131.19)
  IN4 w0.069: v6(83.96,131.19) 83.95,131.19 83.83,131.32 83.83,131.52 84.01,131.71 84.44,132.14 86.37,132.14 86.67,131.84 86.67,131.68 86.67,130.7 86.8,130.57 86.8,130.57 86.82,130.55 87.05,130.55 87.17,130.43 87.17,129.68 87.32,129.53 87.53,129.53 87.64,129.65 87.64,130.04 v5(87.89,130.29)
M_A_DQS_DP_5: length 25.3
  IN3 w0.06: 76.67,125.43 76.67,125.39 76.67,125.39 76.67,125.27 75.75,124.35 75.75,123.81 75.28,123.33 75.28,122.68 75.2,122.6 75.2,122.44 75.27,122.36 75.27,122.15 v10(75.4,122.03)
  IN3 w0.091: 76.67,125.43 76.67,125.56 76.67,125.56 76.67,126.74 76.9,126.96 77.15,126.96 77.23,127.04 77.23,127.29 77.27,127.34 77.41,127.48 77.72,127.48 77.85,127.61 77.85,127.92 77.9,127.96 78.49,128.56 78.55,128.62 83.86,133.92 84.29,133.92 84.56,133.65 84.86,133.65 84.94,133.73 84.94,133.86 85.1,134.03 85.66,134.03 85.85,133.83 85.85,133.75 85.95,133.65 86.46,133.65 86.51,133.7 86.51,133.86 86.68,134.03 87.38,134.03 87.57,133.83 87.57,133.62 87.67,133.52 88.13,133.52 88.3,133.69 88.74,133.69 88.91,133.51 88.91,133.32 88.99,133.24 89.35,133.24 89.52,133.07 89.52,133.05 89.92,132.65 89.92,132.61 90.37,132.17 90.37,131.49 90.43,131.43 90.43,131.33 v10(90.39,131.29)
M_A_DQS_DP_6: length 15.2
  IN3 w0.091: v10(86.39,131.29) 86.24,131.29 85.96,131.01 85.96,130.56 85.82,130.42 84.29,130.42 84.01,130.15 84.01,129.75 83.98,129.72 v6(83.97,129.72)
  IN4 w0.06: 79.41,125.89 79.4,125.88 77.97,125.88 77.52,125.43 77.52,124.95 77.01,124.44 76.98,124.44 76.92,124.44 76.81,124.33 76.81,124.16 76.86,124.11 76.86,124.1 76.88,124.08 76.88,123.91 76.68,123.71 v5(76.68,123.5)
  IN4 w0.069: v6(83.97,129.72) 83.93,129.77 83.64,129.77 82.89,129.01 82.16,129.01 82.14,129 82.04,128.9 82.04,128.56 82.24,128.36 82.24,127.68 82.02,127.45 81.79,127.45 80.24,125.9 79.41,125.9 79.41,125.89
M_A_DQS_DP_7: length 22.7
  IN3 w0.091: v6(88.15,132.22) 87.99,132.05 87.99,131.7 88.04,131.65 88.04,130.87 88.1,130.82 88.15,130.82 88.22,130.74 88.22,130.59 88.15,130.52 88.09,130.52 88.04,130.48 88.04,130.33 88.26,130.12 88.72,130.12 v10(88.89,130.29)
  IN4 w0.06: 77.09,127.13 77.09,127.07 75.4,125.37 v5(75.4,124)
  IN4 w0.069: v6(88.15,132.22) 88.13,132.22 87.96,132.39 87.96,132.66 87.35,133.27 84.02,133.27 83.18,132.43 82.36,131.61 82,131.61 80.4,130 80.4,128.48 79.55,127.63 78.92,127.63 78.72,127.83 78.72,128.01 78.56,128.16 78.12,128.16 77.95,127.99 77.09,127.13
M_A_ODT0: length 25.1
  IN4 w0.061: v5(88.39,129.79) 88.43,129.79 89.02,129.21 89.02,129.1 88.7,128.78 88.7,128.67 88.79,128.58 88.93,128.58 89.23,128.88 89.34,128.88 89.48,128.75 89.48,128.38 ; 89.48,128.38 89.39,128.29 89.39,127.46 89.26,127.33 88.94,127.33 88.77,127.5 87.73,128.54 86.76,128.54 86.63,128.67 86.63,128.88 86.49,129.02 86.27,129.02 86.14,128.9 86.14,128.68 86,128.54 85.18,128.54 84.66,128.02 84.66,127.81 84.28,127.42 84.28,127.33 84.66,126.95 84.66,126.84 84.55,126.74 84.44,126.74 83.96,127.22 83.86,127.22 83.75,127.11 83.75,127 84.28,126.47 84.28,126.36 84.2,126.28 84.04,126.28 83.53,126.78 83.42,126.78 82.63,125.99 82.63,125.42 81.9,124.69 81.69,124.69 81.61,124.77 81.61,125.14 81.53,125.21 81.37,125.21 81.3,125.14 81.3,124.75 81.24,124.69 80.68,124.69 80.44,124.45 78.69,124.45 78.6,124.36 78.6,124.36 78.49,124.26 78.37,124.13 v5(78.37,124.09) ; 89.48,128.38 89.85,128.38 90.04,128.18 90.04,128.07 89.74,127.77 89.74,127.66 89.84,127.55 89.95,127.55 90.26,127.86 90.37,127.86 90.89,127.33 v5(90.89,127.29)
M_B_CA_0_0: length 17.7
  IN3 w0.076: v10(69.28,133.78) 69.28,133.88 69.15,134.01 69.04,134.01 68.96,133.94 68.96,133.52 68.89,133.45 68.73,133.45 68.66,133.52 68.66,133.95 68.58,134.03 68.43,134.03 68.35,133.95 68.35,133.07 68.25,132.96 68.1,132.96 68.02,133.04 68.02,133.95 67.95,134.03 67.54,134.03 67.32,133.81 67.32,133.23 67.66,132.9 67.66,132.64 67.59,132.57 67.39,132.37 67.39,131.84 67.57,131.66 67.57,131.41 67.27,131.11 67.07,130.91 67.07,130.57 67.16,130.47 67.16,129.82 67.13,129.79 67.13,128.8 67.19,128.75 v6(67.19,128.72)
  IN4 w0.06: v5(68.95,123.5) 68.82,123.64 68.82,123.84 68.76,123.9 68.76,123.91 68.75,123.91 68.75,124.08 68.76,124.08 68.76,124.35 68.84,124.43 68.84,124.96 68.81,124.98 68.81,125.11
  IN4 w0.061: 68.81,125.11 68.54,125.38 68.54,125.38 67.42,126.5 67.42,126.58 67.31,126.69 67.31,127.24 67.11,127.44 67.11,128 67.24,128.13 67.34,128.13 67.41,128.2 67.41,128.36 67.34,128.43 67.02,128.43 66.93,128.52 66.93,128.65 66.99,128.72 v6(67.19,128.72)
M_B_CA_0_1: length 17.3
  IN3 w0.076: v6(68.59,131.08) 68.43,130.93 68.43,130.35 68.25,130.17 68.25,129.64 68.38,129.51 68.38,129 68.43,128.94 68.58,128.94 68.62,128.98 68.73,128.98 68.79,128.92 68.79,128.75 68.71,128.67 68.25,128.67 68.17,128.59 68.17,128.44 68.21,128.41 68.57,128.41 68.65,128.32 68.65,128.25 68.6,128.19 67.98,128.19 67.9,128.27 67.9,128.49 v6(67.95,128.54)
  IN4 w0.06: v5(69.28,124.24) 69.29,124.26 69.29,125.21 67.84,126.66
  IN4 w0.061: v6(68.59,131.08) 68.99,131.08 69.52,131.61 69.52,132.4 69.37,132.55 69.19,132.55 69.19,132.56 69.14,132.56 68.89,132.81 68.89,133.01 68.99,133.12 69.13,133.12 69.19,133.05 69.35,133.05 69.52,132.89 69.52,132.71 69.67,132.56 69.69,132.56 69.69,132.55 69.88,132.55 69.88,132.56 69.92,132.56 70.03,132.66 70.03,133.4 69.9,133.53 68.78,133.53 68.73,133.58 68.73,133.72 v5(68.78,133.78) ; 67.84,126.66 67.84,127.51 67.98,127.64 67.98,128.51 v6(67.95,128.54)
M_B_CA_0_2: length 18
  IN3 w0.076: v6(68.89,131.41) 68.82,131.34 68.61,131.34 68.51,131.43 68.51,131.75 68.45,131.81 68.45,131.9 68.53,131.97 68.75,131.97 68.97,131.74 69.06,131.74 69.22,131.59 69.22,131.18 69.14,131.1 68.89,131.1 68.81,131.02 68.81,130.87 68.89,130.8 69.14,130.8 69.22,130.72 69.22,130.4 68.98,130.16 v6(68.89,130.16)
  IN4 w0.06: 68.35,129.78 68.35,129.22 68.38,129.19 68.38,128.15 68.41,128.11 68.41,128.1 68.76,127.76 68.76,126.87 68.55,126.66 68.55,126.4 68.75,126.2 68.81,126.2 69.57,125.44 69.57,124.66 69.6,124.63 69.6,124.38 69.6,124.38 69.6,124.11 69.6,124 v5(69.6,124)
  IN4 w0.061: v5(68.28,133.78) 68.28,133.96 68.53,134.21 68.53,134.46 68.62,134.55 68.92,134.55 69.04,134.44 69.04,134.21 69.06,134.19 69.06,134.19 69.12,134.12 69.12,133.99 69.07,133.93 68.96,133.93 68.89,134 68.66,134 68.58,133.93 68.58,133.37 68.51,133.3 68.51,133.21 68.72,133 68.72,132.7 69.04,132.37 69.04,131.56 v6(68.89,131.41) ; 68.35,129.78 68.35,129.91 68.28,129.99 67.84,129.99 67.77,130.06 67.77,130.17 67.82,130.22 68.83,130.22 v6(68.89,130.16)
M_B_CA_0_3: length 18
  IN3 w0.076: v6(70.94,128.59) 70.9,128.59 70.57,128.92 70.57,129.25 70.66,129.34 70.94,129.34 70.99,129.4 70.99,129.52 70.94,129.58 70.65,129.58 70.54,129.68 70.54,129.83 v6(70.41,129.96)
  IN4 w0.06: v5(71.21,123.75) 71.21,123.96 71.01,124.16 71.01,124.33 71.02,124.34 71.09,124.41 71.09,126.42 71.09,126.98 71.09,126.98 71.09,127.79 70.91,127.96
  IN4 w0.061: 70.91,127.96 70.81,128.07 70.81,128.46 v6(70.94,128.59) ; v6(70.41,129.96) 70.56,130.11 70.56,130.19 70.46,130.3 70.31,130.3 70.14,130.47 70.14,130.65 70.06,130.73 69.91,130.73 69.83,130.65 69.83,130.06 69.61,129.84 69.61,129.73 69.7,129.64 69.8,129.64 70.05,129.88 70.1,129.88 70.17,129.81 70.18,129.81 70.18,129.71 69.93,129.46 69.53,129.46 69.39,129.59 69.39,130.04 69.47,130.12 69.57,130.12 69.65,130.19 69.65,130.35 69.57,130.42 69.47,130.42 69.39,130.5 69.39,130.71 69.47,130.78 69.62,130.78 69.7,130.86 69.7,130.97 69.62,131.04 69.55,131.04 69.47,131.12 69.47,131.27 69.55,131.35 69.62,131.35 69.7,131.42 69.7,132.05 70.26,132.61 70.26,133.4 70.1,133.55 70.1,133.8 69.89,134.02 69.55,134.02 v5(69.28,134.28)
M_B_CA_0_4: length 16.9
  IN3 w0.06: 67.8,128.75 67.73,128.68 67.73,128.45 67.75,128.44 v6(67.75,127.97)
  IN3 w0.076: v10(68.78,134.28) 68.84,134.34 69.06,134.34 69.51,133.89 69.51,133.5 69.41,133.41 69.33,133.41 69.28,133.45 69.17,133.45 69.06,133.34 69.06,133.24 69.12,133.18 69.12,133.07 69.06,133.01 68.95,133.01 68.79,133.17 68.68,133.17 68.57,133.06 68.57,132.95 68.73,132.79 68.73,132.68 68.71,132.66 68.71,132.47 68.34,132.1 68.18,132.1 68.11,132.18 68.11,132.68 68.03,132.76 67.89,132.76 67.81,132.68 67.81,132.54 67.82,132.53 67.57,132.29 67.57,131.89 67.75,131.71 68.07,131.71 68.2,131.58 68.2,131.29 68.07,131.16 68.01,131.16 67.95,131.1 67.95,130.98 68.1,130.83 68.1,130.6 67.91,130.42 67.91,129.18 67.8,129.07 67.8,128.75
  IN4 w0.06: 67.69,126.62 69.14,125.17 69.14,124.4 69.06,124.32 69.06,124.18 69.08,124.16 69.14,124.1 69.14,124.09 69.15,124.08 69.15,123.91 69.08,123.84 69.08,123.83 69.08,123.67 69.09,123.65 69.09,123.65 69.15,123.59 69.15,123.42 69.09,123.36 69.09,123.35 69.08,123.34 69.08,123.18 69.19,123.06 69.19,123.06 69.28,122.98 v5(69.28,122.77)
  IN4 w0.061: v6(67.75,127.97) 67.75,127.63 67.69,127.58 67.69,127.52 67.69,126.62
M_B_CA_0_5: length 18.3
  IN3 w0.076: v6(70.44,130.55) 70.36,130.47 70.36,130.3 70.41,130.24 70.48,130.24 71.25,129.48 71.25,129.25 71.16,129.16 70.85,129.16 70.79,129.1 70.79,128.98 70.94,128.83 71.07,128.83 71.22,128.67 71.22,128.34 71.07,128.19 v6(71.04,128.19)
  IN4 w0.06: 71.23,127.7 71.23,124.27 v5(71.21,124.24)
  IN4 w0.061: 71.23,127.7 71.23,128.04 71.08,128.19 v6(71.04,128.19) ; v5(68.78,135.78) 68.73,135.73 68.73,135.56 68.78,135.5 69.39,135.5 69.55,135.35 69.55,135.2 69.56,135.19 69.56,135.19 69.7,135.05 70.05,135.05 70.13,134.97 70.13,134.86 70.05,134.79 69.67,134.79 69.5,134.62 69.5,134.41 69.62,134.29 69.83,134.29 70.26,134.71 70.36,134.71 70.44,134.64 70.44,134.52 70.1,134.17 70.1,134.06 70.43,133.73 70.43,132.4 70.3,132.27 70.16,132.27 70.1,132.21 70.1,132.11 70.18,132.04 70.33,132.04 70.41,131.96 70.41,131.81 70.33,131.73 69.93,131.73 69.85,131.65 69.85,131.57 69.93,131.49 70.33,131.49 70.41,131.42 70.41,131.26 70.33,131.19 69.93,131.19 69.85,131.11 69.85,131.03 70,130.88 70.16,130.88 70.29,130.75 70.29,130.7 v6(70.44,130.55)
M_B_CA_0_6: length 18.2
  IN4 w0.06: v5(71.21,123.26) 71.21,123.26 71.1,123.36 71.03,123.36 70.97,123.3 70.8,123.3 70.69,123.42 70.69,123.44 70.58,123.55 70.48,123.55 70.36,123.67 70.36,123.83 70.48,123.95 70.48,124.04 70.36,124.16 70.36,124.43 70.46,124.53 70.46,125.48 70.43,125.51 70.43,126.97 70.34,127.07 70.34,127.45
  IN4 w0.061: 70.34,127.45 70.46,127.58 70.46,129.18 71.07,129.79 71.07,131.24 70.9,131.41 70.9,136.62 70.64,136.88 68.92,136.88 68.55,136.5 68.55,135.79 68.46,135.71 68.35,135.71 68.28,135.78 v5(68.28,135.78)
M_B_CA_0_7: length 17.2
  IN4 w0.06: 70.03,127.53 70.03,125.54 70.22,125.35 70.22,124.82 70.08,124.69 70.08,124.36 70.12,124.33 70.12,124.16 70.1,124.14 70.1,124.14 70.04,124.08 70.04,123.91 70.12,123.84 70.12,123.67 70.04,123.59 70.04,123.42 70.16,123.3 70.16,123.3 70.21,123.26 v5(70.56,123.26)
  IN4 w0.061: v5(69.28,136.28) 69.16,136.28 69.01,136.13 69.01,135.86 69.16,135.71 69.37,135.71 69.92,136.26 70.03,136.26 70.13,136.16 70.13,136.05 69.81,135.73 69.81,135.62 69.88,135.55 69.99,135.55 70.26,135.82 70.37,135.82 70.48,135.71 70.48,135.61 70.31,135.44 70.31,135.33 70.59,135.05 70.59,131.16 70.71,131.03 70.71,129.92 70.1,129.31 70.1,127.6 70.03,127.53
M_B_CA_0_8: length 16.9
  IN4 w0.06: v5(70.24,124) 70.24,124.62 70.34,124.71 70.34,125.4 70.26,125.48 70.26,126.49 70.19,126.57 70.19,127.48
  IN4 w0.061: v5(68.78,136.28) 68.78,136.52 68.98,136.72 69.43,136.72 69.51,136.65 69.51,136.42 69.58,136.34 69.73,136.34 69.81,136.42 69.81,136.65 69.89,136.72 70.04,136.72 70.11,136.65 70.11,136.42 70.19,136.34 70.34,136.34 70.42,136.42 70.42,136.65 70.5,136.72 70.57,136.72 70.74,136.55 70.74,136.3 70.67,136.22 70.54,136.22 70.46,136.14 70.46,135.99 70.54,135.92 70.67,135.92 70.74,135.84 70.74,131.31 70.89,131.16 70.89,129.84 70.29,129.24 70.29,127.58 70.19,127.48
M_B_CA_0_9: length 18
  IN4 w0.06: v5(70.56,124.24) 70.56,124.46 70.61,124.51 70.61,127.04 70.48,127.18 70.48,127.22 70.48,127.4 70.61,127.53
  IN4 w0.061: v5(68.28,136.28) 68.04,136.52 67.59,136.52 67.44,136.67 67.44,136.88 67.62,137.05 70.77,137.05 71.07,136.75 71.07,131.47 71.24,131.3 71.24,129.7 70.64,129.11 70.64,127.56 70.61,127.53
M_B_CA_1_0: length 21.8
  IN3 w0.06: v10(71.21,122.77) 71.2,122.77 71.2,123.09 71.32,123.21 71.32,126.35 69.96,127.72 68.61,127.72 68.27,127.72 67.85,127.3 67.34,127.3 66.96,127.68 66.96,128.05 66.96,128.05 66.96,128.63
  IN3 w0.076: 66.96,128.63 66.96,129.92 67.01,129.97 67.01,129.97 67.01,130.15 67.01,130.15 67.01,130.39 66.87,130.52 66.87,131.01 67.24,131.38 67.24,132.44 67.51,132.71 67.51,132.86 66.71,133.65 66.71,133.72 65.99,134.44 65.99,134.92 65.64,135.27 64.93,135.27 64.27,134.61 64.27,132.79 v10(64.78,132.28)
M_B_CA_1_1: length 20.8
  IN3 w0.06: v10(71.21,122.27) 71.21,122.48 70.97,122.72 70.97,123.14 71.17,123.34 71.17,126.31 69.9,127.58 68.67,127.58 68.33,127.58 67.91,127.16 67.29,127.16 66.81,127.63 66.81,128.1 66.82,128.11 66.82,128.52 66.81,128.53 66.81,128.54 66.78,128.57 66.78,128.6
  IN3 w0.076: 66.78,128.6 66.78,129.17 66.35,129.61 66.35,129.83 66.37,129.85 66.37,132.12 66.48,132.23 66.48,133.72 65.81,134.39 65.81,134.87 65.59,135.09 65,135.09 64.42,134.51 64.42,133.14 v10(64.78,132.78)
M_B_CA_1_2: length 20.6
  IN3 w0.06: 65.44,128.85 65.16,128.58 65.16,128.26 66.98,126.45 66.98,126.44 68.76,124.66 69.04,124.66 69.04,124.66 69.09,124.66 69.2,124.78 69.2,125.28 68.78,125.7 68.78,125.95 68.4,126.34 68.4,126.56 68.74,126.9 69.51,126.9 69.91,126.5 69.91,124.89 70.12,124.68 70.12,122.68 70.05,122.62 70.05,122.61 70.04,122.6 70.04,122.36 70.17,122.23 70.4,122.23 70.85,121.78 v10(71.21,121.78)
  IN3 w0.076: 65.44,128.85 65.44,130 65.3,130.13 65.3,131.92 65.25,131.97 65.25,131.98 65.12,132.11 65.11,132.11 65.01,132.22 65.01,133.05 v10(64.78,133.28)
M_B_CA_1_3: length 20.7
  IN3 w0.06: v10(70.24,122.52) 70.24,122.52 70.24,122.63 70.24,122.63 70.24,122.9 70.24,124.79 70.05,124.98 70.05,125.61 70.23,125.79 70.23,126.38 69.57,127.04 68.9,127.04 68.63,127.04 68.23,126.63 68.23,126.28 68.61,125.9 68.61,125.65 69.07,125.19 69.07,124.84 69.03,124.8 68.83,124.8 68.67,124.96 68.67,125.08 68.73,125.14 68.73,125.25 68.62,125.35 68.51,125.35 68.46,125.3 68.35,125.3 68.22,125.42 68.22,125.6 68.37,125.75 68.37,125.86 68.29,125.95 68.17,125.95 68,125.78 67.87,125.78 67.8,125.84 67.8,125.95 68.06,126.21 68.06,126.45 67.97,126.54 67.86,126.54 67.82,126.49 67.82,126.24 67.66,126.09 67.56,126.09 67.49,126.15 67.49,126.26 67.63,126.4 67.63,126.53 67.56,126.6 67.4,126.6 67.27,126.48 67.16,126.48 66.03,127.61 66.01,127.61 65.31,128.31 65.31,128.52 65.59,128.79
  IN3 w0.076: 65.59,128.79 65.59,130.07 65.48,130.17 65.48,132.08 v10(65.28,132.28)
M_B_CA_1_4: length 19.5
  IN3 w0.06: v10(69.92,121.78) 69.56,121.78 69.37,121.97 69.37,122.26 69.28,122.35 69.28,123.11 69.47,123.31 69.47,123.61 69.21,123.87 69.04,123.87 68.71,124.2 68.71,124.46 65,128.16 ; 65.54,128.51 65.74,128.72
  IN3 w0.076: v6(65.54,128.44) 65.54,128.51 ; v10(65.28,132.78) 65.28,132.6 65.66,132.23 65.66,130.3 65.74,130.22 65.74,129.31 65.74,129.31 65.74,128.72 ; v6(65.05,128.8) 65,128.75 65,128.16
  IN4 w0.061: v6(65.05,128.8) 65.08,128.83 65.08,128.88 65.18,128.98 65.18,129.1 65.27,129.19 65.43,129.19 65.57,129.05 65.57,128.95 65.65,128.87 65.8,128.87 65.88,128.95 65.88,129.28 65.95,129.36 66.14,129.36 66.24,129.26 66.24,129 66.16,128.92 66.16,128.92 66.03,128.78 66.03,128.6 66.04,128.59 66.04,128.57 66.35,128.26 66.35,127.83 66.24,127.73 66.12,127.73 66.04,127.81 66.04,127.92 66.13,128.01 66.13,128.12 66.02,128.23 65.92,128.23 65.82,128.14 65.71,128.14 65.54,128.31 v6(65.54,128.44)
M_B_CA_1_5: length 16.2
  IN3 w0.06: v10(68.95,122.52) 68.74,122.73 68.74,123.79 68.26,124.27 68.26,124.34 67.39,125.22 66.12,126.48 64.52,128.08
  IN3 w0.076: v6(65.18,129.86) 64.99,129.67 64.9,129.67 64.52,129.28 64.52,128.08 ; v10(66.78,132.78) 66.71,132.7 66.71,132.12 66.55,131.97 66.55,129.76 v6(66.57,129.74)
  IN4 w0.061: v6(66.57,129.74) 66.5,129.82 66.5,130.05 66.4,130.14 65.99,130.14 65.76,129.92 65.48,129.92 65.38,130.02 65.38,130.63 65.28,130.73 65.1,130.73 65.02,130.65 65.02,130.02 v6(65.18,129.86)
M_B_CA_1_6: length 21.8
  IN3 w0.06: 65.89,128.66 65.81,128.57 65.81,128.02 66.09,127.75 66.09,127.75 67.1,126.73 68.11,126.73 68.11,126.74 68.12,126.74 68.56,127.17 68.84,127.17 68.84,127.17 69.64,127.17 70.74,126.07 70.74,123.64 70.57,123.47 70.57,123.17 70.36,122.97 70.36,122.85 70.36,122.68 70.37,122.67 70.37,122.67 70.44,122.6 70.44,122.43 70.84,122.03 v10(70.89,122.03)
  IN3 w0.076: v6(65.32,134.18) 65.32,134.22 64.95,134.58 64.73,134.58 64.6,134.46 64.6,133.9 64.99,133.5 65.38,133.5 65.38,133.5 65.4,133.5 65.53,133.37 65.53,133.17 65.65,133.06 65.69,133.06 65.69,133.05 65.83,133.05 66.01,132.88 66.01,132.87 66.01,132.69 66.01,132.6 65.94,132.53 65.94,132.52 65.84,132.42 65.84,130.4 65.89,130.35 65.89,129.38 65.89,129.38 65.89,128.66
  IN4 w0.061: v6(65.32,134.18) 65.32,134.54 65.47,134.69 65.84,134.69 66.51,134.02 66.51,133.48 66.71,133.28 v5(66.78,133.28)
M_B_CA_1_7: length 22.1
  IN3 w0.06: 65.96,128.51 65.96,128.09 67.17,126.88 68.05,126.88 68.48,127.31 69.71,127.31 70.88,126.15 70.88,124.06 70.87,124.05 70.87,123.56 70.69,123.39 70.69,122.89 v10(70.56,122.77)
  IN3 w0.076: v6(64.85,134.34) 64.85,133.9 65.03,133.72 65.77,133.72 66.17,133.31 66.17,132.54 66.02,132.38 66.02,130.48 66.05,130.45 66.05,129.44 66.05,129.44 66.05,128.59 65.96,128.51
  IN4 w0.061: v6(64.85,134.34) 65.02,134.17 65.02,133.65 65.16,133.51 65.43,133.51 65.56,133.64 65.56,134.28 65.63,134.36 65.91,134.36 66.06,134.21 66.06,133.69 66.07,133.68 66.07,133.67 66.48,133.26 66.48,133.26 66.56,133.19 66.71,133.03 66.84,133.03 67.04,132.84 67.04,132.71 67.28,132.46 v5(67.28,132.28)
M_B_CA_1_8: length 15.7
  IN3 w0.06: 64.72,128.14 64.85,128 68.49,124.36 68.49,124.23 69.02,123.7 69.2,123.7 69.34,123.56 69.34,123.41 69.27,123.33 69.21,123.33 69.11,123.23 69.11,123.17 69.16,123.13 69.16,121.9 v10(69.28,121.78)
  IN3 w0.076: v10(67.28,132.79) 67.01,132.53 67.01,131.43 66.71,131.14 66.71,130.19 v6(66.78,130.12) ; 64.72,128.14 64.72,129.23 64.93,129.44 v6(65.18,129.44)
  IN4 w0.061: v6(66.78,130.12) 66.8,130.1 66.8,129.61 66.68,129.48 66.42,129.48 66.3,129.61 66.3,129.7 66.2,129.79 66.08,129.79 65.99,129.7 65.99,129.61 65.91,129.53 65.28,129.53 v6(65.18,129.44)
M_B_CA_1_9: length 21
  IN3 w0.06: 66.6,128.58 66.6,128.56 66.68,128.49 66.68,128.47 66.68,128.46 66.68,128.17 66.68,128.16 66.68,127.57 67.22,127.02 67.99,127.02 68.41,127.45 68.73,127.45 69.81,127.45 71.02,126.23 71.02,123.49 70.82,123.29 70.82,122.58 v10(70.89,122.52)
  IN3 w0.076: 66.6,128.58 66.6,129.1 66.2,129.5 66.2,132.3 66.32,132.43 66.32,133.64 66.12,133.85 65.87,133.85 65.61,134.1 65.61,134.63 65.4,134.85 v6(65.15,134.85)
  IN4 w0.061: v5(67.28,133.28) 67.29,133.27 67.29,133.07 67.24,133.02 67.13,133.02 67.03,133.12 67.03,133.9 66.93,134 66.75,134 65.9,134.85 v6(65.15,134.85)
M_B_CK_DDR0_DN: length 14.6
  IN3 w0.06: 67.3,128.32 67.3,128.31 67.32,128.3 67.32,128.24 67.24,128.16 67.15,128.07 67.15,127.79 67.41,127.53 67.86,127.53 68.22,127.89 68.22,127.89 69.68,127.89 69.97,128.18 69.97,128.32 70.06,128.41 70.27,128.41 70.43,128.25 70.43,127.79 70.69,127.52 v6(70.69,127.31)
  IN3 w0.091: 67.3,128.32 67.3,128.46 67.43,128.59 67.43,129.12 67.61,129.31 67.61,130.62 v3(67.49,130.75)
  IN4 w0.06: v6(70.69,127.31) 70.77,127.23 70.77,124.16 70.69,124.08 70.69,123.91 70.89,123.71 v5(70.89,123.51)
  IN4 w0.069: v3(67.49,130.75) 67.57,130.84 67.57,131.02 67.22,131.37 66.59,131.37 66.38,131.58 66.38,132.19 v5(66.28,132.28)
M_B_CK_DDR0_DP: length 14.7
  IN3 w0.06: v6(70.87,127.7) 70.69,127.7 70.55,127.84 70.55,128.3 70.32,128.53 70.01,128.53 69.85,128.37 69.85,128.23 69.63,128.01 68.18,128.01 68.14,127.97 67.81,127.65 67.46,127.65 67.27,127.84 67.27,128.02 67.32,128.07 67.45,128.2 67.45,128.3
  IN3 w0.091: 67.45,128.3 67.45,128.39 67.59,128.52 67.59,128.65 67.59,128.65 67.59,129.06 67.77,129.24 67.77,130.66 v3(67.85,130.75)
  IN4 w0.06: v6(70.87,127.7) 70.86,127.69 70.86,127.46 70.92,127.39 70.92,127.14 70.89,127.11 v5(70.89,124)
  IN4 w0.069: v3(67.85,130.75) 67.7,130.9 67.7,131.07 67.28,131.5 66.64,131.5 66.51,131.64 66.51,132.37 66.28,132.6 v5(66.28,132.78)
M_B_CK_DDR1_DN: length 23.8
  IN3 w0.06: v6(69.12,126.23) 69.12,126.01 69.06,125.95 69.06,125.71 69.35,125.43 69.35,124.69 69.6,124.44 69.6,123.2 69.44,123.05 69.44,122.65 69.4,122.6 69.4,122.44 69.51,122.32 69.52,122.32 69.6,122.24 69.6,122.03 v10(69.6,122.03)
  IN3 w0.091: v10(68.78,135.28) 68.95,135.28 69.5,134.73 69.77,134.73 69.94,134.9 69.94,135.6 69.79,135.75 68.59,136.95 67.84,136.95 67.75,137.04 67.75,137.24 67.86,137.35 68.54,137.35 70.33,135.56 70.33,133.58 70.52,133.39 70.52,131.73 69.73,130.94 69.73,129.63 69.55,129.45 69.37,129.45 69.21,129.28 69.2,129.28 69.2,129.12 69.2,129.12 69.2,128.99 69.44,128.76 69.44,128.63 69.4,128.59 v6(69.27,128.59)
  IN4 w0.06: v6(69.12,126.23) 69.31,126.23 69.39,126.31 69.39,126.95 69.39,126.95 69.39,127 69.22,127.18 69.22,128.29 69.34,128.41 69.34,128.52 v6(69.27,128.59)
M_B_CK_DDR1_DP: length 23.7
  IN3 w0.06: v6(69.4,125.92) 69.36,125.96 69.25,125.96 69.18,125.89 69.18,125.76 69.47,125.48 69.47,124.74 69.72,124.49 69.72,123.15 69.56,123 69.56,122.55 v10(69.6,122.52) ; 69.49,128.28 69.5,128.26
  IN3 w0.091: v10(69.28,135.28) 69.28,135.17 69.56,134.89 69.71,134.89 69.79,134.96 69.79,135.54 69.47,135.86 69.41,135.91 69.27,135.91 69.09,135.73 68.94,135.73 68.84,135.82 68.84,135.95 69.06,136.17 69.06,136.26 68.52,136.8 67.78,136.8 67.6,136.98 67.6,137.3 67.8,137.5 68.6,137.5 70.48,135.62 70.48,133.65 70.67,133.46 70.67,131.66 69.88,130.88 69.88,129.57 69.61,129.3 69.44,129.3 69.36,129.21 69.36,129.06 69.59,128.82 69.59,128.57 69.47,128.45 69.47,128.3 69.49,128.28 ; 69.5,128.26 v6(69.51,128.26)
  IN4 w0.06: v6(69.51,128.26) 69.34,128.08 69.34,127.23 69.51,127.05 69.51,126.9 69.51,126.9 69.51,126.26 69.37,126.11 69.37,125.95 v6(69.4,125.92)
M_B_CKE0: length 18.7
  IN4 w0.06: 69.88,127.22 69.88,125.44 69.81,125.38 69.81,124.9 69.96,124.75 69.96,124.28 v5(69.92,124.24)
  IN4 w0.061: 69.88,127.22 69.63,127.47 69.63,127.8 69.88,128.06 69.88,128.74 69.61,129.01 69.36,129.01 69.27,129.1 69.27,129.23 69.16,129.34 69.16,129.54 69.01,129.69 68.94,129.69 68.86,129.76 68.86,129.89 68.91,129.94 69.08,129.94 69.16,130.02 69.16,130.22 68.93,130.44 68.82,130.44 68.76,130.38 67.97,130.38 67.84,130.51 67.65,130.51 67.52,130.38 67.41,130.38 67.24,130.55 67.24,131.11 67.16,131.19 67.03,131.19 66.95,131.11 66.95,130.78 66.88,130.7 66.77,130.7 66.69,130.78 66.69,131.06 66.57,131.18 66.47,131.18 66.39,131.1 66.39,130.8 66.29,130.7 66.06,130.7 65.93,130.84 65.93,130.95 66.25,131.26 66.25,131.39 66.17,131.46 66.06,131.46 65.74,131.14 65.63,131.14 65.56,131.21 65.56,131.44 65.84,131.72 66.01,131.72 66.18,131.88 66.18,131.99 66.07,132.1 65.92,132.1 65.38,131.56 65.21,131.56 65.02,131.74 65.02,132.38 65.18,132.53 65.4,132.53 65.51,132.63 65.51,132.69 65.51,132.87 65.51,132.87 65.51,132.94 65.61,133.04 65.73,133.04 65.78,132.99 v10(65.78,132.78)
M_B_CKE1: length 18.1
  IN4 w0.06: 68.41,126.82 68.15,126.82 68.07,126.74 68.07,126.63 69.45,125.26 69.45,124.35 69.48,124.33 69.48,124.16 69.36,124.05 69.36,123.95 69.4,123.92 69.51,123.8 69.52,123.8 69.6,123.72 v5(69.6,123.5)
  IN4 w0.061: v10(65.78,133.28) 65.78,133.26 65.94,133.1 66.02,133.1 66.08,133.17 66.12,133.17 66.18,133.23 66.18,133.34 66,133.52 65.69,133.52 65.51,133.34 65.51,133.17 65.38,133.04 64.62,133.04 64.38,132.8 64.38,132.68 64.46,132.6 64.62,132.6 64.65,132.57 64.65,132.47 64.56,132.37 64.43,132.37 64.36,132.3 64.36,132.24 64.48,132.12 64.62,132.12 64.75,131.99 64.75,131.8 66.02,130.53 67.06,130.53 67.11,130.47 67.11,130.47 67.82,129.76 68.1,129.76 68.17,129.69 68.17,129.53 68.1,129.46 67.82,129.46 67.75,129.38 67.75,129.07 68.18,128.64 68.18,127.95 68.13,127.9 68.13,127.72 68.26,127.59 68.54,127.59 68.61,127.52 68.61,127.41 68.53,127.33 68.05,127.33 67.99,127.27 67.99,127.14 68.05,127.08 68.48,127.08 68.56,127 68.56,126.89 68.48,126.82 68.41,126.82
M_B_CKE2: length 17.9
  IN3 w0.06: v6(69.14,126.68) 69.37,126.68 69.76,126.29 69.76,124.83 69.98,124.62 69.98,122.82 v10(69.92,122.77)
  IN3 w0.076: v6(67.3,135.21) 67.59,134.92 68.94,134.92 69.86,134 69.86,133.24 69.04,132.43 69.04,132.12 69.12,132.05 69.35,132.05 69.52,131.88 69.52,130.16 68.86,129.5 v6(68.86,129.45)
  IN4 w0.06: v6(69.14,126.68) 69.06,126.77 69.06,127.84 68.69,128.21
  IN4 w0.061: v5(68.78,134.78) 68.72,134.78 68,135.5 67.6,135.5 67.45,135.35 67.45,135.35 v6(67.3,135.21) ; 68.69,128.21 68.69,129.22 68.86,129.4 v6(68.86,129.45)
M_B_CKE3: length 17.5
  IN3 w0.076: v6(67.98,131.43) 67.89,131.43 67.52,131.06 67.47,131.06 67.39,130.98 67.26,130.85 67.26,130.65 67.37,130.54 v6(67.37,129.4)
  IN4 w0.06: 68.42,125.29 68.42,124.63 68.64,124.41 68.64,124.13 68.63,124.13 68.63,123.87 68.64,123.86 68.64,123.55 68.43,123.34 68.43,123.18 68.6,123.01 v10(68.95,123.01)
  IN4 w0.061: v6(67.37,129.4) 67.37,129.4 66.82,129.4 66.68,129.25 66.55,129.13 66.55,128.59 66.57,128.57 66.57,128.07 66.63,128.01 66.84,128.01 66.93,127.92 66.93,127.76 66.85,127.69 66.57,127.69 66.5,127.61 66.5,127.5 66.63,127.37 66.76,127.37 66.85,127.28 66.85,127.15 67.07,126.93 67.07,126.64 68.42,125.29 ; v5(68.28,134.78) 68.28,134.89 68.13,135.05 67.67,135.05 67.54,134.92 67.54,134.69 67.69,134.54 67.97,134.54 68.03,134.48 68.03,133.21 68.23,133.01 68.48,133.01 68.56,132.93 68.56,131.4 68.4,131.24 68.17,131.24 v6(67.98,131.43)
M_B_CS0_N: length 28.4
  IN3 w0.076: v10(68.28,134.28) 68.24,134.33 67.55,134.33 67.16,133.93 66.72,133.93 66.14,134.51 66.14,135.2 66.22,135.27 66.37,135.27 66.5,135.15 66.5,134.51 66.81,134.21 v6(67.04,134.21)
  IN4 w0.06: v5(68.95,124) 68.94,124.01 68.94,124.37 68.98,124.41 68.98,125 68.98,125 68.98,125.13
  IN4 w0.061: v10(65.28,133.28) 65.15,133.28 64.91,133.52 64.64,133.52 64.54,133.62 64.54,134.65 64.99,135.09 65.89,135.09 66.78,134.21 v6(67.04,134.21) 67.04,134.36 67.09,134.41 67.09,134.69 66.2,135.57 66.2,135.81 65.97,136.04 65.56,136.04 64.03,134.52 64.03,133.65 64.17,133.51 64.36,133.51 64.37,133.5 64.38,133.5 64.51,133.37 64.51,133.19 64.21,132.89 64.21,132.17 64.51,131.87 64.51,131.78 65.94,130.35 66.91,130.35 67.59,129.67 67.59,129.31 67.59,129.01 67.59,129.01 67.59,128.13 67.52,128.06 67.52,127.87 67.56,127.84 67.56,126.55 68.98,125.13
M_B_CS1_N: length 31
  IN3 w0.076: v6(68.66,130.63) 68.59,130.56 68.59,130.24 68.4,130.06 68.4,129.92 68.4,129.91 68.4,129.73 68.4,129.72 68.4,129.71 68.56,129.55 68.56,129.43 68.96,129.03 68.96,128.41 v6(68.92,128.36)
  IN4 w0.06: 69.72,127.15 69.72,125.48 69.69,125.45 69.69,124.83 69.77,124.74 69.77,124.38 69.72,124.33 69.72,124.16 69.84,124.04 69.84,123.95 69.72,123.83 69.72,123.67 69.84,123.55 69.84,123.55 69.92,123.47 v5(69.92,123.26)
  IN4 w0.061: 67.59,133.55 67.7,133.55 67.85,133.4 67.85,133.16 68.08,132.93 68.08,131.75 67.99,131.66 67.88,131.66 67.82,131.72 67.82,131.94 67.77,132 67.62,132 67.54,131.92 67.54,131.54 68.1,130.98 68.1,130.63 68.19,130.53 68.31,130.53 68.4,130.63 68.4,130.75 68.51,130.86 69.14,130.86 69.21,130.78 69.21,130.67 69.16,130.62 68.68,130.62 v6(68.66,130.63) ; 67.59,133.55 67.56,133.58 67.56,133.89 67.34,134.11 67.34,134.72 66.97,135.09 66.97,135.35 67.12,135.5 67.39,135.5 67.51,135.63 67.51,135.76 66.89,136.38 66.89,136.56 66.98,136.65 67.08,136.65 67.69,136.04 67.92,136.04 68.02,135.94 68.02,135.71 68.71,135.02 68.93,135.02 69.17,134.78 v5(69.28,134.78) ; 67.59,133.55 67.51,133.47 67.51,133.22 67.62,133.12 67.62,133.01 67.52,132.92 67.52,132.8 67.6,132.71 67.82,132.71 67.89,132.64 67.89,132.53 67.82,132.45 67.61,132.45 67.54,132.38 67.54,132.16 67.41,132.02 66.83,132.02 66.74,132.11 66.74,132.2 66.82,132.28 66.93,132.28 67.01,132.35 67.01,132.46 66.94,132.52 66.66,132.52 66.55,132.63 66.55,132.87 66.41,133.02 66.15,133.02 66.02,132.89 66.02,132.62 65.92,132.52 65.66,132.52 65.51,132.37 65.51,132.37 65.51,132.19 65.38,132.05 65.37,132.05 65.22,131.9 65.22,131.81 65.28,131.74 65.32,131.74 65.78,132.2 v5(65.78,132.28) ; v6(68.92,128.36) 68.84,128.44 68.84,128.69 68.99,128.84 69.51,128.84 69.73,128.63 69.73,128.13 69.48,127.88 69.48,127.39 69.72,127.15
M_B_DQ_0: length 19
  IN3 w0.06: v10(72.5,121.78) 72.39,121.68 72.22,121.68 71.95,121.57 71.73,121.57 71.63,121.67 71.41,122.03 71.41,123.06 71.48,123.13 71.48,126.11
  IN3 w0.076: 71.48,126.11 71.87,126.5 71.87,129.75 70.94,130.68 70.94,133.5 70.71,133.73 70.71,135.73 68.78,137.66 68.66,137.66 68.54,137.78 v10(68.28,137.78)
M_B_DQ_1: length 19
  IN3 w0.06: v10(71.85,121.78) 71.53,122.1 71.53,123.01 71.65,123.14 71.65,126.03
  IN3 w0.076: 71.65,126.03 72.04,126.41 72.04,129.86 71.12,130.78 71.12,133.57 70.89,133.8 70.89,135.81 68.89,137.81 68.72,137.81 68.52,138.01 68.18,138.01 67.94,137.78 v10(67.78,137.78)
M_B_DQ_2: length 22.2
  IN3 w0.06: v10(72.5,122.77) 72.5,125.63 73.15,126.28
  IN3 w0.076: v10(67.78,138.78) 67.54,139.02 67.54,139.44 67.64,139.54 67.98,139.54 68.12,139.67 68.5,139.67 68.66,139.52 69.08,139.52 69.27,139.71 70.42,139.71 71.21,138.92 71.21,137.09 72.01,136.29 72.01,134.23 72.21,134.03 72.21,131.36 73.15,130.42 73.15,126.28
M_B_DQ_3: length 18.7
  IN3 w0.06: v10(71.85,122.27) 71.65,122.48 71.65,122.95 71.81,123.11 71.81,125.95 72.21,126.36 72.21,126.46
  IN3 w0.076: v10(67.78,138.28) 67.9,138.17 68.58,138.17 68.76,137.99 68.97,137.99 71.07,135.89 71.07,133.99 71.3,133.76 71.3,130.88 72.21,129.97 72.21,126.46
M_B_DQ_4: length 24.5
  IN3 w0.06: 73.56,126.23 72.82,125.49 v10(72.82,122.52)
  IN3 w0.076: v10(67.28,138.78) 66.77,138.78 66.67,138.88 66.67,139.28 67.56,140.18 70.43,140.18 71.72,138.89 71.72,137.16 72.42,136.47 72.42,134.28 72.62,134.08 72.62,131.49 73.56,130.55 73.56,126.23
M_B_DQ_5: length 24.4
  IN3 w0.06: v10(72.82,122.03) 72.82,122.03 72.82,122.24 72.62,122.44 72.62,122.6 72.62,122.61 72.7,122.68 72.7,122.85 72.7,122.85 72.7,122.89 72.65,122.93 72.65,125.55 73.36,126.26
  IN3 w0.076: v10(67.28,139.28) 67.28,139.2 67.03,138.94 66.88,138.94 66.82,139 66.82,139.22 67.6,140 70.37,140 71.46,138.91 71.46,137.14 72.21,136.39 72.21,134.26 72.42,134.06 72.42,131.44 73.36,130.5 73.36,126.26
M_B_DQ_6: length 19
  IN3 w0.06: 72.39,126.38 72.39,126.33 71.96,125.91 71.96,123.07 71.93,123.04 71.93,122.85 v10(71.85,122.77)
  IN3 w0.076: v10(67.28,138.28) 67.32,138.28 67.56,138.52 67.86,138.52 68.07,138.32 68.65,138.32 68.79,138.17 69.07,138.17 69.18,138.04 71.25,135.97 71.25,134.06 71.48,133.83 71.48,130.98 72.39,130.07 72.39,126.38
M_B_DQ_7: length 21.5
  IN3 w0.06: 72.95,126.31 72.82,126.18 72.36,125.72 72.36,122.93 72.3,122.87 72.3,122.68 72.5,122.48 v10(72.5,122.27)
  IN3 w0.076: v10(67.78,139.28) 67.94,139.28 68.18,139.52 68.44,139.52 68.6,139.36 69.29,139.36 69.47,139.54 69.9,139.54 70.35,139.09 70.79,139.09 70.98,138.9 70.98,137.06 71.81,136.23 71.81,134.21 72.01,134 72.01,131.29 72.95,130.35 72.95,126.31
M_B_DQ_8: length 30
  IN3 w0.06: 73.61,125.14 73.61,125 73.6,124.99 73.6,122.87 73.58,122.85 73.58,122.68 73.6,122.67 73.6,122.66 73.66,122.61 73.66,122.6 73.66,122.44 73.66,122.43 73.66,122.43 73.59,122.36 73.59,122.19 73.66,122.11 73.66,121.94 73.5,121.78 v10(73.14,121.78)
  IN3 w0.076: 73.61,125.14 74.56,126.09 74.56,130.9 74.4,131.06 74.4,137.59 70.89,141.09 66.09,141.09 64.64,139.64 64.31,139.64 64.03,139.36 64.03,139.03 v10(63.78,138.78)
M_B_DQ_9: length 34.5
  IN3 w0.06: 74.42,124.71 74.32,124.61 74.32,123.04 74.36,123 74.36,122.72 74.43,122.65 74.43,122.35 v10(74.11,122.03)
  IN3 w0.076: v10(64.28,138.28) 64.14,138.14 63.98,138.14 63.91,138.07 63.36,138.07 62.9,138.52 62.9,139.45 64.01,140.56 64.18,140.56 65.61,141.98 71.34,141.98 75.31,138.01 75.31,131.49 75.57,131.24 75.57,125.85 74.42,124.71
M_B_DQ_10: length 29.4
  IN3 w0.06: v10(73.14,122.77) 73.14,125.36
  IN3 w0.076: v10(64.28,137.78) 64.28,137.78 64.28,137.57 64.36,137.49 64.47,137.49 64.54,137.56 64.54,138.39 64.66,138.52 64.68,138.52 64.68,138.52 64.88,138.52 64.88,138.52 64.99,138.52 65.09,138.42 65.09,138.07 65.15,138.01 65.3,138.01 65.39,138.1 65.39,138.44 65.39,138.45 65.39,139.5 66.47,140.58 70.65,140.58 73.81,137.42 73.81,130.91 73.99,130.73 73.99,126.21 73.14,125.36
M_B_DQ_11: length 28.6
  IN3 w0.06: 73.79,125.09 73.75,125.05 73.75,122.8 v10(73.78,122.77)
  IN3 w0.076: 73.79,125.09 74.78,126.08 74.78,130.93 74.58,131.13 74.58,137.68 71.4,140.86 70.99,141.27 65.99,141.27 64.55,139.83 64.28,139.83 63.88,139.42 63.88,139.42 63.86,139.4 63.86,139.35 v10(63.78,139.28)
M_B_DQ_12: length 33.3
  IN3 w0.06: 74.24,124.76 74.18,124.7 74.18,123.01 74.24,122.95 74.24,122.67 74.24,122.67 74.31,122.6 74.31,122.44 74.16,122.28 74.08,122.28 73.78,121.99 v10(73.78,121.78)
  IN3 w0.076: 74.24,124.76 75.39,125.9 75.39,131.13 75.13,131.39 75.13,137.94 71.4,141.67 71.27,141.8 65.69,141.8 64.26,140.38 64.06,140.38 63.06,139.37 63.06,138.62 63.15,138.53 v10(63.78,138.28)
M_B_DQ_13: length 29.3
  IN3 w0.06: v10(73.14,122.27) 73.02,122.39 73.02,122.6 72.94,122.68 72.94,122.85 72.96,122.87 72.96,125.4 73.76,126.21
  IN3 w0.076: 73.76,126.21 73.76,130.65 73.61,130.8 73.61,137.35 70.56,140.41 66.54,140.41 65.54,139.41 65.54,138.38 65.54,138.38 65.54,137.01 65.45,136.92 65.12,136.92 65.04,137 65.04,137.7 64.97,137.78 v10(64.78,137.78)
M_B_DQ_14: length 30.5
  IN3 w0.06: v10(73.78,122.27) 73.78,122.48 73.98,122.68 73.98,122.7 73.98,122.87 73.89,122.97 73.89,124.89 73.89,124.9 73.89,124.96 73.94,125.01
  IN3 w0.076: 73.94,125.01 74.98,126.05 74.98,131.03 74.75,131.26 74.75,137.78 71.4,141.14 71.09,141.45 65.89,141.45 64.45,140.01 64.17,140.01 63.54,139.38 63.54,139.04 v10(63.28,138.78)
M_B_DQ_15: length 30.2
  IN3 w0.06: 74.09,124.89 74.02,124.82 74.02,123 74.11,122.92 v10(74.11,122.52)
  IN3 w0.076: v10(63.28,139.28) 63.39,139.39 63.39,139.44 64.13,140.18 64.35,140.18 65.79,141.62 71.18,141.62 71.4,141.41 74.93,137.88 74.93,131.34 75.18,131.08 75.18,125.98 74.09,124.89
M_B_DQ_16: length 11.4
  IN4 w0.06: 68.17,125.15 68.18,125.15 68.18,124.53 68.31,124.39 v5(68.31,124)
  IN4 w0.061: 68.17,125.15 64.59,128.74 64.59,129.45 64.67,129.53 64.67,130.81 63.82,131.66 63.82,131.85 63.53,132.15 63.53,132.87 63.78,133.12 v5(63.78,133.28)
M_B_DQ_17: length 12.6
  IN4 w0.06: v5(67.99,124.24) 67.93,124.3 67.93,124.99
  IN4 w0.061: v5(63.28,133.78) 63.03,133.53 63.03,133.17 62.87,133.01 62.69,133.01 62.54,132.86 62.54,132.15 62.67,132.02 62.88,132.02 63.03,131.87 63.03,131.68 63.44,131.27 63.78,131.27 64.3,130.74 64.3,129.73 64.26,129.69 64.26,128.67 67.93,124.99
M_B_DQ_18: length 12.4
  IN4 w0.06: v5(68.31,123.5) 68.4,123.59 68.4,123.79 68.51,123.91 68.51,124.18 68.51,124.36 68.3,124.58 68.3,125.23 66.93,126.59 66.93,126.59
  IN4 w0.061: 66.93,126.59 64.74,128.79 64.74,129.3 64.86,129.42 64.86,130.88 64.01,131.73 64.01,133.39 63.78,133.62 v5(63.78,133.78)
M_B_DQ_19: length 14.3
  IN4 w0.06: 67.13,124.75 67.13,124.66 67.35,124.44 67.35,124.13 67.35,123.75 v5(67.34,123.75)
  IN4 w0.061: v5(62.78,134.28) 62.62,134.28 62.52,134.18 62.52,134.18 62.36,134.01 62.2,134.01 62.06,133.88 61.52,133.88 61.19,133.55 61.19,131.24 62.65,129.78 62.8,129.78 63.17,129.41 63.17,128.71 67.13,124.75
M_B_DQ_20: length 12.8
  IN4 w0.061: v5(67.34,124.73) 63.35,128.72 63.35,129.48 62.87,129.96 62.71,129.96 61.37,131.3 61.37,133.41 61.64,133.68 62.19,133.68 v5(62.28,133.78)
  BOTTOM w0.119: UC1.BN25 67.34,124.24 UC1.BN25 ; UC1.BN25 v5(67.34,124.73)
M_B_DQ_21: length 13.4
  IN4 w0.06: 68.05,125.08 68.05,125.04 68.06,125.04 68.06,124.94 68.05,124.94 68.05,124.46 68.19,124.33 68.19,124.16 68.07,124.04 68.07,123.83 v5(67.99,123.75)
  IN4 w0.061: v5(63.28,134.28) 63.28,134.12 63.54,133.86 63.54,133.17 63.38,133.01 63.17,133.01 63.02,132.86 63.02,132.17 63.17,132.02 63.39,132.02 63.52,131.89 63.52,131.75 64.5,130.77 64.5,129.56 64.44,129.5 64.44,128.7 68.05,125.08
M_B_DQ_22: length 14.7
  IN4 w0.06: 67.01,124.68 67.01,124.58 67.21,124.39 67.21,124.11 67.22,124.1 67.22,123.91 67.14,123.83 67.14,123.82 67.13,123.81 67.13,123.68 67.34,123.47 v5(67.34,123.26)
  IN4 w0.061: 67.01,124.68 63.02,128.66 63.02,129.3 62.76,129.56 62.58,129.56 61.01,131.13 61.01,133.65 61.42,134.05 61.93,134.05 62.15,134.28 v5(62.28,134.28)
M_B_DQ_23: length 14.7
  IN4 w0.06: 67.36,124.94 67.42,124.94 67.56,124.8 67.56,124.46 67.51,124.41 67.51,124.13 67.47,124.08 67.47,124.08 67.47,123.91 67.56,123.82 67.56,123.68 67.47,123.59 67.47,123.42 67.58,123.3 67.58,123.3 67.63,123.26 v5(67.99,123.26)
  IN4 w0.061: 67.36,124.94 63.53,128.77 63.53,129.56 62.97,130.12 62.79,130.12 61.55,131.36 61.55,133.37 61.68,133.5 62.48,133.5 62.76,133.78 v5(62.78,133.78)
M_B_DQ_24: length 18.7
  IN4 w0.06: v5(67.02,124) 67.02,124.36 66.86,124.53 66.86,124.64 66.2,125.29
  IN4 w0.061: 66.2,125.29 62.62,128.87 60.78,128.87 60.58,129.08 60.58,133.55 61.16,134.12 61.16,135.08 61.46,135.38 62.35,135.38 62.5,135.54 62.87,135.54 63.04,135.7 63.04,135.85 63.2,136.02 63.46,136.02 63.55,136.11 63.55,136.37 63.78,136.61 v5(63.78,136.78)
M_B_DQ_25: length 22
  IN4 w0.06: 65.37,124.45 65.4,124.45 65.73,124.11 65.86,123.99 65.86,123.83 65.86,123.83 65.86,123.67 65.86,123.67 65.86,123.62 65.98,123.5 66.1,123.5 66.27,123.33 66.27,123.33 66.29,123.3 66.46,123.3 66.48,123.33 66.48,123.33 66.62,123.46 66.62,123.46 66.67,123.5 67.02,123.5 v5(67.02,123.5)
  IN4 w0.061: 65.37,124.45 65.22,124.59 65.22,125.08 62.57,127.73 60.2,127.73 59.36,128.57 59.36,134.31 59.82,134.76 59.82,135.58 61.15,136.91 61.15,137.46 61.7,138.01 62.55,138.01 v5(62.78,137.78)
M_B_DQ_26: length 19.8
  IN4 w0.06: 65.46,124.78 65.55,124.69 65.55,124.67 65.76,124.47 65.76,124.46 65.9,124.32 65.95,124.32 66.03,124.24 v5(66.05,124.24)
  IN4 w0.061: 65.46,124.78 65.46,125.18 62.6,128.04 60.37,128.04 59.72,128.7 59.72,134.11 60.2,134.59 60.2,135.45 61.39,136.64 61.51,136.76 61.51,137.34 61.7,137.52 63.03,137.52 v5(63.28,137.78)
M_B_DQ_27: length 23.3
  IN4 w0.06: v5(66.7,123.26) UC1.BJ23 66.7,123.05 66.45,122.8 66.31,122.8 66.05,123.06 65.99,123.06 65.99,123.06 65.97,123.06 65.78,123.25 65.78,123.33 65.61,123.5 65.61,123.83 64.84,124.61 64.84,125.1 62.89,127.04 62.51,127.43 61.62,127.43
  IN4 w0.061: 61.62,127.43 59.99,127.43 58.98,128.44 58.98,128.78 58.98,128.78 58.98,134.46 59.45,134.94 59.45,135.83 60.79,137.16 60.79,137.66 61.64,138.51 62.55,138.51 v5(62.78,138.28)
M_B_DQ_28: length 19.2
  IN4 w0.06: v5(66.7,123.75) UC1.BL23 66.7,123.96 66.5,124.16 66.5,124.42 66.24,124.68 66.22,124.68 66.05,124.68 65.91,124.82 65.91,124.86 65.82,124.94 65.82,125.33 62.58,128.57 62.26,128.57
  IN4 w0.061: v5(63.28,137.28) 63.28,137.13 63.04,136.88 63.04,136.66 62.89,136.52 62.06,136.52 60.75,135.21 60.75,134.3 60.25,133.8 60.25,128.92 60.61,128.57 62.26,128.57
M_B_DQ_29: length 19
  IN4 w0.06: v5(66.7,124.24) UC1.BN23 66.7,124.6 66.19,125.11 66.19,125.14 65.99,125.33
  IN4 w0.061: 65.99,125.33 62.6,128.72 60.71,128.72 60.43,129 60.43,133.67 60.96,134.21 60.96,135.1 61.41,135.55 61.88,135.55 62.03,135.7 62.03,135.9 62.15,136.02 62.87,136.02 63.04,136.18 63.04,136.41 63.15,136.53 63.37,136.53 63.54,136.7 63.54,137.04 v5(63.78,137.28)
M_B_DQ_30: length 20.9
  IN4 w0.06: v5(66.05,123.26) 66.03,123.26 65.73,123.55 65.73,123.88 65.11,124.51 65.11,124.53 65.1,124.54 65.1,125.01 62.94,127.17
  IN4 w0.061: v5(62.28,138.28) 61.7,138.28 60.96,137.54 60.96,137.05 59.64,135.73 59.64,134.87 59.18,134.41 59.18,128.49 60.09,127.58 62.53,127.58 62.94,127.17
M_B_DQ_31: length 19.6
  IN4 w0.06: v5(66.05,123.75) 65.98,123.83
  IN4 w0.061: 65.98,123.83 65.98,123.94 65.98,124.04 65.97,124.04 65.85,124.16 65.34,124.67 65.34,125.13 62.59,127.89 60.27,127.89 59.54,128.62 59.54,134.2 59.99,134.65 59.99,135.49 61.31,136.8 61.31,137.38 61.71,137.78 v5(62.28,137.78)
M_B_DQ_32: length 26.4
  IN4 w0.06: 73.78,125.46 v5(73.78,124.24)
  IN4 w0.061: 73.78,125.46 73.78,125.88 74.69,126.78 74.69,127.2 74.83,127.34 74.87,127.34 74.98,127.45 74.98,127.71 74.69,128 74.69,128.99 74.73,129.03 74.73,137.81 71.52,141.02 66.71,141.02 65.52,139.84 65.52,139.02 v5(65.28,138.78)
M_B_DQ_33: length 28.5
  IN4 w0.06: 74.2,125.79 74.2,125.14 74.04,124.98 74.04,124.46 74.11,124.4 v5(74.11,124)
  IN4 w0.061: 74.2,125.79 74.2,125.85 75.03,126.69 75.03,126.89 75.3,127.16 75.3,127.9 75.01,128.19 75.01,128.77 75.08,128.85 75.08,137.97 71.65,141.4 66.57,141.4 65.02,139.86 65.02,138.44 65.18,138.28 v5(65.28,138.28)
M_B_DQ_34: length 25.5
  IN4 w0.06: 72.87,125.55 72.87,124.5 72.94,124.43 72.94,124.16 73.02,124.08 73.02,123.87 v5(73.14,123.75)
  IN4 w0.061: v5(65.28,137.78) 65.52,138.02 65.52,138.38 65.66,138.52 65.96,138.52 66.06,138.62 66.06,138.9 66.17,139.02 68.35,139.02 68.53,139.19 68.53,139.59 69.03,140.1 71.25,140.1 73.81,137.53 73.81,127.92 73.9,127.84 73.9,127.13 72.9,126.13 72.9,125.59 72.87,125.55
M_B_DQ_35: length 30
  IN4 w0.06: v5(74.11,123.5) 74.22,123.5 74.43,123.72 74.43,124.13 74.43,124.13 74.43,124.41 74.66,124.64 74.66,124.98 74.53,125.11 74.53,125.73 75.31,126.5 75.31,126.63 75.34,126.66
  IN4 w0.061: v5(64.78,138.78) 64.56,139.01 64.56,139.91 66.4,141.75 71.86,141.75 75.41,138.2 75.41,128.71 75.3,128.59 75.3,128.35 75.59,128.06 75.59,126.91 75.34,126.66
M_B_DQ_36: length 24.1
  IN4 w0.06: v5(73.14,124.24) 73.14,124.39 72.99,124.55 72.99,125.44 73.02,125.48
  IN4 w0.061: v5(65.78,138.78) 65.78,138.92 66.17,139.3 66.43,139.3 66.66,139.52 67.38,139.52 67.64,139.78 67.64,140 67.92,140.29 71.32,140.29 74.01,137.59 74.01,128.34 74.01,128.34 74.01,127.94 74.07,127.89 74.07,127.05 73.08,126.07 73.08,125.54 73.02,125.48
M_B_DQ_37: length 27.1
  IN4 w0.06: v5(73.78,123.75) 73.78,123.96 73.98,124.16 73.98,124.33 73.9,124.41 73.9,125.03 74,125.12 74,125.46
  IN4 w0.061: 74,125.46 74,125.88 74.84,126.72 74.84,127.01 74.99,127.16 75.02,127.16 75.15,127.29 75.15,127.8 74.84,128.1 74.84,128.86 74.91,128.92 74.91,137.89 71.6,141.2 66.61,141.2 65.28,139.87 v5(65.28,139.28)
M_B_DQ_38: length 29.1
  IN4 w0.06: 74.35,125.78 74.35,125.11 74.17,124.93 74.17,124.51 74.3,124.38 74.3,124.09 74.31,124.08 74.31,123.84 74.19,123.73 74.05,123.73 73.78,123.47 v5(73.78,123.26) ; 75.45,127.03 75.45,127.49
  IN4 w0.061: 75.45,127.03 75.18,126.77 75.18,126.61 74.35,125.78 ; v5(64.78,139.28) 64.78,139.89 66.48,141.58 71.75,141.58 75.25,138.08 75.25,128.74 75.16,128.65 75.16,128.29 75.45,128 75.45,127.49
M_B_DQ_39: length 26.4
  IN4 w0.06: 73.61,125.46 73.61,125.04 73.67,124.98 73.67,124.41 73.58,124.33 73.58,124.16 73.66,124.08 73.66,123.91 73.58,123.83 73.58,123.67 73.61,123.64 73.61,123.64 73.66,123.59 73.66,123.42 73.5,123.26 v5(73.14,123.26)
  IN4 w0.061: v5(65.78,139.28) 66.03,139.53 66.03,139.89 66.98,140.84 71.47,140.84 74.54,137.78 74.54,126.85 73.61,125.92 73.61,125.46
M_B_DQ_40: length 19.8
  IN4 w0.06: v5(72.82,124) 72.82,124.11 72.82,124.11 72.82,124.38 72.82,124.38 72.73,124.46 72.73,124.86 72.7,124.89 72.7,126
  IN4 w0.061: 72.7,126 72.7,126.26 73.46,127.02 73.46,129.78 73.05,130.19 73.05,132.05 72.89,132.21 72.89,138.08 71.07,139.9 69.4,139.9 v5(68.78,139.28)
M_B_DQ_41: length 19.1
  IN4 w0.06: v5(72.5,124.24) 72.45,124.29 72.45,124.65 72.39,124.71 72.39,126.32
  IN4 w0.061: v5(68.78,138.78) 69.04,139.03 69.41,139.03 69.52,139.15 69.52,139.36 69.68,139.52 70.9,139.52 72.56,137.86 72.56,132.03 72.67,131.92 72.67,130.07 73.15,129.59 73.15,127.22 72.39,126.46 72.39,126.32
M_B_DQ_42: length 18.2
  IN4 w0.06: 71.52,126.91 71.52,124.4 71.53,124.4 71.53,124.11 71.53,124.11 71.53,123.88 71.53,123.79 71.65,123.67 71.77,123.55 71.85,123.55 72.14,123.26 v5(72.5,123.26)
  IN4 w0.061: 71.52,126.91 71.52,127.14 71.62,127.24 71.88,127.5 71.88,128.11 72.04,128.26 72.04,128.72 71.6,129.15 71.6,131.41 71.45,131.57 71.45,136.92 70.14,138.23 69.62,138.23 69.43,138.05 69.39,138.05 69.38,138.04 69.18,138.04 69.18,138.05 69.05,138.05 v5(68.78,137.78)
M_B_DQ_43: length 17
  IN4 w0.06: v5(71.85,124.24) 71.8,124.3 71.8,126.81
  IN4 w0.061: v5(68.78,138.28) 69.04,138.53 70.36,138.53 71.82,137.07 71.82,131.78 71.96,131.64 71.96,129.26 72.34,128.87 72.34,128.13 72.21,128.01 72.21,127.3 71.92,127.01 71.8,126.88 71.8,126.81
M_B_DQ_44: length 19.6
  IN4 w0.06: 72.54,126.22 72.54,124.81 72.57,124.78 72.57,124.45 72.7,124.33 72.7,124.16 72.7,124.16 72.64,124.11 72.64,124.11 72.62,124.08 72.62,123.91 72.74,123.8 72.82,123.71 v5(72.82,123.51)
  IN4 w0.061: 72.54,126.22 72.54,126.36 73.31,127.12 73.31,129.69 72.87,130.12 72.87,131.97 72.73,132.11 72.73,137.97 71.01,139.69 69.56,139.69 69.28,139.42 v5(69.28,139.28)
M_B_DQ_45: length 18.6
  IN4 w0.06: 72.24,126.48 72.24,124.66 72.31,124.58 72.31,124.34 72.3,124.33 72.3,124.16 72.5,123.96 v5(72.5,123.75)
  IN4 w0.061: v5(69.28,138.78) 69.43,138.78 69.69,139.04 69.92,139.04 70.07,139.19 70.94,139.19 72.39,137.74 72.39,131.95 72.49,131.85 72.49,130 73,129.49 73,127.35 72.24,126.59 72.24,126.48
M_B_DQ_46: length 16.8
  IN4 w0.06: v5(71.85,123.75) 71.65,123.96 71.65,124.37 71.66,124.38 71.66,126.83
  IN4 w0.061: v5(69.28,138.28) 69.38,138.38 70.26,138.38 71.65,136.99 71.65,131.68 71.78,131.54 71.78,129.2 72.19,128.8 72.19,128.18 72.06,128.06 72.06,127.4 71.66,127 71.66,126.83
M_B_DQ_47: length 17.1
  IN4 w0.06: v5(71.85,123.26) 71.49,123.26 71.33,123.42 71.33,123.59 71.41,123.67 71.41,123.83 71.4,123.84 71.4,124.15 71.41,124.16 71.41,124.35 71.38,124.38 71.38,125.39 71.38,126.93
  IN4 w0.061: 71.38,126.93 71.38,127.25 71.49,127.37 71.71,127.58 71.71,128.18 71.86,128.33 71.86,128.62 71.43,129.05 71.43,131.35 71.26,131.51 71.26,136.85 70.05,138.06 69.67,138.06 69.49,137.89 69.39,137.89 v5(69.28,137.78)
M_B_DQ_48: length 14.9
  IN3 w0.06: v10(68.31,122.52) 68.34,122.55 68.34,123.65 63.96,128.03 63.96,128.07
  IN3 w0.076: v10(63.28,132.78) 63.2,132.86 63.2,133.54 63.27,133.6 63.38,133.6 63.43,133.54 63.43,133.04 63.54,132.93 63.54,132.2 63.69,132.05 63.8,132.05 64.77,131.08 64.77,130.24 63.96,129.43 63.96,128.07
