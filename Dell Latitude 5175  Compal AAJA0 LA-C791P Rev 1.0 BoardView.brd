# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RP_DP_N1_C: length 2.4
  TOP w0.119: CV21.1 126.11,104.27 126.11,104.69 125.58,105.22 125.58,105.67 125.47,105.79 UV1.19
RP_DP_N2: length 11.8
  TOP w0.119: v1(124.23,101.32) 124.4,101.49 124.4,103.13 124.48,103.21 124.48,103.43 D14.1 124.48,103.81 124.48,104.15 CV15.2
  IN1 w0.109: v2(124.2,100.94) 124.2,101.29 v1(124.23,101.32)
  IN2 w0.079: v2(124.2,100.94) 124.38,100.76 124.38,98.24 124.4,98.22 124.4,98.22 126.41,96.21 126.41,95.48 v2(126.26,95.33)
  IN3 w0.084: v2(126.26,95.33) 126.47,95.12 126.47,94.75 126.35,94.63 v7(126.34,94.63)
  BOTTOM w0.119: v7(126.34,94.63) 126.35,94.63 126.4,94.67 126.4,94.85 126.32,94.93 JIO4.74
RP_DP_N2_C: length 1.6
  TOP w0.119: CV15.1 124.48,105.02 124.48,105.1 124.09,105.5 124.09,105.73 123.97,105.85 UV1.16
RP_DP_N3: length 11.1
  TOP w0.119: CV19.2 122.88,103.43 122.88,103.03 D19.1 122.93,102.64 122.93,101.5 v1(122.75,101.31)
  IN1 w0.109: v2(122.65,100.97) 122.57,101.06 122.57,101.2 122.68,101.31 v1(122.75,101.31)
  IN2 w0.079: v2(125.06,95.35) 125.22,95.52 125.22,96 122.83,98.39 122.83,100.79 v2(122.65,100.97)
  IN3 w0.084: v7(125.15,94.68) 125.22,94.76 125.22,95.19 v2(125.06,95.35)
  BOTTOM w0.119: JIO4.80 125.12,94.7 v7(125.15,94.68)
RP_DP_N3_C: length 2.3
  TOP w0.119: UV1.13 122.47,105.56 122.58,105.45 122.58,105.15 122.93,104.81 122.93,104.33 CV19.1
RP_DP_P0: length 11.7
  TOP w0.119: CV18.2 127.92,104.12 127.92,103.87 D18.1 127.98,103.36 127.98,102.1 127.72,101.84 127.72,101.47 v1(127.84,101.35)
  IN1 w0.109: v2(127.84,100.95) v1(127.84,101.35)
  IN2 w0.079: v2(129.18,95.3) 129,95.48 129,96.79 127.63,98.16 127.63,98.24 127.63,100.75 v2(127.84,100.95)
  IN3 w0.084: v7(129.11,94.6) 129,94.71 129,95.11 v2(129.18,95.3)
  BOTTOM w0.119: JIO4.60 129.12,94.92 129.04,94.84 129.04,94.67 v7(129.11,94.6)
RP_DP_P0_C: length 1.8
  TOP w0.119: UV1.23 127.47,105.77 127.35,105.65 127.35,105.58 127.42,105.5 127.69,105.5 127.91,105.27 127.91,105.01 CV18.1
RP_DP_P1: length 11
  TOP w0.119: v1(126.31,101.35) 126.25,101.35 126.16,101.44 126.16,102.19 126.32,102.34 126.32,102.57 D22.1 126.34,103 126.34,103.36 CV22.2
  IN1 w0.109: v1(126.31,101.35) 126.27,101.3 v2(126.27,100.98)
  IN2 w0.079: v2(128.03,95.3) 127.85,95.47 127.85,96.3 127.13,97.02 127.13,97.03 126.09,98.07 126.09,100.79 v2(126.27,100.98)
  IN3 w0.084: v2(128.03,95.3) 127.84,95.11 127.84,94.69 v7(127.91,94.62)
  BOTTOM w0.119: JIO4.66 127.92,94.87 127.87,94.82 127.87,94.66 v7(127.91,94.62)
RP_DP_P1_C: length 2.4
  TOP w0.119: UV1.20 125.97,105.75 125.85,105.63 125.85,105.33 126.37,104.8 126.37,104.29 CV22.1
RP_DP_P2: length 11.8
  TOP w0.119: v1(124.79,101.32) 124.66,101.45 124.66,103.02 124.74,103.1 124.74,103.4 D15.1 124.74,103.85 124.74,104.14 CV16.2
  IN1 w0.109: v2(124.73,100.97) 124.79,101.02 v1(124.79,101.32)
  IN2 w0.079: v2(124.73,100.97) 124.56,100.8 124.56,98.32 126.59,96.29 126.59,95.53 v2(126.79,95.33)
  IN3 w0.084: v7(126.73,94.63) 126.63,94.73 126.63,95.17 v2(126.79,95.33)
  BOTTOM w0.119: v7(126.73,94.63) 126.66,94.71 126.66,94.83 126.72,94.9 JIO4.72
RP_DP_P2_C: length 1.6
  TOP w0.119: UV1.17 124.47,105.81 124.35,105.69 124.35,105.6 124.74,105.21 124.74,105.03 CV16.1
RP_DP_P3: length 11.1
  TOP w0.119: CV20.2 123.14,103.39 123.14,103.1 D20.1 123.19,102.67 123.19,101.48 v1(123.34,101.33)
  IN1 w0.109: v2(123.19,100.97) 123.19,101.18 v1(123.34,101.33)
  IN2 w0.079: v2(123.19,100.97) 123.02,100.79 123.02,98.47 125.41,96.08 125.41,95.54 v2(125.59,95.35)
  IN3 w0.084: v7(125.53,94.68) 125.38,94.82 125.38,95.17 125.56,95.35 v2(125.59,95.35)
  BOTTOM w0.119: JIO4.78 125.52,94.69 v7(125.53,94.68)
RP_DP_P3_C: length 2.3
  TOP w0.119: CV20.1 123.19,104.26 123.19,104.92 122.85,105.26 122.85,105.45 122.97,105.56 UV1.14
RP_PEQ: length 2.7
  TOP w0.119: RV9.2 RV8.2 119.99,110.2 120.75,110.96 UV1.4
RPDP_CBL_DET: length 1.4
  TOP w0.119: UV2.10 22.67,50.04 RV21.1
RTC_RST#: length 206.9
  TOP w0.119: CLRP2.2 55.46,126.91 v1(55.57,126.91) ; JAPS2.10 71.14,130.74 v1(71.41,131)
  IN1 w0.084: v1(55.57,126.91) 55.71,126.78 55.71,126.53 v2(55.85,126.38) 56.32,126.84 57.22,126.84 57.36,126.98 58.52,126.98 58.68,127.14 59.76,127.14 63.44,130.82 65.39,130.82 65.86,131.3 70.86,131.3 71.16,131 v1(71.41,131) 71.48,130.93 72.23,130.93 73.01,130.15 75.19,130.15 76.13,131.09 77.16,131.09 77.68,131.61 86,131.61 87.6,133.21 98.15,133.21 98.51,132.85 98.51,132.8 v2(98.63,132.68)
  IN3 w0.084: v3(193.26,112.77) 193.31,112.82 197.41,112.82 198.25,113.65 v7(198.58,113.65) ; v2(55.85,126.38) 55.63,126.61 55.63,127.29 v7(55.6,127.32) ; v2(98.63,132.68) v3(99.11,132.68)
  IN4 w0.089: v3(193.26,112.77) 192.44,112.77 189.03,109.36 183.15,109.36 179.74,105.95 175.49,105.95 169.6,111.85 169.6,115.15 170.1,115.66 170.1,121.04 170.49,121.43 170.49,124.88 171.31,125.69 171.65,125.69 172.36,126.41 172.36,130.95 168.94,134.38 154.25,134.38 153.54,133.67 151.64,133.67 151.28,134.03 139.44,134.03 137.62,132.21 137.25,132.21 136.65,131.61 134.31,131.61 134.08,131.39 133.37,131.39 132.07,130.09 126.51,130.09 125.75,130.85 124.62,130.85 121.69,133.77 117.25,133.77 116.99,134.03 112.36,134.03 112.21,134.17 104.23,134.17 102.6,132.54 99.25,132.54 v3(99.11,132.68)
  BOTTOM w0.06: T20.1 57.58,126.57 57.14,127.02 55.91,127.02 v7(55.6,127.32)
  BOTTOM w0.076: UC1.BN12 63.48,124.6 62.33,125.75 59.25,125.75 58.66,126.34 58.27,126.34 58.04,126.57 T20.1
  BOTTOM w0.119: v7(198.58,113.65) 198.58,111.75 199.19,111.14 v14(200.84,111.14) 201.47,111.14 201.87,111.53 202.86,111.53 203.58,112.26 203.58,112.58 204.9,113.9 R400.1
RTCRST_ON: length 27.6
  IN4 w0.089: v4(194.32,135.74) 194.32,135.66 195.08,134.9 195.24,134.9 196.5,133.64 196.5,132.3 196.94,131.87 196.94,131.56 197.57,130.92 197.57,129.8 198.16,129.22 198.6,129.22 199.36,129.98 201.13,129.98 204.5,126.61 204.5,119.76 v5(203.95,119.22)
  BOTTOM w0.254: Q15.2 206.18,119.64 205.89,119.93 204.58,119.93 203.95,119.3 v5(203.95,119.22)
RUN_ON: length 1.8
  BOTTOM w0.119: U34.D1 195.28,135.78 R337.1
RUN_ON_EC: length 429.3
  TOP w0.119: v1(68.01,100.35) 68.01,101.96 68.38,102.33 R171.1 ; U7.3 v1(108.3,129.52) ; v13(34.86,73.69) 34.86,73.97 35.26,74.36 38.52,74.36 39.85,75.7 41.86,75.7 42.71,74.86 42.71,73.16 42.02,72.48 U26.3 ; v1(200.51,129.35) 200.05,129.81 UH1.2 ; PR709.1 129.72,118.02 129.72,119.64 130.06,119.98 v1(131.32,119.98) 136.49,119.98 v1(136.52,120.02) ; U22.5 50.16,103.82 50.31,103.97 50.98,103.97 51.35,103.6 v1(51.35,103.57)
  IN1 w0.084: v2(40.26,116.12) 39.97,115.83 37.84,115.83 37.64,115.64 33.26,115.64 32.25,114.62 29.07,114.62 v1(28.93,114.76) ; v1(200.51,129.35) 200.26,129.11 v2(199.06,129.11) ; v2(91.88,100.4) 91.05,101.22 88.15,101.22 87.96,101.04 85.4,101.04 84.29,99.92 82.47,99.92 80.27,97.72 70.45,97.72 v2(70.23,97.5) 70.03,97.71 64.03,97.71 63.83,97.91 62.75,97.91 61.55,99.11 56.47,99.11 55.12,100.45 53.5,100.45 51.43,102.52 51.43,103.49 v1(51.35,103.57) 51.17,103.39 50.93,103.39 v2(50.37,102.83) ; v1(31.24,130.42) 28.22,130.42 25.62,127.82 25.62,126.87 24.17,125.42 24.17,124.42 23.67,123.93 23.67,117.93 24.02,117.59 25.97,117.59 26.4,117.16 26.4,116.04 26.26,115.9 24.83,115.9 24.61,115.69 24.61,114.71 24.97,114.35 27.6,114.35 28.15,113.8 28.15,110.64 27.75,110.24 25.01,110.24 23.43,108.66 23.43,102.05 v2(24.95,100.53) ; v1(131.32,119.98) 131.23,120.07 123.89,120.07 123.33,119.5 121.88,119.5 121.79,119.59 119.34,119.59 118.92,119.17 117.51,119.17 117.08,118.74 117.08,118.46 116.5,117.87 115.9,117.87 115.44,118.33 115.44,119.1 115.23,119.3 115.23,120.65 112.42,123.47 112.42,124.76 111.65,125.52 111.65,126.29 109,128.95 108.48,128.95 108.3,129.12 v1(108.3,129.52) ; v1(68.01,100.35) v2(67.34,100.35) ; v2(23.55,66.87) 23.55,66.92 25.81,69.18 32.94,69.18 35.04,71.27 35.04,73.51 v13(34.86,73.69) ; v2(133.44,117.41) 134.34,117.41 136.52,119.59 v1(136.52,120.02) 136.83,120.32 141.39,120.32 144.28,123.21 147.4,123.21 149.52,125.33 150.69,125.33 v1(151.65,124.36) 151.65,126.38 151.54,126.49 151.54,127.68 v2(151.41,127.8)
  IN1 w0.109: v2(36.06,100.94) 36.09,100.9 v1(36.09,100.55)
  IN2 w0.079: v2(24.95,100.53) 35.45,100.53 35.8,100.88 35.99,100.88 v2(36.06,100.94) 39.6,104.49 46.94,104.49 47.27,104.15 47.66,104.15 47.91,103.91 48.51,103.91 49.59,102.83 v2(50.37,102.83)
  IN3 w0.084: v2(23.55,66.87) 23.33,67.08 v3(23.14,67.08) ; v2(40.26,116.12) 41.14,116.12 42.08,115.17 42.08,111.57 40.89,110.38 v7(40.89,109.64) 40.77,109.53 40.77,107.22 41.28,106.71 41.28,101.13 41.03,100.88 v3(36.5,100.88) 36.12,100.88 v2(36.06,100.94) ; v3(133.41,118.09) 133.41,117.44 v2(133.44,117.41) ; v2(70.23,97.5) 68.63,97.5 66.23,99.9 66.23,100.3 66.42,100.5 67.18,100.5 v2(67.34,100.35) ; v3(92.23,100.38) 92.21,100.4 v2(91.88,100.4) ; v2(199.06,129.11) 198.9,128.95 v7(198.58,128.95) 198.58,129.53 198.52,129.59 198.52,130.65 v3(198.45,130.72) 198.36,130.81 198.06,130.81 197.32,131.55 195.63,131.55 195.35,131.28 193.81,131.28 190.05,127.52 185.28,127.52 184.33,128.47 175.48,128.47 173.2,130.74 167.29,130.74 165.45,132.59 156.58,132.59 151.79,127.8 v2(151.41,127.8)
  IN4 w0.089: v3(198.45,130.72) 198.45,130.73 198.34,130.84 198.34,131.24 197.7,131.88 197.7,135.44 v4(197.36,135.78) ; v3(36.5,100.88) 36.42,100.88 33.6,98.06 33.6,89.05 38.35,84.31 38.35,77.42 34.86,73.93 v13(34.86,73.69) ; v3(23.14,67.08) 20.24,64.18 v4(20.24,59.79) ; v3(92.23,100.38) 92.23,100.7 92.7,101.18 93.83,101.18 94.08,100.93 94.97,100.93 95.4,100.49 97.43,100.49 97.86,100.92 100.94,100.92 101.74,101.72 106.78,101.72 107.89,100.61 108.89,100.61 108.99,100.71 110.9,100.71 111.06,100.88 112.34,100.88 113.79,102.33 113.79,103.93 115.72,105.86 115.72,107.1 116.24,107.63 116.25,107.63 118.36,109.73 118.36,110.74 120.4,112.79 123.44,112.79 124.62,113.96 127.38,113.96 128.6,115.18 128.6,115.98 128.84,116.22 129.44,116.22 129.76,116.54 129.76,116.91 130.59,117.74 133.07,117.74 v3(133.41,118.09)
  BOTTOM w0.119: v14(39.46,112.04) 39.7,111.8 39.7,110.25 40.31,109.64 v7(40.89,109.64) 41.63,109.64 41.81,109.82 41.81,110.68 41.94,110.81 42.54,110.81 42.62,110.89 U38.2
RUNPWROK: length 388
  TOP w0.119: R35.1 43.23,134.12 43.05,133.94 41.97,133.94 v1(41.78,134.13) ; v1(132.34,102.29) 132.34,102.35 132.61,102.62 132.61,110.81 131.5,111.93 131.5,117.71 v1(131.25,117.95) ; R143.1 30.28,113.64 30.28,115.14 29.86,115.56 24.71,115.56 23.98,116.3 23.98,122.16 v13(24.27,122.45) ; R24.2 196.54,135.56 v1(196.25,135.27) ; v1(124.97,118.89) 124.97,118.04 124.8,117.87 R139.1
  IN1 w0.084: v2(195.81,135.47) 196,135.27 v1(196.25,135.27) ; v1(124.97,118.89) 125.03,118.89 125.45,118.47 129.63,118.47 130.15,117.95 v1(131.25,117.95) ; v1(132.34,102.29) 131.92,102.29 v2(131.81,102.17) ; v1(43.36,134.43) 43.36,134.71 v2(43.41,134.76) ; v1(41.78,134.13) 41.78,134.12 41.78,132.32 41.78,130.41 41.78,130.21 41.78,129.13 41.27,128.62 41.27,128.28 40.7,127.71 40.7,117.11 42.34,115.46 42.34,109.69 41.84,109.19 41.84,102.76 43.09,101.51 43.09,100.27 42.35,99.53 42.35,99.04 43.59,97.81 46.75,97.81 47.71,98.76 50.55,98.76 51.48,97.83 54.03,97.83 55.83,96.03 58.3,96.03 59.43,94.9 60.66,94.9 60.83,94.72 61.06,94.72 61.77,94.02 77.72,94.02 78.25,94.56 81.41,94.56 81.96,95.1 81.96,95.32 83.93,97.29 85.67,97.29 86.04,97.66 102.15,97.66 103.48,96.33 117.16,96.33 118.27,97.45 119,97.45 v2(119.48,96.97) ; v2(170.54,107.51) v1(170.54,105.7)
  IN2 w0.079: v2(195.81,135.47) 195.35,135.47 194.83,135.99 191.46,135.99 190.92,135.45 190.52,135.45 189.98,135.99 187.58,135.99 187.2,135.61 184.58,135.61 181.57,132.6 180.78,132.6 180.02,131.84 v2(180.01,131.84) ; v2(171.12,111.5) 170.84,111.22 170.84,108.02 170.54,107.71 v2(170.54,107.51)
  IN3 w0.084: v3(179.81,131.43) 180.01,131.64 v2(180.01,131.84) ; v2(43.41,134.76) 43.41,134.2 v3(43.26,134.05) ; v2(119.48,96.97) v7(119.86,96.97) ; v7(195.25,135.19) 195.54,135.19 v2(195.81,135.47) ; v7(131.52,102.45) 131.8,102.17 v2(131.81,102.17) ; v2(171.12,111.5) v3(171.12,111.9)
  IN4 w0.089: v7(195.25,135.19) 196.69,133.75 196.69,132.38 197.13,131.95 197.13,131.64 197.77,131 197.77,129.88 197.96,129.69 198.24,129.41 198.46,129.41 199.23,130.17 201.21,130.17 204.69,126.69 204.69,119.53 202.55,117.38 202.55,114.11 200.27,111.83 200.27,107.87 199.13,106.72 198.51,106.72 196.68,104.9 196.68,104.71 195.71,103.74 195.71,103.24 193.26,100.79 192.87,100.79 192.86,100.8 186.92,100.8 183.81,97.68 178.76,97.68 176.04,94.97 166.53,94.97 165.86,94.3 148.42,94.3 147.56,95.16 147.56,97.54 146.38,98.73 144.3,98.73 141.19,95.62 136.03,95.62 135.72,95.31 133.3,95.31 132.61,96 132.32,96 131.81,96.51 120.76,96.51 120.3,96.97 v7(119.86,96.97) ; v3(43.26,134.05) 42.96,134.34 30.94,134.34 27.85,131.26 27.85,130.88 27.55,130.57 27.16,130.57 25.35,128.76 v4(25.35,128.69) ; v3(179.81,131.43) 177.41,129.04 176.9,129.04 171.93,124.07 v4(171.93,121.3) 171.93,121.1 171.29,120.46 171.29,119.98 170.99,119.67 170.99,117.24 171.37,116.86 171.37,116.4 170.99,116.01 170.99,112.11 171.12,111.98 v3(171.12,111.9)
  BOTTOM w0.119: R364.1 24.82,128.69 24.08,127.96 24.08,122.64 v13(24.27,122.45) 24.27,122.11 24.47,121.91 R388.1 ; v7(131.52,102.45) 131.52,101.73 129.23,99.44 120.76,99.44 119.86,98.54 v7(119.86,96.97) ; v7(195.25,135.19) 195.21,135.24 U34.F1
RX_DE_0: length 4.3
  TOP w0.119: U27.3 v14(35.84,61.77) 35.02,61.77 R225.2 34.81,61.94 34.35,61.48 33.53,61.48 R223.2
RX_DE_1: length 3.5
  TOP w0.119: R233.2 R234.2 36.02,58.47 36.02,59.95 36.34,60.27 U27.6
RX_EQ_0: length 3.4
  TOP w0.119: U27.2 35.61,62.27 35.36,62.52 35.36,62.75 35.25,62.85 R222.2 34.85,63.74 R219.2
RX_EQ_1: length 3.1
  TOP w0.119: U27.4 36.38,61.27 36.16,61.04 R227.2 R229.2
SAR_DPR: length 18.3
  TOP w0.119: v1(202.77,144.06) 202.92,143.91 204.03,143.91 204.8,143.14 Q1.1
  IN1 w0.084: v2(202.18,144.24) 202.59,144.24 v1(202.77,144.06)
  IN2 w0.079: v2(202.18,144.24) 198.21,144.24 197.85,143.87 197.85,139.7 196.08,137.94 v2(195.83,137.94)
  IN3 w0.084: v2(195.83,137.94) 194.95,137.94 194.78,137.77 194,137.77 193.57,137.35 193.57,137.35 192.96,136.74 v10(192.82,136.74)
SAR_DPR_R: length 7
  TOP w0.119: Q1.3 208.04,143.79 v1(208.04,143.79)
  IN1 w0.084: v2(207.66,144.11) 207.72,144.11 v1(208.04,143.79)
  IN2 w0.079: v2(207.66,144.11) 206.07,144.11 v2(204.67,142.71)
  IN3 w0.084: v7(204.34,142.71) v2(204.67,142.71)
  BOTTOM w0.119: v7(204.34,142.71) 203.84,142.21 JNGFF1.17
SCLK: length 1.6
  IN1 w0.084: v1(113.74,120.36) 114.26,119.84 v2(114.26,119.76)
  IN3 w0.06: v2(114.26,119.76) 114.26,119.73 114.06,119.52 v6(114.06,119.45)
  IN4 w0.06: v6(114.06,119.45) 113.83,119.22 v4(113.83,119.2)
SD_PWR_EN: length 218.2
  TOP w0.119: U12.5 204.84,125.42 v1(204.69,125.26) 204.69,125.19 204.37,124.87 204.37,124.86 R483.2
  IN1 w0.084: v2(54.99,125.39) 56.48,125.39 56.79,125.69 57.13,125.69 57.25,125.82 58.05,125.82 58.55,126.32 58.79,126.32 58.95,126.48 60.74,126.48 64.42,130.16 65.64,130.16 65.98,130.5 70.75,130.5 71,130.24 71.98,130.24 72.72,129.5 75.46,129.5 76.4,130.44 77.43,130.44 77.95,130.96 86.27,130.96 87.86,132.56 90.02,132.56 90.68,131.9 92.81,131.9 93.39,132.47 97.74,132.47 97.99,132.21 98.73,132.21 99.59,133.07 104.61,133.07 105.33,133.79 109.62,133.79 112.54,130.86 112.54,129.83 114.07,128.3 116.98,128.3 117.5,127.78 118.33,127.78 119.3,126.81 122.17,126.81 122.86,126.12 126.88,126.12 127.75,125.26 130.54,125.26 131.75,126.47 132.71,126.47 135.19,128.95 136.83,128.95 138,130.13 140.04,130.13 140.3,130.39 143.02,130.39 143.62,130.99 145.33,130.99 146.18,131.84 146.89,131.84 148.58,133.54 152.81,133.54 153.08,133.26 168.3,133.26 172.3,129.26 178.21,129.26 179.46,130.52 180.2,130.52 180.82,131.14 180.82,132.58 182.12,133.88 182.12,135.03 184.17,137.07 184.96,137.07 185.54,137.66 185.54,138.71 187.03,140.2 188.23,140.2 191.3,143.28 194.61,143.28 197.02,145.69 202.38,145.69 202.93,145.14 204.11,145.14 207.35,141.9 208.54,141.9 208.88,141.56 208.88,140.79 208.72,140.63 208.72,135.47 209.18,135.02 211.68,135.02 212.84,133.86 212.84,130.16 212.44,129.76 212.44,126 211.35,124.92 206.68,124.92 205.89,125.71 205.13,125.71 v1(204.69,125.26)
  IN3 w0.084: v2(54.99,125.39) 54.99,125.89 54.88,126 54.88,126.57 v3(54.9,126.59)
  IN4 w0.06: v5(61.47,123.66) 61.47,123.81 61.4,123.89 61.39,123.89 61.27,124 61.27,124.01 61.25,124.04 61.25,124.25 60.9,124.6 59.46,124.6 59.16,124.3 58.42,124.3 57.24,125.48 57.11,125.48 56.51,126.08 56.31,126.08 55.87,126.52 55.41,126.52
  IN4 w0.089: 55.41,126.52 54.97,126.52 v3(54.9,126.59)
SDA: length 1
  IN1 w0.109: v2(114.24,118.65) 114.11,118.52 v1(113.74,118.52)
  IN3 w0.06: v7(113.83,118.7) 113.88,118.65 v2(114.24,118.65)
SDIO_RCOMP: length 4.3
  BOTTOM w0.381: RC39.2 56.97,123.76 57.89,123.76 58.73,122.92 59.39,122.92 59.8,122.51 60.55,122.51 60.61,122.45 UC1.BF1
SIM_VCC: length 3.7
  IN3 w0.381: v2(213.61,100.6) 213.61,100.59 214.22,99.98 v7(214.22,99.02)
  BOTTOM w0.203: v7(214.22,99.02) 214.22,98.55 213.83,98.16 JNFC1.4
  vias: v1(213.23,100.62) v1(213.33,100.37)
SIO_EXT_SCI#: length 265.8
  IN1 w0.084: v2(131.28,97.58) 131.22,97.64 118.18,97.64 117.07,96.52 103.57,96.52 102.24,97.85 85.97,97.85 85.59,97.47 83.85,97.47 81.77,95.39 81.77,95.17 81.34,94.74 78.03,94.74 77.6,94.31 61.74,94.31 61.14,94.91 60.91,94.91 60.74,95.08 59.57,95.08 58.44,96.21 55.91,96.21 54.11,98.01 51.56,98.01 50.62,98.95 47.63,98.95 46.67,97.99 43.66,97.99 42.54,99.11 42.54,99.46 43.79,100.71 v2(43.79,101.34)
  IN2 w0.079: v2(131.28,97.58) 131.28,100.55 131.04,100.78 131.04,102.93 v2(132.23,104.12)
  IN3 w0.06: 57.44,123.4 58.97,123.4 59.62,122.75 60.22,122.75 61.23,121.74 61.97,121.74 62.55,121.16 62.99,121.16 63.07,121.07 63.11,121.07 v10(63.35,120.84)
  IN3 w0.084: v2(132.23,104.12) 132.23,104.75 132.54,105.06 134.39,105.06 134.62,105.29 143.1,105.29 143.44,104.95 148.43,104.95 148.89,104.49 154.22,104.49 154.51,104.2 157.85,104.2 158.12,103.93 176.62,103.93 177.62,104.93 186.6,104.93 189.64,107.97 189.64,108.72 192.2,111.28 192.33,111.41 197.59,111.41 199.04,112.86 199.04,115.2 200.63,116.79 200.63,130.08 199.84,130.86 199.84,131.04 199.84,133.08 199.09,133.83 199.09,136.68 197.98,137.79 197.26,137.79 197.06,137.58 194.07,137.58 193.65,137.16 193.64,137.16 193.38,136.9 193.38,136.79 v10(193.32,136.74) ; v2(43.79,101.34) 43.79,101.46 v3(43.46,101.79) 43.24,102.01 43.24,108.11 43.77,108.64 43.77,109.63 43.61,109.78 43.61,110.29 43.61,110.29 43.61,110.67 43.8,110.86 43.8,115.93 42.22,117.52 42.22,120.13 42.41,120.32 42.41,120.55 42.03,120.93 42.03,123.1 42.2,123.27 42.2,124.42 42.62,124.84 43.29,124.84 44.5,126.04 46.79,126.04 47.07,125.77 47.19,125.65 48.17,125.65 48.51,125.99 50.56,125.99 51.1,125.44 51.27,125.44 51.45,125.26 52.06,125.26 52.28,125.04 54.18,125.04 54.39,124.84 55.19,124.84 55.52,124.5 55.91,124.11 56.73,124.11 57.44,123.4
  IN4 w0.089: v3(43.46,101.79) 43.54,101.72 46.43,101.72 47.14,101.01 49.02,101.01 49.53,101.51 49.53,102.33 48.93,102.92 48.92,102.92 v4(48.63,103.22)
SIO_EXT_SMI#: length 196.6
  IN3 w0.084: v3(61.57,103.44) 61.57,102.4 61.39,102.22 61.39,99.71 62.29,98.81 65.57,98.81 v3(68.08,96.29) ; v7(194.43,128.73) 194.53,128.73 196.39,130.59 197.2,130.59 198.25,129.54 198.25,127.88 199.23,126.9 199.23,117.37 198.37,116.51 198.37,114.72 197.13,113.48 193.04,113.48 190.63,111.07 190.63,110.49 189.08,108.95 189.08,108.2 186.37,105.48 170.95,105.48 170.04,104.57 154.66,104.57 154.37,104.86 149.15,104.86 148.08,105.92 146.62,105.92 146.2,105.51 134.58,105.51 134.32,105.25 132.44,105.25 130.94,103.75 130.01,103.75 129.35,103.09 v7(129.17,103.09)
  IN4 w0.06: v5(63.16,110.45) 63.14,110.42 63.14,110.22 62.92,110 62.74,110 62.08,109.34 62.08,109.2 61.22,108.34 61.22,107.31 v4(61.11,107.2) 61.26,107.05 61.26,106.02 61.32,105.97 61.32,105.56 61.26,105.51 61.26,105.31 61.49,105.09 61.49,104.79
  IN4 w0.089: v4(99.78,98.44) 95.75,98.44 94.09,96.78 86.32,96.78 85.82,96.28 82.37,96.28 81.15,95.06 77.92,95.06 77.55,95.43 75.62,95.43 75.18,94.99 74.36,94.99 73.99,94.62 69.43,94.62 68.08,95.97 v3(68.08,96.29) ; v3(61.57,103.44) 61.51,103.51 61.51,104.02 61.49,104.04 61.49,104.79
  BOTTOM w0.119: R355.1 192.76,129 193.01,128.75 194.41,128.75 v7(194.43,128.73) ; v7(129.17,103.09) 129.07,103.09 128.8,103.36 127.47,103.36 125.98,101.87 120.18,101.87 116.19,97.88 116.19,94.16 115.23,93.2 100.12,93.2 99.69,93.62 99.69,98.35 v4(99.78,98.44) ; v4(61.11,107.2) 60.93,107.03 60.93,106.31 60.74,106.12 60.62,106.12 60.46,105.97 60.46,105.53 60.38,105.44 RC82.2
SIO_EXT_SMI#_R: length 1.6
  BOTTOM w0.119: R355.2 192.85,130.28 192.85,131.71 U34.N5
SIO_EXT_WAKE#: length 217.2
  TOP w0.119: v1(46.53,119.83) 46.93,119.83 47.11,119.65 47.11,118.61 45.86,117.36 45.86,111 v1(45.67,110.81)
  IN1 w0.084: v1(46.53,119.83) 46.63,119.93 46.63,121.6 47.28,122.25 48.2,122.25 48.97,123.01 48.97,126.17 49.42,126.62 50.42,126.62 50.58,126.78 51.04,127.24 51.04,127.74 51.16,127.85 51.16,129.86 51.41,130.11 51.41,130.82 51.69,131.11 51.69,131.66 51.77,131.73 51.77,132.18 51.82,132.23 51.82,133.24 52.63,134.05 52.63,134.96 52.76,135.1 52.76,135.34 52.97,135.54 54.73,135.54 55,135.27 56.44,135.27 56.74,134.97 57.49,134.97 57.91,134.55 61.63,134.55 61.96,134.88 65.77,134.88 66.44,135.55 68.4,135.55 68.89,135.07 79.77,135.07 80.3,134.54 84.86,134.54 86.44,136.12 94.12,136.12 94.62,136.62 96.05,136.62 96.42,136.25 98.14,136.25 98.33,136.43 110.14,136.43 110.24,136.33 120.51,136.33 124.6,132.24 125.88,132.24 126.47,131.65 127.35,131.65 127.56,131.44 130.2,131.44 130.39,131.25 131.52,131.25 132.56,132.29 134.55,132.29 138.62,136.36 168.96,136.36 173.33,131.99 177.36,131.99 179.77,134.41 v2(179.83,134.41) ; v2(46.51,103.47) 47.82,103.47 48.79,104.45 48.79,106.05 47.23,107.61 47.23,108.79 47.3,108.85 47.3,110.11 47.24,110.17 47.24,110.25 46.68,110.81 v1(45.67,110.81)
  IN3 w0.084: v2(179.83,134.41) 180.51,134.41 180.88,134.03 182.13,134.03 182.37,134.28 186.69,134.28 186.93,134.03 188.59,134.03 189.06,134.5 189.92,134.5 190.24,134.81 190.74,134.81 190.91,134.99 v3(191.19,134.99) ; v2(46.51,103.47) 46.71,103.27 v7(46.81,103.27)
  IN4 w0.06: v5(61.13,116.01) 61.05,115.93 60.88,115.93 60.71,115.76 60.04,115.76 59.46,115.19 59.3,115.19 58.77,114.66 57.92,114.66 57.55,114.29 55.62,114.29 55.55,114.35 54.49,114.35 54.13,114.72 53.61,114.72 53.47,114.86 53.16,114.86 ; v4(191.82,132.74) 192.02,132.94 192.02,134.16 v3(191.19,134.99)
  IN4 w0.089: v7(46.81,103.27) 46.88,103.27 47.27,103.66 47.27,104.04 46.93,104.38 46.93,105.28 47.5,105.85 47.5,107.13 48.79,108.42 48.79,109.14 49.29,109.63 49.29,112.38 49.79,112.89 50.25,112.89 50.25,112.89 50.41,112.89 51.31,113.78 51.4,113.78 52.37,114.76 52.39,114.76 52.49,114.86 53.16,114.86
  BOTTOM w0.119: v7(46.81,103.27) 47.37,102.71 RC113.2
SIO_PWRBTN#: length 281.5
  TOP w0.119: v1(52.01,125.22) 52.01,127.08 52.2,127.27 T11.1 52.53,127.29 RH22.2 ; JAPS2.8 72.14,130.99 71.8,131.33 v1(64.14,131.33)
  IN1 w0.109: v1(64.14,131.33) 63.1,131.33 59.4,127.63 58.48,127.63 58.31,127.47 57.17,127.47 57.03,127.32 55.57,127.32 53.94,125.69 53.14,125.69 v2(52.91,125.45) 52.86,125.45 52.79,125.39 52.17,125.39 v1(52.01,125.22)
  IN2 w0.079: v2(122.3,102.78) 121.08,101.56 121.08,97.4 119.24,95.55 118.92,95.55 118.29,94.92 102.5,94.92 98.36,99.05 96.04,99.05 95.27,99.82 93.59,99.82 93.42,99.66 88.18,99.66 87.9,99.94 86.25,99.94 v2(85.88,99.57) 85.38,99.57 82.47,96.66 82.47,93.86 79.92,91.3 45.91,91.3 v2(45.19,92.03)
  IN3 w0.084: v2(85.88,99.57) 85.92,99.61 v3(86.21,99.61) ; v2(122.3,102.78) 122.35,102.73 124.66,102.73 124.64,102.75 v3(125.93,102.75) ; v2(52.91,125.45) 52.7,125.25 52.33,125.25 52.14,125.45 51.53,125.45 51.3,125.67 51.17,125.67 50.64,126.2 48.37,126.2 48.03,125.86 47.28,125.86 46.88,126.25 44.41,126.25 43.21,125.05 42.53,125.05 41.99,124.5 41.99,123.36 41.82,123.18 41.82,117.35 43.41,115.76 43.41,111.03 43.22,110.83 43.22,110.16 42.84,109.79 42.84,109.1 42.84,109.1 42.84,98.38 44.02,97.2 44.02,93.02 45.02,92.03 v2(45.19,92.03)
  IN4 w0.089: v3(125.93,102.75) 126.39,102.75 127.5,103.85 130.14,103.85 131.81,105.51 132.3,105.51 133.1,106.31 136.02,106.31 137.02,105.31 139.94,105.31 142,103.25 143.4,103.25 144.19,102.46 148.22,102.46 148.76,102.99 150.26,102.99 150.56,102.69 153.15,102.69 153.66,102.19 155.11,102.19 155.6,101.7 165.21,101.7 167.49,103.98 171.26,103.98 172.07,104.78 174.57,104.78 175.52,103.84 178.32,103.84 178.55,104.07 180.91,104.07 182.88,106.03 188.64,106.03 189.89,107.28 193.93,107.28 194.98,108.34 194.98,110.61 195.44,111.07 195.44,113.41 196.79,114.76 196.79,123.21 194.27,125.73 193.33,125.73 192.22,126.84 190.58,126.84 189.55,127.87 188.04,127.87 185.93,129.98 185.93,130.2 186.75,131.02 187.44,131.02 188.65,132.24 v4(188.82,132.24) ; v4(87.17,101.91) 87.38,101.7 87.38,101.32 87.37,101.3 87.37,101.28 87.22,101.13 87.02,101.13 86.21,100.32 v3(86.21,99.61)
SIO_RCIN#: length 175.8
  IN1 w0.084: v2(180.64,136.92) 180.64,136.05 179.22,134.63 179.22,134.38 177.25,132.41 173.55,132.41 169.16,136.79 169.03,136.79 169.02,136.8 138.42,136.8 134.28,132.66 132.41,132.66 131.37,131.62 130.57,131.62 130.38,131.81 127.71,131.81 127.5,132.02 126.62,132.02 126.03,132.61 124.75,132.61 123.67,133.69 123.67,134.91 123.77,135.02 123.77,135.93 123.01,136.7 110.76,136.7 110.66,136.8 98.17,136.8 98,136.63 96.95,136.63 96.59,136.99 94.47,136.99 93.98,136.5 86.3,136.5 84.7,134.91 80.46,134.91 79.84,135.52 68.96,135.52 68.54,135.94 66.31,135.94 65.78,135.42 61.9,135.42 61.41,134.92 58.06,134.92 57.64,135.34 56.9,135.34 56.6,135.64 55.16,135.64 54.37,136.42 53.06,136.42 52.21,135.57 52.21,135.33 51.74,134.86 51.74,134.01 51.44,133.71 51.44,132.38 51.39,132.33 51.39,131.88 51.32,131.81 51.32,131.26 49.9,129.85 49.9,129.7 v2(49.71,129.5)
  IN3 w0.084: v2(180.64,136.92) 180.73,136.84 184.5,136.84 184.98,136.35 186,136.35 186.93,137.28 187.81,137.28 188.86,136.24 v10(189.82,136.24) ; v7(49.99,128.64) 49.99,128.62 50.04,128.67 50.04,129.15 49.81,129.38 49.8,129.38 49.68,129.5 v2(49.71,129.5)
  IN4 w0.06: 53.36,127.9 55.65,127.9 56.71,126.85 56.71,126.72 56.86,126.57 57.96,126.57 58.37,126.16 58.69,126.16 59.41,125.44 61.52,125.44 62.73,124.22 62.73,123.85 v5(62.83,123.75)
  IN4 w0.089: v7(49.99,128.64) 49.99,128.43 50.29,128.13 50.51,128.13 50.84,127.8 51.23,127.8 51.33,127.9 53.36,127.9
  BOTTOM w0.119: RH61.1 49.85,128.78 v7(49.99,128.64)
SIO_SLP_A#: length 179.6
  TOP w0.119: JAPS2.13 69.64,130.22 68.91,130.95 63.93,130.95 62.79,132.1 T5.1 62.59,132.93 v1(60.05,132.93)
  IN1 w0.084: v2(59.13,132.65) 59.18,132.7 59.82,132.7 v1(60.05,132.93)
  IN2 w0.079: v2(59.13,132.65) 62.14,135.66 71.14,135.66 71.18,135.62 72.45,135.62 72.68,135.85 94.16,135.85 94.76,136.44 95.98,136.44 96.46,135.96 96.88,135.96 110.28,135.96 110.93,136.61 120.4,136.61 122,135.01 124.58,135.01 124.58,135.01 124.74,135.01 126.83,132.92 126.84,132.92 126.99,132.92 133.78,132.92 137.57,136.71 169.75,136.71 173.94,132.52 177.14,132.52 179.28,134.66 179.28,134.66 181.9,137.28 181.91,137.28 181.98,137.35 182.3,137.35 v2(182.78,137.84)
  IN3 w0.06: v10(64.77,122.27) 64.77,122.48 64,123.25 63.91,123.25 63.73,123.43 62.99,123.43 62.47,123.95 62.47,124.16 61.82,124.81
  IN3 w0.084: v2(182.78,137.84) 182.88,137.94 182.88,137.99 183.26,138.37 184.96,138.37 186.03,137.3 v3(186.16,137.3) ; v2(59.13,132.65) 58.76,133.03 57.82,133.03 57.18,132.39 57.18,130.82 58.09,129.9 58.09,128.54 61.82,124.81
  IN4 w0.06: 194.08,131.97 194.08,132.28 193.84,132.52 193.73,132.52 193.54,132.71 193.54,132.83 193.34,133.02 192.76,133.02 192.52,133.25 192.52,133.32 192.25,133.59 192.25,134.23 190.96,135.52 189.75,135.52 189.61,135.66 189.61,136.74 189.33,137.02
  IN4 w0.089: v3(186.16,137.3) 186.27,137.3 186.56,137.02 189.33,137.02 ; 194.08,131.97 194.08,131.33 194.56,130.85 v4(194.56,130.83)
  BOTTOM w0.119: U34.N1 194.82,131.08 v4(194.56,130.83)
SIO_SLP_S0#: length 296.9
  TOP w0.119: v1(62.07,103.08) 62.32,103.32 62.32,103.67 63.43,104.77 63.43,110.91 64.33,111.81 64.33,112.57 64.77,113.01 64.77,115.62 64.32,116.06 64.32,116.75 64.33,116.77 64.33,117.6 64.32,117.61 64.32,118.87 63.79,119.4 63.79,120.19 64.03,120.44 64.03,125.74 65.46,127.17 72.44,127.17 74.14,128.87 JAPS2.4 74.14,131.34 73.43,132.05 67.26,132.05 65.6,133.71 61.21,133.71 60.67,134.25 v1(60.55,134.25) ; PR908.1 179.67,104.88 179.83,105.04 179.83,106.24 v1(179.77,106.31) ; v1(68.38,100.65) 68.76,101.03 R176.1
  IN1 w0.084: v2(51.51,128.43) 51.51,129.94 51.59,130.03 51.59,130.74 51.88,131.03 51.88,131.58 51.95,131.65 51.95,132.1 52,132.15 52,133 52.29,133.29 52.87,133.29 53.04,133.47 55.64,133.47 55.72,133.55 56.19,133.55 56.3,133.43 59.64,133.43 59.78,133.57 60.15,133.57 60.55,133.98 v1(60.55,134.25) 61.59,134.25 62.01,134.67 65.82,134.67 66.51,135.36 68.33,135.36 68.81,134.88 77.02,134.88 v2(77.56,134.34) ; v2(33.05,131.74) 32.99,131.79 v1(32.99,132.25) ; v1(179.77,106.31) 179.7,106.24 v2(179.37,106.24) ; v1(62.07,103.08) 62.07,103.07 63.04,102.1 63.73,102.1 64.05,101.78 64.05,101.47 64.63,100.89 65.47,100.89 65.65,100.71 68.31,100.71 v1(68.38,100.65)
  IN3 w0.084: v2(179.37,106.24) 179.6,106.46 v3(179.6,106.56) ; v3(42.02,140.06) 38.49,140.06 33.05,134.61 v2(33.05,131.74) ; v7(49.86,127.9) 50.38,128.43 v2(51.51,128.43) ; v2(77.56,134.34) 77.8,134.58 77.8,135.54 80.9,138.64 102.01,138.64 102.88,137.77 102.88,137.6 103.21,137.27 123.14,137.27 127.2,133.21 132.18,133.21 132.54,133.57 132.82,133.57 134.28,135.03 165.97,135.03 168.07,132.93 178.33,132.93 179.4,134 180.65,134 180.81,133.85 181.25,133.85 v3(181.37,133.73) 181.52,133.57 182.66,133.57 183,133.91 185.92,133.91 186.22,133.61 186.22,133.22 186.58,132.86 v7(186.58,132.74)
  IN4 w0.089: 47.7,127.1 47.7,128.16 47.9,128.36 47.9,129.17 48.39,129.66 v4(48.39,129.68) ; 47.7,127.1 47.5,127.1 47,126.6 44.61,126.6 44.35,126.86 44.35,130.65 44.95,131.24 44.95,134.63 42.02,137.56 v3(42.02,140.06) ; 47.7,127.1 48.23,127.1 49.03,127.9 v7(49.86,127.9) ; v3(181.37,133.73) 176.92,129.28 176.71,129.28 171.64,124.21 171.24,124.21 170.96,123.93 170.96,121.24 170.61,120.88 170.61,115.26 v4(170.2,114.86) 170.2,114.75 170.61,114.35 170.61,111.5 175.31,106.8 177.25,106.8 177.54,106.51 179.55,106.51 v3(179.6,106.56)
  BOTTOM w0.119: v7(186.58,132.74) 186.38,132.55 R348.1 ; v7(49.86,127.9) 49.9,127.9 50.67,127.14 50.98,127.14 51.65,126.47 51.65,126.27 RH71.2 ; v4(170.2,114.86) 170.2,114.84 171.09,113.95 v14(171.09,113.52)
SIO_SLP_S0IX#: length 23.1
  TOP w0.119: U24.1 72.98,102.34 v1(72.9,102.43) 72.62,102.15 72.36,102.15 72.23,102.29 UH2.4 72.23,103.51 72.35,103.64 73.1,103.64 v14(73.27,103.47)
  IN1 w0.109: v2(72.74,101.91) 72.9,102.07 v1(72.9,102.43)
  IN3 w0.084: v2(72.74,101.91) 72.74,101.5 v3(72.87,101.36)
  IN4 w0.089: v3(72.87,101.36) 73.28,101.36 74.35,100.29 74.35,97.78 75.15,96.98 75.15,96.37 74.76,95.98 71.94,95.98 v4(71.08,96.85) v4(67.56,96.85)
  BOTTOM w0.119: R464.1 67.66,95.27 67.47,95.45 67.47,96.76 v4(67.56,96.85) ; R463.1 71.08,95.71 v4(71.08,96.85)
SIO_SLP_S3#: length 186
  TOP w0.119: v1(60.2,132.17) 60.2,132.13 60.72,131.61 61.19,131.61 T8.1 62.64,130.16 67.44,130.16 67.64,129.96 JAPS2.17
  IN1 w0.084: v2(58.55,132.68) 58.92,132.31 60.06,132.31 v1(60.2,132.17)
  IN2 w0.079: v2(183.67,139.41) 182.44,138.19 182.44,137.92 182.14,137.61 181.96,137.61 179.97,135.62 179.97,135.6 179.1,134.74 179.1,134.73 177.07,132.7 174.02,132.7 169.83,136.89 169.76,136.89 169.67,136.97 137.49,136.97 133.62,133.1 126.9,133.1 124.82,135.19 124.72,135.19 124.71,135.2 122.08,135.2 120.47,136.81 110.86,136.81 110.2,136.15 96.53,136.15 96.05,136.62 94.68,136.62 94.09,136.03 72.6,136.03 72.42,135.85 61.72,135.85 v2(58.55,132.68)
  IN3 w0.06: 62.09,124.81 62.59,124.3 62.59,124 63.04,123.55 63.78,123.55 63.86,123.47 63.94,123.47 64.97,122.45 64.97,122.19 64.65,121.87 64.65,121.11 64.35,120.82 v22(63.65,120.82)
  IN3 w0.084: v2(58.55,132.68) 57.73,132.68 57.36,132.31 57.36,130.89 58.28,129.98 58.28,128.68 58.28,128.61 62.09,124.81 ; v3(185.95,138.32) 185.95,138.5 185.23,139.22 183.86,139.22 v2(183.67,139.41)
  GND3 w0.06: v22(63.65,120.82) 63.77,120.93 v15(63.93,120.93)
  IN4 w0.06: 189.15,137.63 189.3,137.63 189.55,137.38 189.55,137.12 189.74,136.94 189.9,136.94 190.02,136.82 190.02,136.15 190.14,136.04 190.3,136.04 190.54,135.8 190.98,135.8 192.96,133.82 192.96,133.76 193.27,133.45 193.41,133.45 193.54,133.33 193.54,133.15 193.66,133.02 193.89,133.02 194.18,132.74 v4(194.32,132.74)
  IN4 w0.089: v4(194.32,132.74) 194.46,132.74 194.94,132.26 194.94,131.38 196.14,130.18 196.14,130.16 198.42,127.88 v4(199.21,127.88) ; v3(185.95,138.32) 185.95,138.17 186.49,137.63 187.16,137.63 187.16,137.63 187.39,137.63 187.39,137.63 189.15,137.63
  BOTTOM w0.119: v4(199.21,127.88) 199.03,128.06 R366.1
SIO_SLP_S4#: length 206.4
  TOP w0.119: v1(60.12,138.39) 59.71,137.98 59.71,134.77 60.12,134.36 60.12,133.47 59.76,133.1 59.76,132.81 60.11,132.46 61.89,132.46 63.71,130.64 68.74,130.64 69.14,130.24 JAPS2.14
  IN1 w0.084: v2(48.18,129.81) 48.19,129.81 49.1,130.72 49.1,130.87 49.57,131.33 49.57,132.04 50.32,132.8 50.32,135.2 50.72,135.6 50.72,135.82 50.93,136.03 50.93,136.13 50.93,136.13 50.93,137.54 51.91,138.52 54.78,138.52 56.24,137.06 57.2,137.06 57.36,136.9 57.38,136.9 57.51,136.77 57.76,136.77 57.77,136.76 58.13,136.76 59.79,138.42 60.15,138.42 ; v2(185.32,135.02) 185.71,135.02 186.49,135.79 189.14,135.79 190.14,136.79 v1(191.92,136.79) 193.09,136.79 193.34,137.05 193.34,138.29 193.17,138.47 v2(193.17,138.5) ; 60.15,138.42 v1(60.12,138.39) ; 60.15,138.42 62.1,138.42 62.89,139.21 64.97,139.21 65.49,139.73 71.16,139.73 73.7,137.18 80.19,137.18 80.89,136.48 84.05,136.48 85.61,138.04 90.17,138.04 90.32,138.19 99.47,138.19 v2(99.8,137.86)
  IN3 w0.06: v10(64.44,122.52) 63.65,123.31 62.94,123.31 62.35,123.9 62.35,124.01 62,124.36
  IN3 w0.084: v2(193.17,138.5) 193.17,138.4 193.32,138.24 v7(193.32,138.15) ; v3(110.84,134.64) 108.83,136.64 102.18,136.64 101.45,137.38 100.58,137.38 100.33,137.12 100,137.12 99.8,137.33 v2(99.8,137.86) ; v2(185.32,135.02) 185.28,134.97 v3(182.07,134.97) ; v2(48.18,129.81) 48.79,130.42 v7(50.42,130.42) 50.44,130.42 50.62,130.6 51.2,130.6 51.32,130.48 52.34,130.48 53.38,129.44 53.44,129.37 55.64,129.37 56.29,128.72 57.64,128.72 57.69,128.67 57.7,128.67 61.43,124.94 61.43,124.93 62,124.36
  IN4 w0.089: v3(182.07,134.97) 182.07,134.81 178.03,130.77 173.21,130.77 168.86,135.12 153.65,135.12 153.04,134.51 151.51,134.51 151.28,134.74 139.48,134.74 137.42,132.68 136.32,132.68 135.92,132.27 134.81,132.27 134.62,132.08 134.12,132.08 133.89,131.86 133.17,131.86 131.88,130.56 126.71,130.56 125.95,131.32 124.81,131.32 121.49,134.64 112.51,134.64 112.38,134.76 110.96,134.76 v3(110.84,134.64)
  BOTTOM w0.119: T16.1 50.42,130.39 v7(50.42,130.42) ; U34.A4 v7(193.32,138.15)
SIO_SLP_S5#: length 41.3
  TOP w0.119: JAPS2.15 68.64,130.03 68.25,130.42 63.17,130.42 61.43,132.16 v1(60.58,132.16)
  IN1 w0.084: v1(60.58,132.16) 60.31,131.89 59.94,131.89 59.72,132.12 57.25,132.12 56.79,131.66 56.79,130.08 56.6,129.88 56.6,129.66 56.18,129.25 55.09,129.25 54.69,129.66 53.7,129.66 53.47,129.43 52.72,129.43 52.69,129.4 v2(52.07,129.4)
  IN3 w0.084: v7(51.61,129.4) v2(52.07,129.4)
  IN4 w0.06: v5(63.8,123.01) 63.8,123.42 63.62,123.6 63.62,124.16 63.34,124.44 63.2,124.44 61.73,125.92 59.62,125.92 58.85,126.68 58.54,126.68 57.99,127.24 57.99,127.72 57.84,127.87 57.29,127.87 57.19,127.97 57.19,128.23 56.21,129.21
  IN4 w0.089: 56.21,129.21 56.21,129.94 55.57,130.59 55.57,131.35 55.31,131.61 54.98,131.61 54.79,131.42 54.02,131.42 53.73,131.71 52.23,131.71 51.91,131.39 51.91,129.82 51.61,129.52 v7(51.61,129.4)
  BOTTOM w0.119: T17.1 v7(51.61,129.4)
SIO_SLP_SUS#: length 248.6
  IN3 w0.084: v3(108.38,91.81) 108.09,91.52 107.84,91.52 107.05,92.3 98.2,92.3 96.93,93.58 87.25,93.58 86.55,92.88 86.55,90.98 86.06,90.49 63.47,90.49 62.76,89.78 48,89.78 46.1,91.68 44.37,91.68 43.32,92.73 43.32,93.12 43.81,93.61 43.81,97.05 42.63,98.23 42.63,108.89 42.63,109.87 43.01,110.25 43.01,110.92 43.2,111.11 43.2,115.68 41.61,117.27 41.61,123.27 41.78,123.44 41.78,124.59 42.45,125.26 43.12,125.26 44.33,126.46 46.97,126.46 47.36,126.07 47.94,126.07 48.3,126.43 50.76,126.43 51.22,125.97 51.51,125.97 51.63,126.09 51.86,126.09 51.99,126.23 52.27,126.23 52.28,126.22 52.29,126.22 52.37,126.14 52.43,126.14 52.56,126.01 53.75,126.01 53.83,126.09 53.94,126.09 54.08,126.23 54.12,126.23 54.18,126.3 v7(54.18,126.3)
  IN4 w0.089: v4(174.8,97.53) 175.26,97.53 177.27,99.54 182.23,99.54 186.33,103.65 189.86,103.65 190.89,104.67 195.29,104.67 195.73,105.11 195.73,105.3 197.95,107.52 197.95,111.41 201.21,114.67 201.21,124.04 198.45,126.8 197.26,126.8 195.74,128.33 194.45,128.33 193.78,129 193.78,130.39 193.55,130.62 193.55,131.78 193.82,132.05 v4(193.82,132.24) ; v3(108.38,91.81) 108.85,91.34 154.73,91.34 155.35,91.96 174.51,91.96 174.9,92.36 v4(174.9,93.55)
  BOTTOM w0.119: RH68.2 54.31,126.43 v7(54.18,126.3) ; v4(174.9,93.55) 174.8,93.65 v4(174.8,97.53)
SIO_SLP_SUS#_L: length 8.7
  BOTTOM w0.076: UC1.BN10 62.83,124.7 61.95,125.58 59.22,125.58 58.6,126.2 57.91,126.2 57.86,126.15
  BOTTOM w0.119: RH68.1 56.04,125.99 56.04,125.95 56.11,125.88 57.28,125.88 57.33,125.83 57.54,125.83 57.86,126.15
SIO_SLP_WLAN#: length 188.4
  IN1 w0.084: v2(192.77,144.07) 192.56,143.87 191.07,143.87 187.96,140.76 186.8,140.76 180.77,134.73 180.77,133.84 179.68,132.75 179.17,132.75 177.44,131.02 173.08,131.02 168.53,135.57 138.88,135.57 134.85,131.55 133.61,131.55 132.08,130.03 129.74,130.03 129.59,130.18 127.81,130.18 127.08,130.9 126.17,130.9 125.57,131.5 124.29,131.5 120.43,135.36 120.28,135.51 96.11,135.51 95.74,135.88 94.93,135.88 94.39,135.34 86.71,135.34 85.17,133.8 77.2,133.8 77.01,133.99 74.52,133.99 74.34,133.8 72.75,133.8 72.09,134.46 68.71,134.46 68.25,134.92 66.59,134.92 65.69,134.01 61.87,134.01 60.92,133.06 60.3,133.06 60.16,133.2 59.93,133.2 59.79,133.06 56.84,133.06 55.84,132.06 55.84,131.91 55.73,131.81 55.72,131.81 55.59,131.68 54.97,131.68 54.68,131.96 54.24,131.96 53.91,131.62 53.91,131.61 53.74,131.44 53.24,131.44 53.09,131.28 52.87,131.28 52.12,130.54 v2(52.12,129.91) ; v1(50.44,132.34) 50.2,132.1 50.2,131.66 v2(50.25,131.61)
  IN3 w0.084: v3(50.56,131.27) 50.25,131.57 v2(50.25,131.61) ; v2(52.12,129.91) 52.12,129.91 52.07,129.91 52.04,129.94 v7(51.64,129.94) ; v2(192.77,144.07) 190.76,142.06 190.76,140.58 190.75,140.57 190.75,140.48 190.44,140.17 190.44,139.05 190.71,138.78 190.93,138.78 v7(191.06,138.65)
  IN4 w0.06: v5(64.44,123.01) 64.41,123.01 64.33,123.09 64.32,123.09 63.8,123.61 63.8,123.62 63.74,123.68 63.74,124.21 63.39,124.56 63.25,124.56 61.78,126.04 59.67,126.04 58.88,126.83 58.57,126.83 58.11,127.28 58.11,127.76 57.29,128.59 57,128.59 56.46,129.13 56.46,129.99 56.06,130.39
  IN4 w0.089: 56.06,130.39 55.76,130.7 55.76,131.43 55.39,131.8 54.9,131.8 54.72,131.62 54.09,131.62 53.81,131.9 51.33,131.9 50.7,131.27 v3(50.56,131.27) 50.56,131.02 v7(51.64,129.94)
  BOTTOM w0.119: v7(191.06,138.65) 191.32,138.39 U34.A8
SKTOCC#: length 7.5
  IN3 w0.06: v6(79.68,110.04) 80.28,110.04 81,109.32 v7(81,109.18)
  IN4 w0.06: v6(79.68,110.04) 79.58,110.14 79.08,110.14 v5(78.8,109.86)
  BOTTOM w0.119: v7(81,109.18) 81,109.05 81.46,108.58 81.46,108.15 82.01,107.6 84.09,107.6 RC64.1
SKYCAM_CSI0_D: length 101.9
  IN2 w0.079: v2(138.15,128.74) 138.01,128.88 138.01,129.15 137.83,129.33 137.44,129.33 136.6,128.49 133.77,128.49 132.97,127.69 132.49,127.69 132.29,127.49 132.29,127.21 132.22,127.14 132,127.14 131.9,127.25 131.9,127.5 131.71,127.69 131.16,127.69 130.82,128.03 129.54,128.03 129.25,127.75 129.25,127.42 129.18,127.34 128.94,127.34 128.86,127.42 128.86,127.81 128.56,128.12 127.91,128.12 127.8,128.23 124.75,128.23 124.4,128.58 124.13,128.58 123.98,128.73 123.45,128.73 123.3,128.58 122.97,128.58 122.82,128.73 122.29,128.73 122.15,128.58 121.95,128.58 121.27,129.26 121.01,129.26 120.73,128.99 120.5,128.99 120.35,129.14 120.35,129.26 120.66,129.57 120.66,129.87 120.47,130.06 119.9,130.06 119.68,129.84 119.68,129.12 119.54,128.99 119.08,128.99 118.93,129.14 118.93,130.01 118.67,130.27 117.45,130.27 117.26,130.08 117.26,129.99 117.18,129.91 116.94,129.91 116.87,129.99 116.87,130.08 116.68,130.27 116.29,130.27 116.1,130.08 116.1,129.99 116.02,129.91 115.79,129.91 115.71,129.99 115.71,130.08 115.52,130.27 113.8,130.27 113.61,130.08 113.61,129.64 113.53,129.56 113.29,129.56 113.22,129.64 113.22,130.08 113.03,130.27 112.5,130.27 112.42,130.35 112.42,130.85 112.23,131.04 111.86,131.04 111.65,130.83 111.65,130.35 111.58,130.27 111.23,130.27 109.82,128.86 106.77,128.86 106.37,129.25 105.43,129.25 105.06,129.62 104.43,129.62 103.69,130.36 100.74,130.36 96.27,125.9 95.61,125.9 94.57,124.86 94.57,124.36 92.11,121.91 90.51,120.31 84.6,120.31 80.45,116.16 80.45,113 79,111.55 72.86,111.55 72.59,111.82 69.28,111.82 69.01,111.55 68.51,111.55 67.6,110.65 67.6,109.89 v2(67.96,109.54)
  IN3 w0.06: v2(67.96,109.54) 68.25,109.83 68.25,110.16 68.55,110.46 68.55,110.61 v10(68.63,110.69)
  IN3 w0.084: v7(139.68,124.95) 139.44,124.95 139.35,125.04 139.35,125.56 140.36,126.57 140.36,127.45 139.57,128.23 138.2,128.23 138.06,128.37 138.06,128.65 v2(138.15,128.74)
  BOTTOM w0.119: v7(139.68,124.95) 139.76,125.03 R376.1
SKYCAM_CSI0_D#: length 101.8
  IN2 w0.079: v2(137.62,128.72) 137.69,128.72 137.83,128.86 137.83,129.07 137.76,129.14 137.52,129.14 136.68,128.3 133.85,128.3 133.05,127.5 132.56,127.5 132.47,127.41 132.47,127.13 132.3,126.95 131.93,126.95 131.71,127.17 131.71,127.43 131.63,127.5 131.08,127.5 130.74,127.85 129.62,127.85 129.44,127.67 129.44,127.34 129.25,127.15 128.86,127.15 128.68,127.34 128.68,127.74 128.48,127.93 127.84,127.93 127.72,128.05 124.67,128.05 124.32,128.4 124.05,128.4 123.91,128.54 123.53,128.54 123.38,128.4 122.89,128.4 122.75,128.54 122.37,128.54 122.22,128.4 121.87,128.4 121.19,129.08 121.08,129.08 120.81,128.81 120.42,128.81 120.17,129.06 120.17,129.34 120.48,129.64 120.48,129.8 120.39,129.88 119.98,129.88 119.86,129.76 119.86,129.05 119.62,128.81 119,128.81 118.74,129.06 118.74,129.93 118.59,130.08 117.52,130.08 117.45,130 117.45,129.91 117.26,129.73 116.87,129.73 116.68,129.91 116.68,130 116.6,130.08 116.37,130.08 116.29,130 116.29,129.91 116.1,129.73 115.71,129.73 115.52,129.91 115.52,130 115.44,130.08 113.87,130.08 113.8,130 113.8,129.56 113.61,129.38 113.22,129.38 113.03,129.56 113.03,130 112.95,130.08 112.42,130.08 112.23,130.27 112.23,130.78 112.15,130.86 111.94,130.86 111.84,130.76 111.84,130.27 111.65,130.08 111.3,130.08 109.89,128.67 106.69,128.67 106.3,129.07 105.36,129.07 104.99,129.44 104.35,129.44 103.61,130.18 100.81,130.18 96.35,125.71 95.68,125.71 94.75,124.78 94.75,124.29 92.24,121.77 90.59,120.12 84.68,120.12 80.64,116.09 80.64,112.92 79.08,111.36 72.78,111.36 72.51,111.64 69.36,111.64 69.09,111.37 68.58,111.37 67.79,110.57 67.79,110.12 67.83,110.07 v2(67.96,110.07)
  IN3 w0.06: v2(67.96,110.07) 67.99,110.07 68.43,110.51 68.43,110.77 68.57,110.91 68.57,110.96 68.39,111.14 68.39,111.23 68.56,111.39 68.67,111.39 68.71,111.35 68.71,111.26 v10(68.63,111.18)
  IN3 w0.084: v7(138.83,124.95) 138.96,124.82 139.12,124.82 139.19,124.89 139.19,125.63 140.2,126.64 140.2,127.38 139.51,128.07 138.13,128.07 137.9,128.31 137.9,128.5 137.68,128.72 v2(137.62,128.72)
  BOTTOM w0.119: R377.1 138.75,125.03 v7(138.83,124.95)
SKYCAM_CSI0_D#_L: length 6.6
  IN3 w0.084: v7(135.2,130.55) 135.42,130.33 135.42,130 137.93,127.49 138.78,127.49 139.18,127.09 139.18,127 v7(138.83,126.65)
  BOTTOM w0.119: v7(138.83,126.65) 138.75,126.57 R377.2
SKYCAM_CSI0_D_L: length 6.6
  IN3 w0.084: v7(139.68,126.65) 139.34,126.98 139.34,127.15 138.85,127.65 138,127.65 135.58,130.07 135.58,130.33 v7(135.8,130.55)
  BOTTOM w0.119: R376.2 139.76,126.57 v7(139.68,126.65)
SKYCAM_CSI1_D: length 103.2
  IN2 w0.079: v2(70.23,110.4) 70.37,110.26 71.2,110.26 71.69,109.77 79.9,109.77 82.16,112.03 82.16,115.41 83.94,117.19 84.71,117.96 85,118.25 85.29,118.25 85.48,118.06 85.48,118.01 85.6,117.9 85.76,117.9 85.87,118.01 85.87,118.06 86.06,118.25 86.45,118.25 86.64,118.06 86.64,118.01 86.75,117.9 86.92,117.9 87.03,118.01 87.03,118.06 87.22,118.25 87.61,118.25 87.8,118.06 87.8,118.01 87.91,117.9 88.08,117.9 88.19,118.01 88.19,118.06 88.38,118.25 88.77,118.25 88.95,118.06 88.95,118.01 89.07,117.9 89.23,117.9 89.35,118.01 89.35,118.06 89.54,118.25 89.92,118.25 90.18,117.98 90.63,117.98 95.82,123.16 96.09,123.16 96.28,123.36 96.28,123.62 96.52,123.85 96.64,123.85 99.64,126.86 100.21,126.86 100.29,126.94 100.29,127.21 100.47,127.4 100.86,127.4 101.05,127.21 101.05,126.94 101.13,126.86 101.64,126.86 101.98,126.51 102.33,126.51 102.41,126.59 102.41,126.73 102.58,126.9 103,126.9 103.18,126.72 103.18,126.59 103.25,126.51 107.65,126.51 107.87,126.73 110.81,126.73 111.11,126.43 111.11,126.15 110.98,126.01 110.98,125.79 111.06,125.71 111.39,125.71 111.61,125.49 111.61,125.16 111.71,125.05 111.9,125.05 111.97,125.13 111.97,125.41 112.17,125.61 112.55,125.61 112.74,125.41 112.74,125.13 112.82,125.05 113.05,125.05 113.13,125.13 113.13,125.42 113.31,125.61 113.7,125.61 113.91,125.4 113.91,125.09 113.97,125.03 115.02,125.03 115.35,124.7 115.44,124.7 115.56,124.81 115.56,125.31 115.8,125.55 116.09,125.55 116.33,125.31 116.33,124.74 116.45,124.62 116.61,124.62 116.95,124.97 117.26,124.97 117.49,124.74 117.49,124.42 117.31,124.24 117.31,124.13 117.4,124.04 117.53,124.04 117.74,123.83 117.74,123.7 119.43,122.01 119.62,122.01 120.04,121.59 125.47,121.59 125.96,122.08 125.96,122.3 126.23,122.58 126.5,122.58 126.81,122.26 126.92,122.26 127.18,122.52 127.18,122.63 126.96,122.85 126.96,123.15 127.48,123.67 128.35,123.67 128.57,123.89 129.32,123.89 130.03,124.6 130.29,124.6 131,125.31 133.29,125.31 134.61,126.63 138.24,126.63 139.09,127.49 140.07,127.49 140.23,127.33 140.23,126.74 140,126.52 139.71,126.52 138.74,125.54 134.78,125.54 134.04,124.79 134.04,124.56 v2(134.21,124.39)
  IN3 w0.06: v10(69.92,111.18) 70.02,111.08 70.02,110.87 70.23,110.66 v2(70.23,110.4)
  IN3 w0.084: v7(134.37,124.96) 134.27,124.96 134.06,124.75 134.06,124.53 v2(134.21,124.39)
  BOTTOM w0.119: R374.1 134.37,125.27 v7(134.37,124.96)
SKYCAM_CSI1_D#: length 103.1
  IN2 w0.079: v2(70.23,109.87) 70.23,109.94 70.36,110.07 71.12,110.07 71.61,109.58 79.98,109.58 82.34,111.95 82.34,115.33 84.07,117.06 84.84,117.83 84.96,117.94 85.08,118.06 85.22,118.06 85.29,117.98 85.29,117.93 85.52,117.71 85.84,117.71 86.06,117.93 86.06,117.98 86.14,118.06 86.37,118.06 86.45,117.98 86.45,117.93 86.68,117.71 86.99,117.71 87.22,117.93 87.22,117.98 87.3,118.06 87.53,118.06 87.61,117.98 87.61,117.93 87.83,117.71 88.15,117.71 88.38,117.93 88.38,117.98 88.45,118.06 88.69,118.06 88.77,117.98 88.77,117.93 88.99,117.71 89.31,117.71 89.53,117.93 89.53,117.98 89.61,118.06 89.84,118.06 90.11,117.8 90.71,117.8 95.89,122.98 96.16,122.98 96.47,123.28 96.47,123.54 96.6,123.67 96.72,123.67 99.72,126.67 100.28,126.67 100.47,126.86 100.47,127.13 100.55,127.21 100.79,127.21 100.87,127.13 100.87,126.86 101.05,126.67 101.56,126.67 101.9,126.33 102.41,126.33 102.6,126.52 102.6,126.66 102.65,126.72 102.92,126.72 102.99,126.65 102.99,126.52 103.18,126.33 107.73,126.33 107.94,126.54 110.74,126.54 110.93,126.35 110.93,126.22 110.79,126.09 110.79,125.71 110.98,125.52 111.31,125.52 111.42,125.41 111.42,125.08 111.63,124.87 111.97,124.87 112.16,125.06 112.16,125.34 112.24,125.42 112.47,125.42 112.55,125.34 112.55,125.06 112.74,124.87 113.13,124.87 113.31,125.05 113.31,125.34 113.39,125.42 113.63,125.42 113.72,125.33 113.72,125.02 113.89,124.84 114.94,124.84 115.27,124.51 115.52,124.51 115.74,124.74 115.74,125.24 115.88,125.37 116.01,125.37 116.15,125.24 116.15,124.66 116.37,124.44 116.68,124.44 117.03,124.79 117.18,124.79 117.3,124.66 117.3,124.5 117.27,124.46 117.12,124.32 117.12,124.06 117.32,123.86 117.45,123.86 117.56,123.75 117.56,123.62 119.35,121.83 119.54,121.83 119.96,121.41 125.54,121.41 126.14,122 126.14,122.23 126.31,122.39 126.42,122.39 126.74,122.08 127,122.08 127.37,122.44 127.37,122.71 127.15,122.93 127.15,123.07 127.56,123.48 128.42,123.48 128.64,123.71 129.39,123.71 130.1,124.42 130.37,124.42 131.08,125.13 133.36,125.13 134.68,126.45 138.32,126.45 139.17,127.3 139.99,127.3 140.04,127.25 140.04,126.82 139.93,126.71 139.64,126.71 138.66,125.73 134.71,125.73 133.85,124.87 133.85,124.56 v2(133.67,124.39)
  IN3 w0.06: v2(70.23,109.87) 69.92,110.17 v10(69.92,110.69)
  IN3 w0.084: v7(133.52,124.96) 133.8,124.96 133.9,124.87 133.9,124.61 v2(133.67,124.39)
  BOTTOM w0.119: v7(133.52,124.96) 133.52,125.27 R375.1
SKYCAM_CSI1_D#_L: length 5.2
  IN3 w0.084: v7(134,130.55) 134.22,130.33 134.22,130.19 134.65,129.76 134.65,127.8 133.87,127.03 133.87,126.74 133.8,126.66 v7(133.52,126.66)
  BOTTOM w0.119: v7(133.52,126.66) 133.52,126.35 R375.2
SKYCAM_CSI1_D_L: length 5.2
  IN3 w0.084: v7(134.37,126.66) 134.13,126.66 134.04,126.76 134.04,126.96 134.81,127.74 134.81,129.83 134.38,130.26 134.38,130.33 v7(134.6,130.55)
  BOTTOM w0.119: v7(134.37,126.66) 134.37,126.35 R374.2
SKYCAM_CSI2_D: length 99.9
  IN2 w0.079: v2(141.58,128.65) 141.4,128.83 141.4,129.17 141.25,129.33 139.27,129.33 137.8,127.85 133.96,127.85 132.66,126.56 130.35,126.56 129.75,125.96 129.25,125.96 127.57,127.64 126.19,127.64 125.87,127.31 125.74,127.31 125.42,127.64 124.51,127.64 124.13,128.01 121.63,128.01 121.29,128.36 119.95,128.36 119.91,128.39 119.76,128.39 115.48,128.39 115.41,128.47 115.41,128.81 115.22,129 114.83,129 114.64,128.81 114.64,128.47 114.56,128.39 114.13,128.39 113.6,128.92 112.13,128.92 112.05,129 112.05,129.26 111.87,129.44 111.48,129.44 111.29,129.26 111.29,129 111.21,128.92 110.82,128.92 109.85,127.94 109.51,127.94 109.28,128.17 108.73,128.17 108.51,127.94 108.27,127.94 108.05,128.17 107.38,128.17 107.15,127.94 106.82,127.94 106.63,127.76 106.63,127.74 106.55,127.66 106.32,127.66 106.24,127.74 106.24,127.76 106.05,127.94 105.77,127.94 104.66,129.05 103.46,129.05 103.35,129.16 103.35,129.6 103.16,129.79 102.83,129.79 102.68,129.65 102.37,129.65 102.23,129.79 101.84,129.79 101.69,129.64 101.42,129.64 101.27,129.79 100.97,129.79 96.49,125.31 95.83,125.31 95.15,124.63 95.15,124.14 90.73,119.72 84.81,119.72 81.02,115.93 81.02,112.62 79.38,110.98 72,110.98 71.58,111.4 69.52,111.4 69.15,111.03 68.57,111.03 68.3,110.76 68.3,109.76 68.5,109.57 68.68,109.57 v2(68.83,109.41)
  IN3 w0.06: v10(68.95,110.94) 68.95,110.69 68.39,110.13 68.39,109.84 68.39,109.74 68.54,109.59 68.64,109.59 68.66,109.59 v2(68.83,109.41)
  IN3 w0.084: v7(143.78,124.95) 143.44,125.28 143.44,125.48 142.39,126.53 142.39,127.35 141.41,128.33 141.41,128.48 v2(141.58,128.65)
  BOTTOM w0.119: R380.1 143.78,125.26 v7(143.78,124.95)
