# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_SIGNAL: length 13.5
  TOP w0.254: v1(129.04,104.41) 129.04,102.28 129.27,102.05 130.05,102.05 130.33,102.33 130.33,102.59 PR405.2 131.4,102.59 PC408.2
  IN1 w0.254: v2(128.52,104.71) 128.64,104.71 128.94,104.41 v1(129.04,104.41)
  IN3 w0.254: v7(128.32,105.42) 128.32,104.92 v2(128.52,104.71)
  IN4 w0.762: 122.61,102.75 123.16,103.3 123.16,104.03 124.97,105.83 125.35,105.83 126.52,107
  BOTTOM w0.254: PU400.10 128.18,110.44 v4(127.91,110.18)
  vias: v2(120.93,102.91) v4(125.7,113.02) v4(125.98,113.02) v4(126.64,110.81) v4(126.67,110.18) v4(126.67,109.54) v4(127.18,105.77) v4(127.25,110.81) v4(127.23,110.19) v4(127.3,109.54) v4(127.48,105.88) v4(127.91,110.84) v4(127.91,109.51) v8(121.09,102.55) v8(121.23,102.77) v9(120.68,102.5) v9(120.93,102.5)
GNDA_CHG: length 0.8
  BOTTOM w0.254: PR506.1 144.37,109.82 144.59,110.04 v4(144.6,110.04)
  vias: v1(140.44,110.86) v1(140.69,110.86) v1(141.2,110.89) v1(141.48,110.91) v1(144.54,110.11) v1(144.87,110.11) v2(140.56,111.19) v2(141.33,111.22) v2(145.14,109.57) v3(140.39,111.52) v3(140.66,111.55) v3(141.12,111.57) v3(141.4,111.57) v3(144.83,109.72) v3(144.83,109.44) v4(136.36,114.79) v4(136.4,113.88) v4(137.93,110.47) v4(138.4,108.57) v4(140.39,113.86) v4(140.39,112.72) v4(140.39,111.83) v4(141.43,113.88) v4(141.55,112.74) v4(141.5,111.88) v4(142.72,113.91) v4(142.72,112.77) v4(142.72,111.62) v4(144.93,110.87) v4(145.91,112.96) v4(147.12,112.21) v4(147.12,111.93)
VBUS_ACDIS#: length 79
  TOP w0.119: PQ106.2 27.89,84.58 27.51,84.97 v13(27.51,85.07) ; PR117.2 34.34,34.43 34.92,33.85 35.81,33.85 36.14,34.18 v1(36.14,34.39)
  IN1 w0.084: v1(36.14,34.39) 36.19,34.34 36.19,32.45 36.61,32.03 39.44,32.03 40.42,33.01 40.42,39.24 43.76,42.58 44.02,42.58 44.62,43.18 44.62,57.68 43.74,58.57 43.74,71.68 39.32,76.1 39.32,83.63 v2(39.14,83.81)
  IN3 w0.084: v13(27.51,85.07) 27.51,85.64 27.79,85.92 29.45,85.92 31.73,83.64 38.97,83.64 v2(39.14,83.81)
VBUS_ACOK: length 304.8
  TOP w0.119: v1(185.1,124.11) 185.2,124.01 185.2,120.16 184,118.95 184,115.89 184.47,115.42 184.47,114.96 PQ151.2 185.46,113.97 PU150.1 185.46,111.81 186.03,111.24 186.03,109.14 187.53,107.64 v1(187.53,104.09) ; PR135.2 PR138.2 26.75,30.36 29.47,33.08 PU100.7 30.52,33.08 31.03,32.57 32.52,32.57 32.65,32.44 32.65,31.49 32.85,31.28 34.63,31.28 34.87,31.52 34.87,32.39 PQ105.2 36.07,32.99 v1(36.47,32.59) ; v1(85.59,92.97) 45.43,92.97 v1(44.34,91.87) ; v13(27.94,85.49) 27.94,85.02 28.54,84.42 PQ106.3
  IN1 w0.084: v1(44.34,91.87) 44.13,91.67 41.21,91.67 40.18,90.64 40.18,88.61 40.02,88.45 40.02,86.59 39.35,85.93 39.35,84.66 38.77,84.08 38.77,83.32 v2(38.96,83.12) 38.79,82.95 38.79,76.37 43.55,71.6 43.55,58.49 44.43,57.61 44.43,43.26 43.94,42.76 43.69,42.76 40.24,39.31 40.24,33.09 39.37,32.22 36.84,32.22 v1(36.47,32.59) ; v1(185.1,124.11) 184.91,124.3 v2(184.91,124.48) ; v2(136.98,107.46) 137.33,107.8 140.5,107.8 141.15,107.15 142.42,107.15 144.94,104.63 146.1,103.47 146.19,103.38 146.19,103.38 146.67,102.9 167.02,102.9 167.85,102.06 168.1,102.06 168.1,102.06 168.49,102.06 169.5,102.06 169.5,102.06 177.77,102.06 179.73,104.03 187.46,104.03 v1(187.53,104.09) ; v1(85.59,92.97) 85.59,92.99 87.07,94.48 87.32,94.73 98.29,94.73 99.58,93.44 112.94,93.44 v2(113.24,93.14)
  IN2 w0.084: v2(192.8,126.97) 192.65,127.12 186.28,127.12 184.91,125.75 v2(184.91,124.48)
  IN3 w0.084: v13(27.94,85.49) 29.55,85.49 31.58,83.45 38.63,83.45 v2(38.96,83.12) ; v2(136.98,107.46) 137.01,107.48 v7(137.36,107.48) ; v3(192.35,128.97) 192.79,128.54 192.79,126.99 v2(192.8,126.97) ; v2(113.24,93.14) 113.44,92.95 113.44,92.89 v3(113.73,92.6)
  IN4 w0.089: v3(192.35,128.97) 192.02,128.97 191.36,129.63 v4(191.36,130.8) ; v4(138.71,104.79) 138.64,104.72 134.96,104.72 134.47,105.22 133.2,105.22 131.93,103.95 v4(131.93,102.68) ; v3(113.73,92.6) 113.75,92.62 118.26,92.62 v4(118.61,92.98)
  BOTTOM w0.119: v4(118.61,92.98) 119.1,93.47 119.1,96.11 119.42,96.43 130.97,96.43 132.32,97.78 JIO4.43 132.32,102.29 v4(131.93,102.68) ; U34.N9 190.82,131.34 v4(191.36,130.8) ; v4(138.71,104.79) 139.17,104.79 139.45,105.07 139.45,107.13 139.09,107.48 v7(137.36,107.48)
VBUS_SENSE: length 118.4
  TOP w0.119: v1(42.37,75.61) 41.95,76.02 R210.1 ; v1(37.33,30.39) R485.2
  IN1 w0.084: v1(37.33,30.39) 37.33,30.47 38.7,31.85 39.52,31.85 40.61,32.93 40.61,39.16 43.84,42.39 44.09,42.39 44.81,43.1 44.81,57.76 43.92,58.64 43.92,71.8 42.62,73.1 v2(42.62,74.97) 42.6,74.95 42.49,74.95 42.27,75.17 42.27,75.5 v1(42.37,75.61)
  IN3 w0.06: 56.18,114.92 56.19,114.92 56.27,115 58.01,115 58.77,115.76 60.42,115.76 60.72,116.06 61.59,116.06 v10(61.87,116.33)
  IN3 w0.084: v3(34.19,91.52) 38.39,87.33 38.39,86.7 44.5,80.58 44.5,76.85 v2(42.62,74.97) ; 56.18,114.92 56.01,114.92 55.8,115.13 54.64,115.13 54.31,115.46 53.08,115.46 52.26,114.65 51.83,114.65 51.27,114.09 50.86,114.09 50.75,113.98 50.2,113.98 49.73,113.5 49.2,113.5 48.43,112.73 48.43,112.08 47.32,110.97 47.32,110.19 47.85,109.65 47.85,107.38 46.79,106.31 v3(46.79,106.09)
  IN4 w0.089: v3(34.19,91.52) 34.19,97.26 39.8,102.87 42,102.87 44.68,105.55 46.25,105.55 v3(46.79,106.09)
VCC_D3.D6: length 10.5
  IN1 w0.508: v1(109.54,118.43) 108.99,118.98 v2(108.99,119.42)
  IN2 w0.508: v2(108.99,119.42) 110.74,121.17 v2(113.32,121.17)
  IN3 w0.254: v2(113.32,121.17) 113.3,121.17 113.33,121.21 113.33,121.87 113.19,122.01 v3(113.19,122.02)
  IN4 w0.254: 112.83,121.35 113.19,121.72 v3(113.19,122.02) 113.51,122.34 113.51,123.52 v4(112.9,124.12)
  vias: v12(112.83,120.2) v12(112.83,118.7)
VCCGT_SENSE: length 53.9
  TOP w0.305: PR1130.1 114.73,123.46 PC1119.1 114.76,124.32 v9(114.76,124.78)
  GND1 w0.305: v9(114.76,124.78) 114.76,125.11 v2(115.11,125.47)
  IN3 w0.152: v7(76.04,112.42) 76.53,112.42 76.98,112.86 80.28,112.86 81.15,113.72 84.42,113.72 v7(84.61,113.54)
  IN3 w0.203: v7(84.61,113.54) 84.61,113.22 86.48,111.35 90.15,111.35 92.76,113.96 94.91,113.96 96.27,115.32 96.27,115.79 96.27,115.79 96.27,118.37 97.7,119.8 97.7,123.13 98.15,123.57 98.15,124.51 99.77,126.14 109.45,126.14 110.1,125.49 111.52,125.49 111.87,125.14 114.15,125.14 114.48,125.47 v2(115.11,125.47)
VCCIO_SENSE: length 41.9
  TOP w0.254: RC10.2 57.33,129.5 57.48,129.5 57.78,129.81 57.78,131.28 v1(57.81,131.31)
  IN1 w0.254: v1(43.23,137.23) 43.23,137.48 v2(43.42,137.67) ; v2(58.5,131.26) 58.45,131.31 v1(57.81,131.31)
  IN3 w0.06: 63.02,124.68 63.88,123.81 64.03,123.81 65.26,122.58 65.26,122.38 65.39,122.26 65.39,122 65.57,121.82 65.57,121.22 65.53,121.17 65.53,120.82 65.98,120.37 66.81,120.37 v10(67.05,120.13)
  IN3 w0.084: 63.02,124.68 59.94,127.75 59.94,128.07
  IN3 w0.254: v3(43.31,138.14) 43.31,137.78 v2(43.42,137.67) ; v2(58.5,131.26) 58.5,130.65 59.08,130.06 59.08,128.93 59.94,128.07
  GND3 w0.254: v2(58.5,131.26) 58.24,131.51 v8(58.24,132.27)
  IN4 w0.254: v8(58.24,132.27) 58.24,134.07 51.63,140.68 44.45,140.68 43.08,139.31 43.08,138.37 v3(43.31,138.14)
VCCIO_SENSE_R: length 2.7
  TOP w0.254: PU808.5 41.9,137.47 v9(42.32,137.05)
  GND1 w0.254: v9(42.32,137.05) 43.21,136.16 v9(43.23,136.16)
VCCIO_VID0: length 1.5
  TOP w0.254: PTC800.1 41.3,141.77 40.77,142.31 PR822.1
VCCIO_VID1: length 0.7
  TOP w0.254: PR807.1 41.48,142.36 PTC801.1
VCCPLL_OC_EN: length 1.2
  BOTTOM w0.119: U49.4 68.32,96.88 68.02,96.59 R464.2
VCCPRIM_VID0: length 202.1
  TOP w0.119: PR920.1 173.25,99.82 173.12,99.68 170.26,99.68 170.13,99.56 v1(170.13,99.2)
  IN1 w0.084: v2(170.16,98.82) 170.13,98.85 v1(170.13,99.2)
  IN3 w0.06: v3(57.55,123.62) 57.54,123.62 57.55,123.61 58.93,123.61 59.67,122.87 60.36,122.87 61.38,121.86 62.11,121.86 62.68,121.28 63.13,121.28 63.25,121.16 v10(63.59,121.16)
  IN3 w0.084: v3(109.19,91.77) 108.57,91.15 107.68,91.15 106.9,91.93 98.05,91.93 96.77,93.21 87.4,93.21 86.92,92.73 86.92,90.83 86.21,90.12 63.63,90.12 62.91,89.41 47.85,89.41 45.95,91.31 44.22,91.31 42.95,92.58 42.95,93.27 43.44,93.77 43.44,96.9 42.26,98.08 42.26,98.63 42.26,110.03 42.63,110.4 42.63,111.07 42.82,111.26 42.82,115.53 41.24,117.11 41.24,123.43 41.41,123.6 41.41,124.15 v3(41.14,124.42) ; v7(169.98,98.5) 169.98,98.62 170.16,98.8 v2(170.16,98.82)
  IN4 w0.06: 56.29,124.36 56.76,124.36 57.36,123.76 57.41,123.76 v3(57.55,123.62)
  IN4 w0.089: v3(109.19,91.77) 109.43,91.53 154.65,91.53 155.27,92.15 169.29,92.15 169.91,92.78 v4(169.95,92.78) ; 56.29,124.36 56.05,124.36 55.63,124.78 55.62,124.79 55.37,124.79 55.21,124.96 52.09,124.96 52,125.06 51.33,125.06 50.47,125.92 49.62,125.92 49.22,125.52 46.62,125.52 46.49,125.65 44.72,125.65 43.5,124.42 v3(41.14,124.42)
  BOTTOM w0.119: v4(169.95,92.78) 169.98,92.75 v7(169.98,98.5)
VCCPRIM_VID1: length 199.7
  TOP w0.119: PR914.1 170.23,100.2 169.75,99.71 v1(169.75,99.15)
  IN1 w0.084: v2(169.63,98.81) 169.63,99.04 v1(169.75,99.15)
  IN3 w0.06: v10(63.37,121.53) 63.37,121.61 63.24,121.74 63.13,121.74 62.95,121.92 62.94,121.92 62.65,122.22 61.8,122.22 59.97,124.04 v3(59.97,124.06)
  IN3 w0.084: v7(169.38,98.57) 169.61,98.81 v2(169.63,98.81) ; v3(43.83,126.35) 42.94,125.47 42.39,125.47 41.59,124.67 41.59,123.52 41.42,123.35 41.42,117.19 43.01,115.6 43.01,111.19 42.82,111 42.82,110.33 42.44,109.95 42.44,108.7 42.44,98.16 43.63,96.97 43.63,93.69 43.14,93.2 43.14,92.65 44.3,91.49 46.02,91.49 47.93,89.59 62.83,89.59 63.55,90.31 86.13,90.31 86.73,90.91 86.73,92.8 87.32,93.39 96.85,93.39 98.13,92.12 106.97,92.12 107.76,91.33 108.35,91.33 v3(108.81,91.8)
  IN4 w0.06: 55.87,126.06 55.92,126.01 56.05,126.01 56.23,125.82 56.38,125.82 56.52,125.68 57.03,125.17 57.19,125.17 58.3,124.06 58.64,124.06 58.7,123.99 59.91,123.99 v3(59.97,124.06)
  IN4 w0.089: v4(167.94,93.28) 167.94,92.56 167.74,92.36 155.19,92.36 154.57,91.74 110.5,91.74 110.11,92.13 109.14,92.13 v3(108.81,91.8) ; 55.87,126.06 54.75,126.06 54.44,126.37 54.44,126.39 54.43,126.4 54.43,126.62 54.34,126.71 54.12,126.71 53.97,126.55 53.97,126.5 53.81,126.34 53.33,126.34 52.58,127.08 51.79,127.08 51.42,126.7 51.26,126.7 48.61,126.7 48.18,126.28 47,126.28 46.86,126.41 43.88,126.41 v3(43.83,126.35)
  BOTTOM w0.119: v4(167.94,93.28) 167.94,93.47 167.91,93.5 167.91,96.67 169.38,98.13 v7(169.38,98.57)
VCCSA_SENSE: length 57.2
  TOP w0.254: PC1501.2 PR1100.2
  GND1 w0.254: v2(68.86,111.95) 69.02,111.79 v9(69.19,111.79)
  GND1 w0.305: v2(118.26,117.29) 118.76,117.29 v9(118.99,117.06)
  IN1 w0.254: v2(68.86,111.95) 69.38,111.95 70.07,111.27 71.13,111.27 72.43,109.97 79.82,109.97 81.43,111.58 85.01,111.58 85.42,111.99 92.03,111.99 92.3,112.27 103.12,112.27 106.18,115.32 110.55,115.32 111.77,114.1 112.93,114.1 v2(113.27,113.76)
  IN2 w0.305: v2(113.27,113.76) 113.49,113.76 113.72,113.53 114.51,113.53 117.98,117 117.98,117.01 v2(118.26,117.29)
  IN3 w0.254: v2(68.86,111.95) 68.85,111.95 v10(68.63,112.17)
VCCSENSE: length 53.8
  TOP w0.305: v1(114.6,113.86) 115.27,113.86 115.58,114.17 PR1127.2 115.58,115.35 PR1131.2
  GND1 w0.254: v9(70.31,111.85) 70.34,111.88 v2(70.34,112.29)
  IN1 w0.254: v2(70.34,112.29) 71.32,112.29 71.67,111.94 71.92,111.94 72.73,111.13 79.15,111.13 80.87,112.85 84.13,112.85 87.91,116.63 90.27,116.63 93.32,113.59 102.65,113.59 105.66,116.59 111.12,116.59 112.8,114.91 113.02,114.91 114.07,113.86 v1(114.6,113.86)
  IN3 w0.254: v7(70.24,111.92) 70.24,112.19 v2(70.34,112.29)
VCCST_EN: length 21.9
  TOP w0.119: v14(76.45,103.67) 76.33,103.55 R170.2 76.81,102.12 77.41,102.12 77.8,101.73 v1(77.8,101.31)
  IN1 w0.084: v2(76.94,100.83) 77.11,101.01 77.5,101.01 v1(77.8,101.31)
  IN3 w0.084: v2(76.94,100.83) 76.91,100.8 76.73,100.8 v3(76.58,100.65)
  IN4 w0.089: v4(65.48,96.05) 65.66,96.05 65.94,95.77 66.96,95.77 67.84,96.66 70.84,96.66 71.21,96.29 71.36,96.29 71.86,95.79 74.84,95.79 75.35,96.3 75.35,98.13 75.78,98.57 75.78,99.17 76.58,99.97 v3(76.58,100.65)
  BOTTOM w0.119: U50.3 65.6,96.22 R465.2
VCCSTG_EN: length 18.6
  TOP w0.119: v14(77.98,103.81) 77.75,103.58 77.75,102.41 78.97,101.19 78.97,100.62 78.77,100.42 77.75,100.42 77.38,100.79 R184.2 76.36,100.79 v1(76.35,100.8)
  IN1 w0.084: v1(76.35,100.8) v2(76.02,100.8)
  IN3 w0.084: v2(76.02,100.8) 75.84,100.8 v3(75.72,100.68)
  IN4 w0.089: v4(74.73,97.88) 74.73,97.88 74.73,99.68 v3(75.72,100.68)
  BOTTOM w0.119: v4(74.73,97.88) 74.99,97.62 74.99,96.09 74.04,95.14 73.28,95.14 73.04,95.38 C339.1 72.66,95.14 72.16,95.14 72.03,95.27 72.03,95.6 71.53,96.1 R463.2 71.53,96.49 71.82,96.79 U48.4
VSSGT_SENSE: length 57.9
  IN3 w0.152: v7(76.34,112.7) 76.48,112.7 76.85,113.07 80.05,113.07 81.01,114.04 84.89,114.04 85.26,113.67 85.26,113.25 v7(85.24,113.24)
  IN3 w0.203: 115.54,125.69 115.19,126.05 112.27,126.05 111.28,127.04 109.88,127.04 109.56,126.72 99.43,126.72 97.56,124.86 97.56,123.85 97.09,123.39 97.09,120.17 95.58,118.66 95.58,115.61 94.65,114.68 92.5,114.68 89.81,111.99 86.81,111.99 85.56,113.24 v7(85.24,113.24)
  IN3 w0.254: 114.07,123.65 115.54,125.12 115.54,125.69
  IN3 w0.305: v7(113.83,120.7) 113.83,120.99 114.34,121.5 114.34,121.82 114.07,122.09 114.07,123.65
VSSIO_SENSE: length 38.1
  TOP w0.254: v1(57.43,130.57) 57.43,130.19 57.21,129.97 RC9.1
  IN1 w0.254: v2(57.99,130.85) 57.71,130.85 v1(57.43,130.57) ; v2(43.61,138.85) 43.56,138.8 v1(43.23,138.8)
  IN3 w0.06: v10(67.05,119.58) 66.41,120.21 65.97,120.21 65.41,120.77 65.41,121.22 65.45,121.26 65.45,121.77 65.27,121.95 65.27,122.21 65.14,122.34 65.14,122.44 63.94,123.65 63.85,123.65 63,124.5 62.89,124.5
  IN3 w0.084: 62.89,124.5 59.44,127.96
  IN3 w0.254: v2(43.61,138.85) v3(43.61,138.45) ; v3(57.63,132.2) 57.98,131.85 57.98,130.86 v2(57.99,130.85) 57.99,130.65 58.67,129.97 58.67,128.72 59.44,127.96
  IN4 w0.254: v3(43.61,138.45) 43.61,138.83 44.83,140.05 51.17,140.05 57.63,133.59 v3(57.63,132.2)
VSSIO_SENSE_R: length 2.2
  TOP w0.254: PU808.6 42.26,137.97 PR812.1 PR811.1
VSSSA_SENSE: length 60.7
  VCC w0.254: v19(68.42,111.58) 68.58,111.74 v18(68.58,111.79)
  GND1 w0.254: v19(68.42,111.58) 68.31,111.7 v2(68.31,111.9)
  IN1 w0.254: v2(68.31,111.9) 68.31,111.74 68.69,111.36 69.39,111.36 69.91,110.84 70.73,110.84 72.17,109.4 80.19,109.4 81.74,110.95 85.27,110.95 85.68,111.36 92.29,111.36 92.56,111.63 103.39,111.63 106.45,114.69 110.28,114.69 111.51,113.46 112.55,113.46 112.94,113.07 v2(114.27,113.07)
  IN3 w0.254: v2(68.31,111.9) v10(68.31,112.42) ; v7(114.33,119.2) 114.77,119.2 115.41,118.56 115.41,118.45 116.13,117.73 116.83,117.73 116.84,117.74 117.2,117.74 117.45,117.48 117.45,116.25 v2(114.27,113.07)
VSSSENSE: length 54.4
  GND1 w0.254: v9(69.73,111.85) 69.73,112.13 v2(69.8,112.21)
  IN1 w0.254: v2(69.8,112.21) 69.8,112.2 70.18,111.83 71.18,111.83 71.49,111.52 71.74,111.52 72.73,110.53 79.45,110.53 81.14,112.22 84.39,112.22 88.17,116 89.94,116 93.03,112.9 102.86,112.9 105.92,115.96 110.83,115.96 v2(112.2,114.58)
  IN3 w0.254: v2(69.8,112.21) 69.8,112.2 69.8,112.12 v7(69.6,111.92) ; v2(112.2,114.58) 113.09,114.58 114.23,115.72 114.23,117.42 114.1,117.55 114.1,117.93 v7(113.83,118.2)
40_DOCK_DET#: length 266.1
  IN2 w0.079: v2(188.21,128.65) 188.21,128.41 188.51,128.11 200.8,128.11 201.14,127.77 206.54,127.77 208.6,125.72 208.6,120.7 208.28,120.39 208.28,115.8 206.18,113.71 204.38,113.71 201.5,110.82 201.5,107.01 198.34,103.85 184.81,103.85 184.19,103.23 184.18,103.23 184.14,103.18 149.6,103.18 148.62,102.2 142.81,102.2 141.26,103.75 137.87,103.75 v2(136.7,104.92)
  IN3 w0.084: v2(136.7,104.92) 136.63,104.99 v3(136.37,104.99) ; v2(188.21,128.65) 188.05,128.81 188.05,130.52 188.1,130.57 v7(188.1,130.71) 188.1,131.14 189.2,132.24 189.27,132.24 189.79,132.77 189.79,132.84 190.14,133.18 190.26,133.18 v10(190.32,133.24)
  IN4 w0.089: v3(136.37,104.99) 135.85,105.52 133.23,105.52 131.14,103.43 131.14,102.66 v4(131.17,102.63)
  BOTTOM w0.119: R362.1 187.76,130.23 188.1,130.57 v7(188.1,130.71) ; 117.94,92.72 117.98,92.69 131.25,92.69 133.12,94.56 JIO4.40 ; 117.94,92.72 118.8,93.58 118.8,97.79 120.67,99.66 129.14,99.66 131.17,101.69 v4(131.17,102.63) ; 117.94,92.72 117.75,92.53 104.44,92.53 103.42,91.5 98.33,91.5 96.57,93.26 81.95,93.26 81.32,92.64 43.14,92.64 42.76,92.26 39.41,92.26 38.52,93.16 28.78,93.16 26.34,95.6 21.74,95.6 20.66,96.67 DA7.2
+AC_DOCK_IN: length 66.1
  IN1 w0.508: v2(194.62,105.34) 193.26,103.98 190.14,103.98 189.78,103.61 179.88,103.61 177.94,101.67 169.67,101.67 169.67,101.67 168.66,101.67 167.93,101.67 167.93,101.67 167.04,101.67 166.22,102.49 143.19,102.49 140.77,100.07 v2(140.77,99.84)
  IN3 w0.254: v7(203.29,107.36) 202.91,106.97 199.61,106.97 197.95,105.32 195.99,105.32
  BOTTOM w0.508: v7(203.29,107.36) 203.66,107.72 R499.1
  vias: v7(140.46,99.38) v7(140.77,99.39) v7(194.97,105.3) v7(195.25,105.3)
+AMP_AVDD1:
  vias: v1(41.81,85.94) v1(41.81,85.66) v1(42.09,85.94) v1(42.09,85.64) v1(42.21,81.27) v1(42.21,80.97) v1(42.21,80.69)
+BAT_DOCK: length 90.3
  TOP w0.119: v16(148.28,108.71) 149.57,110 v1(149.57,110.12) 150.44,110.12 C366.1 C365.1
  IN1 w0.508: v2(186.23,107.7) 185.94,107.41 179.22,107.41 176.85,105.04 173.53,105.04 172,106.58 172,107.59 171.16,108.44 168.24,108.44 167.33,107.53 158.5,107.53 158.22,107.81
  IN3 w0.508: v7(186.24,108.07) 186.24,107.69 v2(186.23,107.7)
  BOTTOM w0.508: PR544.2 149.57,114.32 150.11,113.77 150.11,111.09 149.85,110.82 ; v7(186.24,108.07) 186.24,107.99 185.85,107.6 185.85,105.65 186.95,104.55 191,104.55 191.89,103.65 197.04,103.65 197.59,104.21 PD104.2
  BOTTOM w2.54: 138.95,100.28 139.6,100.93 147.98,100.93 150.6,98.31 152.93,98.31 152.93,95.04 150.85,92.95 139.01,92.95 138.96,93
  vias: v1(149.83,110.1) v1(154.58,109.41) v1(154.58,109.13) v1(154.58,108.88) v1(154.58,108.63) v1(154.58,108.35) v1(154.81,109.54) v1(154.81,109.26) v1(154.81,109.01) v1(154.81,108.75) v1(154.81,108.47) v1(154.94,98.97) v1(155.04,109.41) v1(155.04,109.13) v1(155.04,108.88) v1(155.04,108.63) v1(155.04,108.35) v1(155.09,98.72) v1(155.22,98.95) v1(155.3,109.54) v1(155.3,109.26) v1(155.3,109.01) v1(155.3,108.75) v1(155.3,108.47) v1(155.37,98.72) v1(155.5,98.95) v1(155.68,98.72) v1(155.83,98.95) v1(155.96,98.72) v1(156.11,98.95) v1(156.26,98.72) v1(156.41,99.89) v1(156.39,98.95) v1(156.54,98.72) v1(156.67,98.97) v1(156.79,98.75) v1(156.95,98.95) v1(157,99.68) v1(157.15,99.46) v1(157.15,99.13) v1(157.1,98.75) v2(150.22,109.41) v2(150.19,108.98) v2(150.22,108.5) v2(150.65,109.36) v2(150.65,108.93) v2(150.65,108.47) v2(151.05,109.34) v2(151.05,108.91) v2(151.05,108.47) v2(151.43,109.11) v2(154.91,99.63) v2(155.14,99.28) v2(155.35,99.66) v2(155.55,99.28) v2(155.75,99.63) v2(155.98,99.28) v2(156.18,99.63) v2(156.41,99.28) v2(156.64,99.63) v2(156.84,99.28) v7(149.15,109.72) v7(149.15,109.44) v7(149.15,109.16) v7(149.15,108.88) v7(149.15,108.6) v7(149.38,109.57) v7(149.38,109.29) v7(149.38,109.01) v7(149.38,108.73) v7(149.38,108.45) v7(149.63,109.67) v7(149.63,109.41) v7(149.61,109.13) v7(149.61,108.85) v7(149.61,108.57) v7(149.86,109.24) v7(149.86,108.96) v7(149.86,108.7) v7(149.86,108.44) v7(149.89,109.54) v7(154.3,99.47) v7(154.32,99.2) v7(154.41,98.96) v7(154.57,99.2) v7(154.56,98.74) v7(154.59,99.47) v7(154.69,98.96) v7(154.81,99.32) v7(154.85,98.73) v7(155,98.96) v7(155.15,98.74) v7(155.3,98.97) v7(155.42,98.74) v7(155.57,98.95) v7(155.73,98.74) v7(155.86,98.96) v7(156.01,98.75) v7(156.15,98.98) v7(156.28,98.75) v7(156.45,98.94)
+BAT_TABLET: length 51.4
  TOP w0.127: v16(149.25,107.23) 149.97,107.95 151.63,107.95 152.53,108.85 152.53,111.39 152.04,111.88
  IN1 w0.508: 167.05,109.23 167.09,109.26 171.32,109.26 172.61,107.98 172.61,106.83 173.78,105.65 176.6,105.65 178.24,107.3 178.24,108.65 178.6,109.01 183.92,109.01 v2(184.81,108.11)
  IN3 w0.508: v7(185.5,108.11) v2(184.81,108.11)
  BOTTOM w0.508: v7(185.5,108.11) 185.24,107.85 185.24,105.4 186.7,103.94 190.61,103.94 191.51,103.05 199.46,103.05 201.02,104.6 PD102.2
  vias: v1(151.92,115.79) v1(152.07,115.53) v1(152.2,115.79) v1(152.32,115.53) v2(166.78,108.57) v2(166.8,108.17) v7(166.19,108.32) v7(166.19,108.02) v7(166.47,108.32) v7(166.47,108.02) v16(165.93,109.49)
+BATT: length 3.4
  BOTTOM w0.127: 166.38,106.57 166.51,106.57 167.72,107.77 v14(167.72,109.34)
  vias: v4(159.46,104.79) v4(159.71,104.79) v4(159.97,104.79) v4(160.12,103.32) v4(160.27,104.79) v4(160.3,103.04) v4(160.45,103.35) v4(160.58,104.79) v4(160.63,103.07) v4(160.75,103.32) v4(160.86,104.79) v4(160.93,103.04) v4(161.06,103.32) v4(161.16,104.79) v4(161.24,103.04) v4(161.36,103.32) v4(161.44,104.79) v4(161.54,103.04) v4(161.64,103.32) v4(161.72,104.79) v4(161.82,103.04) v4(161.95,103.32) v4(162,104.79) v4(162.12,103.04) v4(162.23,103.32) v4(162.4,103.04) v4(162.51,103.32) v4(162.68,103.04) v4(162.79,103.32) v4(162.96,103.04) v4(163.32,104.82) v4(163.63,104.82) v4(163.96,104.84) v4(164.26,104.82) v4(164.57,104.82) v4(164.87,104.82) v4(165.15,104.82) v4(165.46,104.82) v4(165.73,104.82) v4(166.01,104.82)
+BMC_LDO_PD: length 2
  TOP w0.119: U32.E1 37.69,43.34 38.47,44.12 C207.1
+CHG_VIN: length 57.7
  TOP w0.254: PR116.1 38.19,29.51 PC116.1 39.28,29.31 42.54,29.31 PQ104.1
  IN4 w3.048: 43.08,84.64 43.08,32.48
  vias: v1(143.43,111.39) v1(143.71,111.39) v1(149.57,113.63) v1(149.83,113.63) v1(154.61,113.17) v1(154.61,112.89) v1(154.89,113.17) v1(154.89,112.87) v1(155.17,113.17) v1(155.17,112.87) v1(155.45,113.17) v1(155.45,112.87) v1(155.73,113.17) v1(155.7,112.87) v1(155.98,113.17) v1(155.98,112.87) v2(43.43,89.35) v2(43.41,88.89) v2(43.43,88.43) v2(44.17,89.32) v2(44.12,88.76) v2(44.12,88.33) v2(135.23,112.66) v2(135.25,112.13) v2(135.25,111.7) v2(135.53,112.97) v2(135.56,112.41) v2(135.61,111.9) v2(144.07,110.86) v3(43.01,89.11) v3(43.01,88.83) v3(43.01,88.55) v3(43.01,88.27) v3(43.78,89.13) v3(43.78,88.83) v3(43.78,88.52) v3(43.78,88.24) v3(44.46,89.16) v3(44.46,88.85) v3(44.46,88.55) v3(44.46,88.24) v7(134.39,112.89) v7(134.39,112.64) v7(134.39,112.38) v7(134.39,111.62) v7(134.65,112.64) v7(134.65,112.38) v7(134.65,112.13) v7(134.65,111.88) v7(134.65,111.62) v7(134.7,112.89) v7(134.9,112.72) v7(134.9,112.46) v7(134.9,112.21) v7(134.9,111.95) v7(134.9,111.7) v7(135.05,112.94) v7(135.23,113.27) v7(135.36,113.57) v7(143.95,110.5) v7(144.23,110.5) v13(43.71,29.4) v13(44.22,31.41) v13(44.22,30.83) v13(44.22,30.24) v13(44.25,29.66) v13(44.25,29.05) v14(135.37,112.19) v18(159.94,99.58) v18(160.1,99.33) v18(160.22,99.58) v18(160.35,99.33) v18(160.5,99.58) v18(160.6,99.33) v18(160.78,99.58) v18(160.91,99.33) v18(161.09,99.58) v18(161.19,99.33) v18(161.39,99.58) v18(161.47,99.33) v19(43.08,89.19) v19(43.08,88.92) v19(43.1,88.64) v19(43.1,88.36) v19(43.76,88.33) v19(43.81,89.19) v19(43.79,88.89) v19(43.81,88.61) v19(44.48,89.19) v19(44.48,88.94) v19(44.48,88.64) v19(44.48,88.33)
+DCIN:
  vias: v1(144.83,115.99) v1(145.15,116.26) v1(145.08,116) v1(145.36,115.99) v1(145.47,116.24) v1(145.62,115.99) v2(145.52,115.64) v2(145.52,115.18) v2(145.9,115.43) v7(144.91,115.2) v7(144.91,114.92) v7(144.91,114.67) v7(145.16,115.28) v7(145.16,115) v7(145.16,114.7)
+EDP_COM: length 2.5
  BOTTOM w0.254: 75.11,108.24 75.11,108.57 75.4,108.86 75.4,109.43 UC1.A50
  BOTTOM w0.508: RC70.1 75.11,107.05 75.11,108.24
+INV_PWR_SRC: length 4
  BOTTOM w0.127: v16(118.78,108.69) 118.82,108.65 PC403.1
  BOTTOM w0.254: PC403.1 117.58,106.49 PC402.1
  BOTTOM w0.508: PR400.1 119.52,108.11 119.15,107.74 PC403.1
  vias: v4(117.8,106.54) v4(117.8,106.24) v4(121.11,112.13) v4(121.26,111.88) v4(121.41,112.13) v4(121.54,111.88)
+LCDVDD: length 85.8
  TOP w0.127: 103.53,102.47 103.53,103.69 v16(102.74,104.47)
  IN2 w0.508: v2(176.45,106.31) 178.54,106.31 179.36,107.14 192.83,107.14 v2(194.03,108.35)
  IN3 w0.508: v7(194.54,108.35) v2(194.03,108.35) ; v2(176.45,106.31) v7(176.12,106.31)
  IN4 w1.016: 109.07,98.16 109.4,98.16 109.72,97.84 113.96,97.84 115.74,99.63 133.11,99.63 133.43,99.95 138.29,99.95 139.5,101.16 142.64,101.16 143.27,100.53 148.41,100.53 151.78,97.16 161.14,97.16 162.82,98.84 166.55,98.84 168.6,100.88
  vias: v2(107.04,100.07) v2(107.49,100.07) v2(107.93,100.05) v4(168.77,101.62) v4(169.04,101.62) v9(106.88,100.42) v9(107.19,100.42) v9(107.47,100.42) v9(107.77,100.42) v9(108.03,100.42) v9(108.28,100.42) v15(107.37,98.62) v15(107.42,98.31) v15(107.75,98.49) v15(108.05,98.64) v15(108.08,98.31) v15(108.38,98.54)
+LED_AN: length 16.8
  TOP w0.127: C160.1 115.47,103.04 115.86,103.43 115.86,104.28 116.14,104.56 v16(116.38,104.56)
  IN4 w0.508: 122.4,106 122.4,111.18 124.78,113.56 126.85,113.56 v4(127.25,113.16)
  BOTTOM w0.305: v4(127.25,113.16) 126.96,113.16 125.65,111.85 PU400.4
  vias: v2(112.52,102.05) v2(112.93,102.15) v9(113.76,102.67) v9(113.82,102.4) v9(114.07,102.4) v9(114.2,102.66) v15(112.29,102.66) v15(112.57,102.66) v15(112.85,102.66) v15(121.76,103.3) v15(121.95,105.32) v15(122.07,105.55) v15(122.02,103.31) v15(122.2,105.32) v15(122.28,103.3)
+PWR_SRC_AC: length 1.8
  TOP w0.119: v1(138.56,120.03) v16(138.56,120.53)
  IN1 w0.084: v2(138.56,119.62) v1(138.56,120.03)
  IN3 w0.084: v2(138.56,119.62) 138.81,119.88 v7(138.81,120.46)
+RTCBATT: length 6.5
  BOTTOM w0.508: RTCR1.2 23.32,19.78 22.48,18.94 20.83,18.94 20.18,19.59 JRTC1.1
+RTCVCC: length 394.5
  TOP w0.508: 55.94,127.62 55.65,127.92 55.65,129 ; RH7.1 46.35,130.44 CLRP1.1 ; RA18.2 20.43,126.42 19.98,125.97 v13(19.98,118.98) ; v1(174.89,127.18) 172.73,125.02 D9.1 D10.1
  VCC w0.508: v18(56.35,125.55) 56.89,125.02 60.98,125.02 61.92,124.08 62.93,124.08 64.26,122.75 65.27,122.75 65.79,122.23 65.79,121.41 65.37,121 65.37,120.01
  IN1 w0.508: v1(174.89,127.18) 175.06,127.02 180.67,127.02 182.84,129.19 182.97,129.19 v2(183.02,129.14) ; v2(45.49,130.77) v1(45.49,130.24) ; 86.26,138.62 89.93,138.62 90.1,138.79 102.57,138.79 v2(103.25,138.11) ; v13(72.59,143.14) 72.59,139.98 74.2,138.38 85.12,138.38
  IN3 w0.508: 54.93,129.96 53.54,129.96 52.62,130.88 51.99,130.88 51.61,131.26 51.61,131.8 51.33,132.08 51.33,132.1 51.09,132.34 50.16,132.34 49.91,132.08 46.69,132.08 45.79,131.19 ; v2(183.02,129.14) 183.07,129.19 183.12,129.19 v3(183.31,129.38) ; v13(19.98,118.98) 19.98,120.38 21.97,122.36 21.97,125.54 24.99,128.56 25.9,128.56 28.05,130.72 28.05,131.63 28.4,131.97 30.15,131.97 31.39,130.72 34.65,130.72 35.15,131.23 41.5,131.23 44.4,128.34
  GND3 w0.254: v2(65.63,119.5) 65.56,119.57 v8(65.56,119.83)
  IN4 w0.254: v8(65.56,119.83) v5(65.56,119.58)
  IN4 w0.508: 45.41,130.65 45.41,134.72 42.49,137.64 42.49,139.86 42.5,139.86 42.5,140.07 44.04,141.62 51.94,141.62 53.42,140.15 57.35,140.15 57.89,140.68 57.89,143.12 58.9,144.13 58.9,144.77 59.34,145.2 71.17,145.2 71.68,144.69 71.68,144.06 v13(72.59,143.14) ; v4(24.75,88.62) 23.34,90.03 23.34,91.66 23.39,91.71 23.39,97.98 22.45,98.92 22.45,107.61 20.86,109.2 20.86,118.1 v13(19.98,118.98) ; v4(180.87,131.82) 182.93,129.76 ; 193.32,145.25 186.22,145.25 183.86,142.88 183.86,141.46 183.01,140.6 183.01,138.61 182.62,138.22 182.62,137.41 180.56,135.35 180.56,134.96 v4(179.01,133.41) 177.54,131.94 173.69,131.94 169.34,136.28 137.2,136.28 135.41,134.48 135.41,134.12 135.1,133.82 134.17,133.82 133.98,133.63 133.48,133.63 133.25,133.4 132.53,133.4 131.24,132.1 127.35,132.1 126.59,132.86 126.12,132.86 124.26,134.72 123.59,134.72 122.01,136.31 105.08,136.31 103.76,137.62 103.76,137.76
  BOTTOM w0.254: v5(65.56,119.58) UC1.AT19
  BOTTOM w0.508: CH24.1 RTCR1.1 24.97,18.91 25.79,18.91 RTCD1.1 27.34,19.05 v14(27.34,19.79) 27.34,24.24 24.54,27.05 24.54,59.38 19.3,64.61 19.3,73.14 24.23,78.07 24.23,88.1 v4(24.75,88.62) ; v4(180.87,131.82) 179.28,133.41 v4(179.01,133.41)
  vias: v1(55.55,130.04) v1(55.6,129.78) v1(193.24,144.82) v1(193.24,144.54) v2(55.88,129.96) v2(193.85,145.23) v3(45.06,128.26) v3(45.03,127.98) v3(45.16,130.55) v3(45.41,130.39) v3(103.42,137.79) v3(103.62,137.98) v3(194.16,145.35) v3(194.28,145.13) v19(65.34,119.32) v19(65.3,119.04)
+RTCVCC_EC: length 0.3
  IN3 w0.254: v7(194.32,137.24) v2(194.65,137.24)
  vias: v1(195.01,137.25) v4(198.17,138.92)
+SIM_PWR: length 28.5
  BOTTOM w0.508: 215.44,112.33 213.82,113.96 213.82,137.66 212.02,139.46
+SYS_DOCK: length 21
  TOP w0.119: v16(139.6,111) 140.55,111.95 141.87,111.95 PR530.2
  TOP w0.508: v13(150.76,113.6) 150.76,114.89 150.46,115.19 143.95,115.19 PC542.1 142.51,113.72 PR530.2
  IN4 w0.508: v13(150.76,113.6) 153.76,113.6 154.33,113.03 v4(154.33,110.84)
+V_DDR_0_DQ_VREF: length 13.9
  TOP w0.508: 86.86,127.44 85.88,126.46 85.88,125.54 82.73,122.39 82.73,122.16 81.76,121.2 80.92,121.2
  IN2 w0.508: v2(76.49,118.58) 78.1,118.58 v2(80.31,120.79)
  vias: v9(80.62,121.19) v9(80.94,121.17) v10(76.49,118.91)
+V_DDR_1_DQ_VREF: length 11.2
  TOP w0.508: R75.1 83.16,127.5 C86.1 82.73,127.07 82.73,127 82.71,126.98 82.71,125.63 82.52,125.44
  IN2 w0.508: v2(82.01,125.44) 80.81,125.44 v2(76.47,121.1)
  IN3 w0.508: v2(76.47,121.1) 76.36,120.98 v10(76.36,120.8)
  GND3 w0.406: v10(76.36,120.8) 76.47,120.91 v2(76.47,121.1)
  vias: v1(81.53,125.14) v1(81.84,125.14)
+V_DDR_VREF_CA: length 12.3
  TOP w0.508: 77.62,120.18 81.71,120.18 83.76,122.23 87.82,122.23 C124.1 87.91,122.19 R120.1
  IN3 w0.508: v10(76.49,119.55) v2(76.49,119.87)
  vias: v9(76.85,120.02) v9(77.1,120.02)
+VDISPLAY_VCC:
  vias: v13(14.3,54.19) v13(14.88,54.17) v16(12.62,54.04)
+VR_CAP: length 2
  BOTTOM w0.119: C250.1 196.42,133.8 195.85,134.36 194.95,134.36 U34.H1
AC_PRESENT: length 155.8
  TOP w0.119: v1(52.43,128.79) 53.12,128.79 RH14.2
  IN1 w0.084: v2(177.52,130.57) 177.26,130.84 172.63,130.84 168.15,135.32 138.89,135.32 134.93,131.36 133.68,131.36 132.16,129.84 129.66,129.84 129.51,129.99 127.75,129.99 127.01,130.73 126.08,130.73 125.49,131.31 125.47,131.31 125.46,131.33 124.2,131.33 120.35,135.17 120.24,135.29 96.06,135.29 95.66,135.69 95,135.69 94.47,135.15 86.79,135.15 85.24,133.61 77.13,133.61 76.93,133.8 74.6,133.8 74.41,133.62 72.67,133.62 72.07,134.22 68.69,134.22 68.33,134.58 66.51,134.58 65.64,133.71 62.51,133.71 60.21,131.4 58.88,131.4 58.68,131.6 57.72,131.6 57,130.88 57,130.02 56.78,129.81 56.78,129.59 56.26,129.07 54.95,129.07 54.61,129.41 53.9,129.41 53.72,129.23 52.86,129.23 v1(52.43,128.79)
  IN3 w0.084: v2(177.52,130.57) 179.39,128.7 184.36,128.7 185.34,127.73 189.6,127.73 v3(191.67,129.8)
  IN4 w0.089: v3(191.67,129.8) 191.66,129.81 191.66,129.81 191.66,130.61 v4(191.85,130.8)
  BOTTOM w0.119: v4(191.85,130.8) 191.32,131.33 U34.N8
AC_PRESENT_R: length 13.4
  TOP w0.119: RH14.1 v1(54.34,128.77)
  IN1 w0.084: v1(54.34,128.77) v2(54.34,128.41)
  IN3 w0.06: v10(63.8,122.03) 63.8,122.16 63.56,122.4 63.56,122.65 63.39,122.83 62.54,122.83 62.1,123.27 62.05,123.27 60.69,124.63
  IN3 w0.084: 60.69,124.63 57.39,127.93 55.97,127.93 55.33,128.57 54.5,128.57 v2(54.34,128.41)
ACAV_IN: length 81.3
  TOP w0.119: v1(146.05,112.12) 145.68,112.49 PR512.1
  IN1 w0.084: v2(147.14,111.52) 146.65,111.52 v1(146.05,112.12)
  IN3 w0.084: v2(147.14,111.52) 147.32,111.34 147.32,109.5 148.91,107.91 160.25,107.91 167.96,115.62 167.96,119.31 170.78,122.13 170.78,125.33 173.11,127.66 183.49,127.66 186.35,124.79 190.27,124.79 191.11,125.63 191.11,128.31 193.11,130.31 193.11,130.32 193.56,130.77 197.83,130.77 198.22,130.39 v3(198.25,130.39)
  IN4 w0.089: v3(198.25,130.39) 198.15,130.49 198.15,131.16 197.51,131.8 197.51,133.72 196.72,134.51 196.72,135.2 v4(195.76,136.16)
  BOTTOM w0.119: v4(195.76,136.16) 195.4,136.16 U34.C1
ACCEL_INT1#: length 197.5
  IN1 w0.084: v2(61.98,122.98) 62,123 62,123.68 64.41,126.09 66.69,126.09 67.52,126.92 70.13,126.92 70.7,126.35 80.71,126.35 80.95,126.59 85.09,126.59 85.14,126.54 85.25,126.54 85.72,126.07 85.72,126.04 86.78,124.98 86.81,124.98 86.93,124.86 87.4,124.86 88.65,124.86 88.78,124.99 89.06,125.27 92.49,125.27 92.85,125.62 94.22,125.62 94.58,125.99 94.58,126.71 95.04,127.16 95.04,127.75 96.26,128.97 97.5,128.97 97.69,129.15 100.77,129.15 101.5,129.88 103.56,129.88 103.73,129.72 105.18,129.72 106.23,128.66 106.74,128.66 107.34,128.06 109.07,128.06 110.72,126.41 110.72,125.49 111.74,124.48 111.74,122.39 112.37,121.76 113.33,121.76 114.68,120.41 114.68,119.07 114.88,118.87 114.88,118.1 115.7,117.29 115.7,116.68 116.31,116.06 117.2,116.06 117.58,116.44 119.24,116.44 121.75,118.95 123.56,118.95 124.09,119.48 126.22,119.48 126.86,118.84 129.81,118.84 130.23,118.41 134.17,118.41 135.32,119.56 135.32,120.51 136.69,121.88 138.28,121.88 138.81,121.34 141.01,121.34 143.74,124.07 145.74,124.07 146.1,124.42 146.1,127.06 146.24,127.2 148.17,127.2 148.96,127.98 149.74,127.98 150.77,129.01 151.94,129.01 152.71,128.25 152.71,127.08 154.03,125.75 163.42,125.75 167.63,121.54 171.54,121.54 173.73,123.73 180.97,123.73 184.91,127.67 198.55,127.67 199.11,128.23 206.04,128.23 208.25,126.02 211.71,126.02 v2(211.86,126.18)
  IN3 w0.06: v10(63.16,122.52) 62.97,122.71 62.24,122.71 v2(61.98,122.98)
  IN3 w0.084: v7(217.9,116.07) 217.28,116.07 216.73,116.63 213.45,116.63 211.86,118.22 v2(211.86,126.18)
ACCEL_INT2#: length 192.4
  IN1 w0.084: v2(211.86,126.71) 211.39,126.24 208.3,126.24 205.82,128.72 190.84,128.72 188.95,130.61 188.95,131.16 187.48,132.62 184.92,132.62 183.62,131.32 183.62,131.05 180.7,128.14 171.71,128.14 167.86,131.99 152.29,131.99 151.66,131.37 149.83,131.37 147.86,129.4 146.19,129.4 141.11,124.31 137.44,124.31 137.06,123.93 135.61,123.93 134.39,122.71 133.84,122.71 133.01,121.88 132.84,121.88 132.13,121.17 128.78,121.17 128.61,121.01 127.75,121.01 127.57,121.19 127.28,121.19 126.86,120.77 119.5,120.77 117.39,122.88 117.39,123.02 115.99,124.42 114.73,124.42 113.4,125.75 112.9,125.75 112.26,126.39 112.26,126.67 110.69,128.24 110.69,130.09 109.93,130.85 105.86,130.85 105.34,131.38 105.08,131.63 101.03,131.63 99.64,130.24 97.24,130.24 96.87,130.61 96.52,130.61 94.06,128.16 94.06,127.64 93.54,127.11 92.96,127.11 92.09,126.24 88.64,126.24 88.35,125.96 87.19,125.96 86.7,126.45 86.7,126.55 85.65,127.59 80.51,127.59 80.25,127.33 71.11,127.33 70.51,127.93 67.11,127.93 66.27,127.09 64.03,127.09 60.93,123.99 60.93,123.75 60.28,123.11 60.28,123.1 59.99,122.81 v2(59.99,122.31)
  IN3 w0.06: v10(60.29,122.13) 60.22,122.13 60.04,122.31 v2(59.99,122.31)
  IN3 w0.084: v7(214.6,117.01) 214.6,117 213.34,117 212.29,118.05 212.29,126.28 v2(211.86,126.71)
  BOTTOM w0.06: v10(60.29,122.13) 60.88,122.13 UC1.BD2
  BOTTOM w0.119: JIO1.24 217.51,115.68 217.26,115.93 215.68,115.93 v7(214.6,117.01)
ADDR_EQ: length 2.5
  TOP w0.119: UV1.3 120.39,111.46 120.24,111.32 RV4.2 RV6.2
ALERT#: length 0.8
  IN1 w0.109: v1(113.74,119.47) 113.74,119.42 113.68,119.36 113.68,119.15 113.68,119.15 v2(113.68,119.14)
  IN3 w0.06: v7(113.33,119.2) 113.62,119.2 113.68,119.14 v2(113.68,119.14)
ALWON: length 318.4
  TOP w0.119: v1(198.02,143.72) R3.2 199.48,143.72 200.14,143.06 D1.2
  IN1 w0.084: v1(198.02,143.72) v2(198.39,143.72)
  IN2 w0.079: v2(204.5,99.2) 213.46,99.2 213.67,99.41 215.64,99.41 220.43,104.2 220.43,116.21 219.97,116.67 219.97,118.98 220.42,119.43 220.42,134.92 212.51,142.84 205.65,142.84 205.18,142.37 202.83,142.37 201.48,143.72 v2(198.39,143.72) ; v2(200.13,104.84) 199.87,104.84 198.49,103.46 192.33,103.46 191.76,102.89 191.55,102.89 191.51,102.85 184.31,102.85 184.29,102.82 162.85,102.82 v2(160.4,100.37)
  IN3 w0.084: v2(200.13,104.84) 200.13,105.23 v7(200.28,105.39) ; v7(29.08,113.32) 28.52,113.32 27.48,114.37 24.95,114.37 24.43,114.89 22.86,114.89 v3(21.69,113.72) ; v2(204.5,99.2) 204.49,99.2 v3(204.04,99.2) ; v2(160.4,100.37) 160.4,100.09 159.56,99.25 v7(159.56,99.14)
  IN4 w0.089: v3(21.69,113.72) 21.69,110.36 24.12,107.93 24.12,101.11 25.08,100.15 25.08,95.88 v4(24.31,95.11) ; v4(203.6,103.37) 204.5,102.47 204.5,100.38 204.04,99.93 v3(204.04,99.2) ; v4(201.47,106.4) 200.46,105.39 v7(200.28,105.39)
  BOTTOM w0.119: PR608.1 194.51,111.26 PR611.1 194.51,110.09 194.08,109.65 194.08,107.01 194.3,106.8 201.02,106.8 201.41,106.4 v4(201.47,106.4) 201.47,106.34 201.54,106.28 201.54,103.86 202.03,103.37 v4(203.6,103.37) ; v4(24.31,95.11) 24.46,94.95 26.52,94.95 28.54,92.94 38.42,92.94 39.32,92.04 42.9,92.04 43.28,92.41 81.23,92.41 81.41,92.41 82.04,93.04 96.46,93.04 98.22,91.28 153.14,91.28 159.56,97.7 v7(159.56,99.14)
AMP_AGND: length 3.6
  TOP w0.203: UA2.20 31.99,80.49 31.75,80.25 30.89,80.25 30.63,80.51 CA28.2 ; UA2.16 32.58,82.09 v18(32.46,82.21)
  vias: v18(30.61,82.36) v18(30.62,81.26)
AMP_ASEL: length 2.8
  TOP w0.119: UA2.14 32.64,82.89 32.56,82.97 31.83,82.97 31.54,83.26 31.54,83.3 RA38.2 RA37.1
AMP_G0: length 2.3
  TOP w0.119: U21.6 141.35,106.13 141.6,106.39 R159.2 R158.2
AMP_G1: length 2.3
  TOP w0.119: R156.2 R157.2 140.33,106.49 140.85,105.98 U21.7
AMP_I2S_BCLK: length 58.2
  TOP w0.119: v1(36.39,84.92) UA2.6
  IN1 w0.109: v1(36.39,84.92) 36.39,85.46 v2(36.47,85.54)
  IN2 w0.079: v2(26.97,95.8) 25.07,97.7 23.76,97.7 22.49,98.97 22.49,110.14 22.96,110.6 22.96,114.08 23.76,114.89 23.76,121.77 23.39,122.15 23.39,122.46 21.48,124.36 21.48,127.67 23.01,129.19 23.01,129.88 v2(22.72,130.16)
  IN3 w0.084: v7(21.72,129.82) 22.26,129.82 22.6,130.16 v2(22.72,130.16) ; v2(36.47,85.54) 35.13,86.88 35.13,88.42 33.33,90.22 32.13,90.22 26.97,95.37 v2(26.97,95.8)
  BOTTOM w0.119: v7(21.72,129.82) 21.74,129.8 CA47.1 22,128.98 RA50.2
AMP_I2S_BCLK_R: length 11.9
  IN3 w0.084: v7(21.41,134.23) 20.61,135.03 18.3,135.03 18.08,134.81 15.93,134.81 v7(15.55,134.44)
  BOTTOM w0.119: v7(15.55,134.44) 15.55,134.42 15.38,134.24 UA3.56 ; RA50.1 22.01,130.16 22.01,131.22 21.72,131.51 21.72,133.92 v7(21.41,134.23)
AMP_I2S_MCLK: length 64.4
  TOP w0.119: v1(36.79,84.97) UA2.5
  IN1 w0.109: v1(36.79,84.97) 37.14,85.32 37.14,85.5 v2(37.13,85.51)
  IN2 w0.079: v2(27.38,96.23) 27.38,96.26 25.68,97.96 23.77,97.96 22.68,99.05 22.68,110.01 24.07,111.4 24.07,114.54 23.95,114.66 23.95,121.85 23.57,122.22 23.57,122.54 21.67,124.44 21.67,127.59 23.19,129.12 23.19,130.04 24.19,131.04 v2(24.19,131.6)
  IN3 w0.084: v2(27.38,96.23) 27.38,95.23 32.2,90.41 33.41,90.41 35.31,88.5 35.31,87.11 36.4,86.02 36.63,86.02 v2(37.13,85.51) ; v2(24.19,131.6) 24.19,131.18 23.16,130.15 23.16,129.89 22.81,129.53 21.42,129.53 21.22,129.73 v7(21.22,129.75)
  BOTTOM w0.119: CA50.1 21.18,129 20.93,129.25 20.93,129.52 21.16,129.75 v7(21.22,129.75) 21.59,130.11 RA51.2
AMP_I2S_MCLK_R: length 20
  TOP w0.119: RA16.1 9.45,131.02 9.8,131.37 9.8,132.82 10.19,133.2 10.82,133.2 12.18,134.56 v1(12.46,134.56)
  IN1 w0.084: v1(12.46,134.56) 13.03,134.56 v2(13.07,134.6)
  IN3 w0.084: v2(13.07,134.6) 13.22,134.75 14.88,134.75 15.14,134.5 v7(15.14,134.43) 15.4,134.17 15.72,134.17 16.18,134.63 18.2,134.63 18.42,134.84 20.36,134.84 v7(20.98,134.23)
  BOTTOM w0.119: UA3.55 14.98,134.24 15.14,134.41 v7(15.14,134.43) ; v7(20.98,134.23) 20.98,133.83 20.24,133.09 20.24,132.58 20.45,132.36 21.09,132.36 21.41,132.04 21.41,131.17 RA51.1
ANA2_EN: length 20.1
  TOP w0.119: U9.5 142.18,123.17 142.05,123.04 141.35,123.04 139.83,121.53 v1(137.59,121.53)
  IN1 w0.084: v2(137.19,121.53) v1(137.59,121.53) ; v2(129.16,126.58) 129.16,127.18 v1(129.36,127.38)
  IN3 w0.084: v3(133.39,123.93) 133.39,123.23 135.09,121.53 v2(137.19,121.53) ; v2(129.16,126.58) 129.18,126.56 129.18,124.93 129.54,124.58 v3(129.54,124.22)
  IN4 w0.089: v3(129.54,124.22) 129.59,124.17 130.48,124.17 131.5,125.19 132.13,125.19 132.45,124.87 132.45,124.56 133.09,123.93 v3(133.39,123.93)
AUDIO_I2C_SW: length 237.8
  TOP w0.119: v1(206.27,99.48) 206.27,100.08 205.07,101.28 205.07,102.83 203.62,104.28 203.62,106.11 201.89,107.84 201.89,108.08 198.5,111.47 198.5,115.65 193.41,120.74 193.41,126.01 191.74,127.67 v1(191.74,128.16) ; v1(32.83,88.72) 29.15,88.72 28.89,88.47 RA30.1 28.57,88.22 28.45,88.09 28.45,87.32 28.6,87.17 28.93,87.17 29.35,86.74 UA1.5 ; v1(31.81,88.32) 31.31,87.81 UA1.1
  IN1 w0.084: v2(188.7,128.48) 190.25,128.48 190.86,127.86 191.45,127.86 v1(191.74,128.16) ; v1(206.27,99.48) 206.27,99.23 205.17,98.13 198.82,98.13 198.46,97.77 180.86,97.77 179.2,96.1 175.76,96.1 174.61,94.96 169.48,94.96 169.26,94.74 134,94.74 132.27,96.46 124.6,96.46 120.73,96.46 120.09,95.83 118.72,95.83 118.06,95.16 103.07,95.16 101.78,96.46 86.41,96.46 83.99,94.04 82.98,94.04 81.7,92.76 78.16,92.76 78.12,92.8 60.6,92.8 60.36,92.57 46.6,92.57 44.96,94.21 43,94.21 42.09,93.3 38.62,93.3 34,88.69 32.87,88.69 v1(32.83,88.72) 32.16,88.72 31.81,88.38 v1(31.81,88.32)
  IN3 w0.084: v3(187.11,131.93) 187.11,130.96 187.69,130.38 187.69,129.09 187.85,128.94 187.85,128.43 187.98,128.3 188.52,128.3 v2(188.7,128.48)
  IN4 w0.06: v4(189.82,133.24) 189.8,133.24 189.56,133.48 188.69,133.48 188.54,133.33
  IN4 w0.089: v3(187.11,131.93) 187.14,131.93 188.54,133.33
AUDIO_IRQ: length 5.2
  TOP w0.119: RA17.2 v1(20.35,131.7)
  IN1 w0.109: v2(20.27,131.26) 20.35,131.34 v1(20.35,131.7)
  IN3 w0.084: v2(20.27,131.26) 17.21,131.26 v7(17.17,131.22)
  BOTTOM w0.119: UA3.6 16.77,130.82 v7(17.17,131.22)
AUDIO_PWR_EN: length 73.2
  IN1 w0.084: v1(28.93,113.85) 28.89,113.85 27,115.74 26.36,115.74 26.34,115.72 25.53,115.72 v2(25.3,115.48)
  IN3 w0.084: v2(25.3,115.48) 25.02,115.48 v3(24.9,115.37)
  IN4 w0.06: v5(61.04,123.66) 60.84,123.66 60.69,123.81 60.53,123.81 60.4,123.68 59.63,123.68 59.37,123.43 59.32,123.43 59.28,123.38 58.3,123.38 57.13,124.55 56.29,124.55
  IN4 w0.089: v3(24.9,115.37) 24.88,115.39 24.45,115.39 23.2,116.65 23.2,119.92 22.61,120.51 22.61,126.15 23.89,127.43 23.89,129.18 26.36,131.64 26.88,131.64 31.34,136.1 42.61,136.1 44.37,134.34 44.37,131.48 43.75,130.86 43.75,127.21 43.12,126.58 43.12,126.01 43.47,125.65 44.25,125.65 44.43,125.84 46.57,125.84 46.7,125.71 49.15,125.71 49.55,126.11 50.55,126.11 51.41,125.25 52.08,125.25 52.17,125.15 55.29,125.15 55.45,124.98 55.7,124.98 55.97,124.71 56.13,124.55 56.29,124.55
AUDIO_PWR_EN_R: length 18.2
  TOP w0.119: U20.5 v1(35.92,102.19)
  IN1 w0.084: v1(35.92,102.19) v2(35.92,102.69) ; v2(28.41,106.06) 28.52,106.17 28.52,111.22 29.11,111.8 v1(29.4,111.8)
  IN2 w0.079: v2(28.41,106.06) 28.47,106.06 28.91,105.62 28.91,104.05 31.16,101.81 35.04,101.81 v2(35.92,102.69)
AUX_EN_WLAN: length 149.6
  TOP w0.119: D4.3 51.95,132.16 v1(52.22,131.88)
  IN1 w0.084: v2(52.22,131.43) 52.27,131.48 52.27,131.83 v1(52.22,131.88)
  IN2 w0.079: v2(52.22,131.43) 53.62,131.43 54.33,130.72 54.64,130.72 54.87,130.96 54.87,131.21 55.32,131.65 55.45,131.65 58.82,135.02 59.51,135.02 60.71,136.22 68.1,136.22 68.82,136.95 69.84,136.95 70.47,136.31 72.37,136.31 72.45,136.39 81.29,136.39 81.32,136.42 93.97,136.42 94.53,136.98 96.2,136.98 96.67,136.51 97.25,136.51 97.26,136.52 101.42,136.52 v2(102.53,137.63)
  IN3 w0.084: v2(102.53,137.63) 103.07,137.09 123.07,137.09 127.12,133.03 132.26,133.03 132.61,133.38 132.89,133.38 134.36,134.85 165.89,134.85 167.66,133.08 168,132.74 178.4,132.74 179.46,133.8 180.59,133.8 180.82,133.57 180.82,133.56 180.99,133.39 182.74,133.39 183.07,133.72 184.99,133.72 185.53,133.18 185.53,132.2 185.74,131.98 185.74,131.86 185.32,131.43 v3(185.32,131.36)
  IN4 w0.089: v3(185.32,131.36) 185.43,131.25 185.43,131.25 185.59,131.09 186.5,131.09 186.65,131.24 187.35,131.24 188.52,132.41 188.52,132.44 v4(188.82,132.74)
B1-4_PHASE_GT: length 14.8
  TOP w0.508: v13(103.63,123.71) PR1137.2
  BOTTOM w0.254: 104.98,123.1 103.4,123.1 103.05,123.46 103.05,125.47 103.33,125.75 105.13,125.75 105.54,126.15 110.88,126.15 PR1155.1
  vias: v7(104.39,124.06) v7(104.38,123.78) v7(104.38,123.48) v7(104.4,123.2) v7(104.4,122.92) v7(104.41,122.66) v7(104.4,122.36) v7(104.4,122.04) v7(104.72,124.09) v7(104.71,123.8) v7(104.71,123.51) v7(104.73,123.23) v7(104.73,122.95) v7(104.74,122.69) v7(104.73,122.39) v7(104.73,122.07) v7(105.06,124.09) v7(105.05,123.8) v7(105.05,123.51) v7(105.07,123.23) v7(105.07,122.95) v7(105.08,122.69) v7(105.07,122.39) v7(105.06,122.07) v7(105.4,124.09) v7(105.39,123.8) v7(105.39,123.51) v7(105.41,123.23) v7(105.41,122.95) v7(105.42,122.69) v7(105.41,122.39) v7(105.4,122.07) v7(105.68,123.51) v7(105.69,124.09) v7(105.68,123.8) v7(105.7,123.23) v7(105.7,122.95) v7(105.71,122.69) v7(105.7,122.39) v7(105.69,122.07) v10(111.83,121.2) v10(111.83,120.7) v10(111.83,120.2) v10(111.83,119.7)
B4_SLP_S0#: length 142.7
  IN2 w0.079: v2(110.08,129.91) 109.84,130.16 106.13,130.16 105.01,131.27 100.37,131.27 99.72,130.62 96.86,130.62 96.66,130.82 94.88,130.82 93.77,129.71 88.1,129.71 86.45,128.06 84.71,128.06 83.42,129.35 83.09,129.35 83.09,129.35 79.39,129.35 76.93,126.89 64.92,126.89 63.93,125.9 61.57,125.9 60.15,124.48 59.87,124.48 v2(59.87,124.47)
  IN3 w0.06: v7(63.22,121.95) 63.09,121.95 62.97,122.07 62.96,122.07 62.7,122.34 62.1,122.34 61.85,122.34 60.4,123.78 60.4,124.07 60.26,124.21 60.2,124.21 59.93,124.47 v2(59.87,124.47)
  IN3 w0.084: v7(185.7,131.36) 185.59,131.25 185.59,131.25 185.43,131.09 185.19,131.09 183.47,132.81 178.99,132.81 178.55,132.37 167.85,132.37 165.74,134.48 134.52,134.48 133.06,133.01 132.77,133.01 132.41,132.66 126.79,132.66 124.46,134.99 114.61,134.99 114.56,134.94 113.46,134.94 112.99,134.47 112.99,133.76 112.78,133.54 112.28,133.54 110.08,131.34 v2(110.08,129.91)
  BOTTOM w0.119: v7(185.7,131.36) R349.1
B5-8_PHASE_IA: length 18.2
  TOP w0.508: PR1138.1 103.78,118.79 104.17,119.17 v13(104.8,119.17)
  IN4 w0.254: v4(113.18,114.21) 113.18,112.56 v4(113.08,112.46)
  BOTTOM w0.254: PL1104.1 105.32,117.39 103.48,117.39 103.23,117.13 103.23,115.18 103.44,114.97 105.04,114.97 105.41,114.59 110.87,114.59 111.25,114.21 v4(113.18,114.21)
  vias: v7(104.57,117.44) v7(104.57,117.14) v7(104.58,116.86) v7(104.57,116.56) v7(104.59,118.32) v7(104.59,118.03) v7(104.58,117.74) v7(104.88,117.89) v7(104.87,117.59) v7(104.86,117.29) v7(104.87,117.01) v7(104.86,116.71) v7(104.86,116.44) v7(104.88,118.47) v7(104.88,118.19) v7(105.18,117.39) v7(105.17,117.09) v7(105.17,116.5) v7(105.19,118.27) v7(105.19,117.98) v7(105.19,117.69) v7(105.18,116.8) v7(105.47,117.52) v7(105.47,117.22) v7(105.48,116.94) v7(105.47,116.64) v7(105.46,116.37) v7(105.49,118.4) v7(105.49,118.12) v7(105.48,117.83) v7(105.74,118.27) v7(105.74,117.98) v7(105.73,117.68) v7(105.72,117.38) v7(105.73,117.09) v7(105.72,116.79) v7(105.71,116.53) v7(105.98,117.83) v7(105.97,117.52) v7(105.96,117.22) v7(105.97,116.94) v7(105.96,116.64) v7(105.96,116.37) v7(105.98,118.4) v7(105.98,118.12) v10(111.83,119.2) v10(111.83,118.7) v10(111.83,118.2) v10(111.83,117.7)
B+: length 9.1
  TOP w0.381: PR1500.1 178.47,112.23 v13(178.64,112.06)
  TOP w1.016: 119.81,114.19 118.77,114.19 116.03,111.45
  IN1 w0.254: 187.96,114.29 187.99,114.32 189.26,114.32 189.31,114.26
  BOTTOM w0.127: 113.64,110.14 v14(111.65,110.14)
  vias: v1(34.34,137.98) v1(34.34,137.67) v1(34.34,137.37) v1(34.65,137.98) v1(34.65,137.67) v1(34.65,137.37) v2(24.43,111.78) v2(24.84,111.78) v2(25.25,111.78) v2(26.06,111.78) v2(26.47,111.78) v2(113.69,111.83) v2(113.69,111.39) v2(114.05,111.6) v2(121.39,115.33) v2(121.69,115.61) v2(122.1,115.61) v2(148.59,123.87) v2(149.02,123.87) v2(149.45,123.84) v2(150.24,123.87) v2(150.67,123.84) v2(151.1,123.83) v2(152.37,123.97) v2(152.81,123.94) v2(153.24,123.94) v2(154.1,123.94) v2(154.53,123.92) v2(154.97,123.92) v7(24.59,112.11) v7(24.89,112.11) v7(25.15,112.11) v7(25.41,112.1) v7(25.62,111.93) v7(25.61,111.66) v7(25.95,112.1) v7(26.25,112.12) v7(26.72,112.11) v7(27.03,112.11) v7(122.1,116.19) v7(122.1,115.94) v7(122.35,116.19) v7(122.35,115.92) v7(122.43,115.66) v7(122.4,115.41) v7(148.67,124.25) v7(148.69,124.55) v7(148.95,124.55) v7(148.92,124.25) v7(149.2,124.53) v7(149.2,124.25) v7(150.53,124.45) v7(150.56,124.17) v7(150.79,124.45) v7(150.81,124.17) v7(151.07,124.45) v7(151.09,124.17) v7(152.17,124.23) v7(152.38,124.38) v7(152.6,124.22) v7(152.82,124.39) v7(153.02,124.21) v7(153.23,124.37) v7(153.96,124.53) v7(153.98,124.25) v7(154.25,124.53) v7(154.26,124.26) v7(154.54,124.53) v7(154.52,124.27) v9(114.68,111.93) v9(114.76,111.27) v9(114.93,111.8) v9(114.99,111.55) v13(24.67,124.08) v13(25.26,124.06) v13(25.87,124.05) v13(26.26,123.23) v13(26.5,123.98) v13(26.9,123.26) v13(179.24,112.07) v13(179.83,112.06) v13(180.06,111.06) v13(180.24,111.63) v13(192.36,109.49) v13(192.35,108.88) v13(192.96,109.47) v13(192.95,108.88) v13(193.54,109.49) v13(193.54,108.89) v13(203.99,100.62) v15(113.66,111.06) v15(113.66,110.78) v15(114.17,111.27) v15(114.17,111.01) v18(105.56,119.04) v18(105.56,118.79) v18(105.56,118.53) v18(105.56,118.28) v18(105.56,118.02) v18(105.66,119.83) v18(105.66,119.32) v18(105.79,119.57) v18(105.82,118.91) v18(105.82,118.66) v18(105.82,118.4) v18(105.82,118.15) v18(105.82,117.9) v18(105.94,119.83) v18(105.97,119.32) v18(106.1,119.57) v18(106.22,119.83) v18(106.25,119.34) v18(106.37,119.57) v18(120.85,115.28) v18(121.03,115.1) v18(121.23,114.94) v18(121.44,114.72) v21(24.41,112.11) v21(24.41,111.45) v21(24.66,112.11) v21(24.66,111.45) v21(24.92,112.11) v21(24.92,111.45) v21(25.17,112.11) v21(25.17,111.45) v21(25.5,112.13) v21(25.76,112.13) v21(30.76,137.51) v21(30.76,137.2) v21(30.76,136.9) v21(31.06,137.51) v21(31.06,137.2) v21(31.06,136.9) v21(121.08,115.45) v21(121.26,115.64) v21(121.44,115.84) v21(121.67,115.97) v21(121.69,115.2) v21(121.92,115.97) v21(148.49,123.43) v21(148.49,123.18) v21(148.79,123.43) v21(148.79,123.18) v21(149.1,123.43) v21(149.1,123.18) v21(150.44,123.36) v21(150.44,123.1) v21(150.75,123.36) v21(150.75,123.1) v21(151.05,123.36) v21(151.05,123.1) v21(152.68,123.48) v21(152.68,123.23) v21(152.98,123.48) v21(152.98,123.23) v21(153.29,123.48) v21(153.29,123.23) v21(154.25,123.54) v21(154.25,123.28) v21(154.56,123.54) v21(154.56,123.28) v21(154.86,123.54) v21(154.86,123.28)
B+_5V: length 251.7
  IN1 w0.203: v2(25.13,129.89) 25.13,129.16 25.2,129.1 25.2,127.02 24.74,126.56 23.22,126.56 22.51,125.85 22.51,123.47 23.43,122.55 23.43,117.83 23.91,117.35 25.39,117.35 v13(25.83,116.91) ; v2(52.07,137.06) 54.56,137.06 55.55,136.07 56.79,136.07 57.09,135.77 58.98,135.77 59.22,136.01 61.39,136.01 63.04,137.66 65.15,137.66 65.84,138.35 68.11,138.35 70.42,136.03 79.94,136.03 80.48,135.49 84.46,135.49 86.02,137.05 93.67,137.05 v2(93.69,137.04) ; v2(96.41,124.18) 97.9,124.18 99.98,126.27 101.56,126.27 101.69,126.13 102.85,126.13 102.87,126.11 108.94,126.11 109.82,125.23 110.38,125.23 111.31,124.3 111.31,119.95 113.84,117.41 114.96,117.41 115.26,117.11 115.26,116.28 116.07,115.48 117.22,115.48 117.76,116.01 119.57,116.01 122.07,118.52 123.23,118.52 123.82,117.92 129.56,117.92 129.95,117.53 132.67,117.53 133.12,117.98 134.56,117.98 135.9,119.32 135.9,120.18 136.29,120.58 141.07,120.58 144.1,123.61 147.22,123.61 148.63,125.02 148.63,126.83 149.2,127.4 149.99,127.4 151,128.41 151.66,128.41 152.12,127.95 152.12,126.84 153.79,125.17 163.18,125.17 165.81,122.53 165.81,120.77 167.52,119.07 169.24,119.07 170.1,119.93 170.89,119.93 171.35,119.47 171.35,118.68 171.53,118.51 173.83,118.51 173.97,118.37 176.14,118.37 177.1,119.33 179.03,119.33 180.21,118.15 180.49,118.15 182.24,116.4 183.55,116.4 184.29,115.66 190.69,115.66 191.55,114.8 195.36,114.8 196.14,115.59 v1(196.88,115.59) 197.56,114.9 197.56,112.16 v1(197.74,111.98)
  IN3 w0.508: v2(52.07,137.06) 52.07,137.76 51.71,138.12 51.71,139.03 52.08,139.4 52.08,141.43 51.56,141.95 51.56,145.02 49.66,146.93 46.68,146.93 46.18,147.44 42.21,147.44 28.36,133.58 27.33,133.58 25.69,131.94 25.69,130.65 25.13,130.09 v2(25.13,129.89) ; v2(93.69,137.04) 93.79,137.04 94.16,136.67 94.16,134.73 96.43,132.45 96.43,131.75 97.48,130.7 97.48,127.7 97.79,127.39 97.79,126.69 96.61,125.5 96.61,124.39 v2(96.41,124.18)
  vias: v13(25.27,116.5) v13(25.83,116.3)
