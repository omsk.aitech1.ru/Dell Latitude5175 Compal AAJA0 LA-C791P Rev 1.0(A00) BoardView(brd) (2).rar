# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VALW_DSW: length 108.8
  TOP w0.381: RH15.1 RH17.1 RH20.1
  VCC w0.381: 54.03,126.13 53.87,126.13 52.36,124.63 52.36,123.47 52.72,123.12 52.72,122.23 53.42,121.53 53.42,117.57 52.88,117.03
  VCC w0.508: 61.11,118.05 60.73,117.67 60.71,117.69 55.36,117.69 54.88,117.21 54.88,117.17 v18(54.74,117.03) 52.88,117.03 52.88,116.27 51.36,114.75 51.36,111.04 v21(51.31,110.99)
  IN3 w0.254: v2(63.86,118.44) 63.71,118.59 v10(63.59,118.59)
  IN3 w0.381: v3(59.46,93.94) 59.46,93.36 59.07,92.97 51.14,92.97 49.44,94.67 49.44,97.94 50.32,98.82 50.32,99.91
  IN4 w0.381: v3(59.46,93.94) 59.69,93.71 60.42,93.71 60.79,94.08 76.38,94.08 v4(76.97,94.68) ; v4(90.22,102.68) 90.8,102.68 91.82,101.67 94.98,101.67 95.6,101.04 v4(96.16,101.04)
  IN4 w0.508: 50.28,101.43 50.28,104.9 51.36,105.98 51.36,107.51 51.49,107.64 51.49,109.65 51.31,109.83 51.31,110.25
  BOTTOM w0.203: v10(63.59,118.59) 63.94,118.59 UC1.AL15
  BOTTOM w0.381: v4(76.97,94.68) 95.5,94.68 96.16,95.35 v4(96.16,101.04)
  BOTTOM w0.508: 53.04,127.57 50.97,127.57 50.48,128.06 RH62.1 RH59.1 RH58.1
  vias: v1(49.81,101.13) v1(49.81,100.87) v1(50.06,101.13) v1(50.06,100.87) v2(50.42,101.21) v2(51.23,111.52) v2(53.78,127.18) v3(50.28,100.69) v3(50.28,100.43) v3(50.53,100.69) v3(50.53,100.43) v3(51.22,111.12) v3(51.22,110.75) v9(53.87,126.57) v9(54.12,126.57) v12(53.91,126.89) v12(54.19,126.99) v14(53.49,126.28) v19(63.5,118.56) v19(63.5,118.3)
+3VALW_EC: length 24.6
  IN1 w0.254: v2(188.93,135.24) 188.95,135.22 v1(189.29,135.22) ; v1(188.87,133.49) 188.87,133.17 v2(188.9,133.13) 189.16,133.13 189.32,133.3 v1(189.32,133.32)
  IN3 w0.203: v10(193.82,135.24) v2(194.15,135.24)
  IN3 w0.254: v7(189.32,135.24) v2(188.93,135.24)
  IN3 w0.381: v2(188.9,133.13) 188.24,133.13 188.06,132.96 186.97,132.96 186.69,133.24 186.69,133.25 v7(186.55,133.39)
  GND3 w0.254: v2(188.9,133.13) 189,133.24 v15(189.32,133.24)
  BOTTOM w0.254: U34.N4 193.32,130.98 194.07,130.23 v7(194.07,129.78) ; U34.A6 192.47,137.88 192.47,138.33 193.29,139.16 v4(193.29,139.27)
  BOTTOM w0.381: 184.49,133.17 184.49,132.3 184.9,131.89 R352.2 R354.1 184.9,129.76 185.17,129.49 186.5,129.49 186.55,129.54 ; R360.1 R361.1 R362.2 R363.2 186.73,129.36 186.55,129.54 ; R353.1 186.55,130.34 186.63,130.26 186.63,129.62 186.55,129.54 ; R329.1 189.61,139.83 R332.2 R331.2 R330.2 192.58,139.83 v4(192.61,139.85) ; R336.2 R339.2 R342.2 v4(184.77,133.67) ; v7(186.55,133.39) 186.52,133.42 R343.1
  vias: v1(193.23,133.29) v1(193.23,132.7) v1(193.79,135.24) v1(194.26,130.28) v1(194.57,130.3) v1(197.92,134.24) v1(198.03,133.95) v2(193.56,132.99) v2(194.41,129.92) v2(198.25,134.21) v7(193.32,133.24) v7(193.32,132.74) v7(195.98,126.85) v13(191.74,141.59) v14(198.04,132.35) v15(198.57,134.05) v15(198.58,134.32)
+3VALW_EC_L:
  vias: v1(193.89,134.28) v2(194.33,133.82) v10(193.82,134.24)
+3VALW_PD: length 5.8
  TOP w0.508: R254.2 C204.1
  IN1 w0.254: v2(35.97,44.64) v1(35.97,44.31) ; v2(40.11,44.47) 40.3,44.27 v1(40.42,44.27)
  IN2 w0.254: v2(35.97,44.64) 36.14,44.47 v2(40.11,44.47)
+3VALW_TPM: length 83.5
  TOP w0.119: C89.1 28.55,129.94 28.13,130.36 v1(28.13,131.32) ; U2.1 56.62,136.77 56.74,136.9 56.74,137.71 v1(56.79,137.76) 56.98,137.76 C21.1 ; v1(61.27,138.78) 61.12,138.63 61.12,136.02 61.99,135.15 66.2,135.15 66.74,134.61 66.89,134.61 v1(67.2,134.31)
  IN1 w0.084: v1(28.13,131.32) 27.01,131.32 v2(26.78,131.55) ; v2(52.15,125.87) 52.35,125.67 v1(52.5,125.67) ; v1(67.2,134.31) 66.83,134.31 66.02,133.5 62.83,133.5 60.27,130.94 59.36,130.94 59.25,130.83 v2(59,130.83) ; v1(61.27,138.78) 59.83,138.78 58.01,136.95 57.58,136.95 57.47,137.07 57.45,137.08 57.26,137.26 57.26,137.3 v1(56.79,137.76)
  IN2 w0.079: v2(59,130.83) 59,130.59 58.46,130.04 57.35,130.04 56.46,129.16 55.55,129.16 55.4,129.3 53.23,129.3 52.21,128.28 52.21,125.94 v2(52.15,125.87)
  IN3 w0.084: v3(26.8,131.94) 26.78,131.93 v2(26.78,131.55) ; v3(51.71,125.76) 51.83,125.87 v2(52.15,125.87)
  IN4 w0.089: v3(51.71,125.76) 51.18,125.76 50.63,126.3 49.42,126.3 49.01,125.9 46.84,125.9 46.71,126.03 44.35,126.03 44.17,125.84 43.55,125.84 43.31,126.09 43.31,126.5 43.94,127.13 43.94,130.78 44.56,131.4 44.56,134.43 42.71,136.29 31.02,136.29 26.8,132.06 v3(26.8,131.94)
+3VALWP: length 20.5
  IN4 w0.305: v4(187.08,112.64) 186.92,112.48 185.4,112.48 184.89,112.99 184.89,123.61 185.76,124.49 v4(191.34,124.49)
  BOTTOM w0.254: v4(187.08,112.64) 187.7,112.64 PU600.5
+3VLP: length 1.4
  BOTTOM w0.254: PC610.2 186.57,113.12 PU600.6
+3VS: length 271.2
  TOP w0.229: 33.39,54.37 33.05,54.71 v18(32.05,54.71) 31.9,54.71 31.73,54.54 UV2.36
  TOP w0.254: CX14.1 28.65,71.59 28.69,71.63 U25.37 ; UV1.32 129.13,110.46 129.44,110.15 130.02,110.15 ; CV35.1 32.32,52.33 v18(32.1,52.54) UV2.32 ; UV2.6 v13(23.2,52.04) 22.67,52.04 CV23.1 ; RV14.2 130.04,106.61 129.79,106.85 v1(129.79,106.96) ; v1(129.57,110.61) 130.02,110.15 ; 130.02,110.15 CV11.1 ; U31.22 v1(24.01,41.8) ; CV14.1 120.42,105.62 120.42,106.09 121.3,106.96 UV1.12 121.99,106.96 122.5,107.47 122.5,109.72 122.26,109.96 v1(121.67,109.96) ; UV1.36 130.06,112.46 v1(130.2,112.6)
  TOP w0.305: R179.1 37.83,100.01 40.43,100.01 v18(40.44,100.02)
  TOP w0.381: CV35.1 32.83,52.53 33.15,52.85 v18(33.48,52.85) CV45.1 v18(34.12,54.08) 33.92,54.28 RV29.1 33.39,54.37
  TOP w0.508: RV19.1 RV24.1 RV26.1 24.79,59.77 26.01,58.55 v1(27.89,58.55) ; 205.89,136.3 205.88,136.29 197.46,136.29 R24.1 ; Q1.2 207.28,142.49 207.81,141.97 207.81,138.1 207,137.29 ; v13(30.99,129.4) 30.86,129.53 R70.1 ; C202.1 v1(21.96,44.64)
  IN1 w0.381: v2(127.61,108.32) 127.37,108.08 127.37,107.42 127.83,106.96 v1(128.77,106.96) v1(129.79,106.96) ; v1(31.11,49.04) 31.33,49.26 32.82,49.26 33.44,49.88 v1(33.44,49.89)
  IN1 w0.508: 50.84,116.14 50.84,115.75 50.19,115.11 50.19,114.83 47.88,112.52 47.88,107.79 49.38,106.29 v2(49.38,105.88) ; v1(44.3,105.1) 44.3,105.15 43.94,105.5 43.94,108.19 v2(43.23,108.91) ; v1(31.11,49.04) v2(31.11,48.11) ; v2(35.62,57.35) 35.74,57.48 36.06,57.48 v20(36.16,57.57) ; v1(208.81,111.29) 209.51,110.59 210.41,110.59 210.76,110.94 210.76,116.04 210.22,116.58 210.22,116.74 209.8,117.17 209.8,117.19 209.51,117.47 209.49,117.47 209.45,117.52 206.21,117.52 204.98,118.75 204.98,121.62 205.38,122.02 205.38,124.31 205.07,124.63 v1(204.72,124.63) ; v1(81.99,122.27) 82.12,122.39 85.44,122.39 85.96,121.87 96.23,121.87 v2(96.48,121.62) ; v1(21.96,44.64) 21.91,44.64 v2(21.55,45) ; v1(30.51,41.43) v2(30.17,41.43)
  IN2 w0.508: 127.96,108.73 128.21,108.97 128.79,108.97 129.29,109.46 129.29,111.17 v2(128.63,111.83) ; v2(24.03,42.33) 25.36,42.33 26.7,41 28.22,41 28.65,41.43 v2(30.17,41.43) ; v2(49.07,131.33) 49.12,131.33 49.33,131.13 49.33,130.32 48.74,129.73 48.74,127.86 48.69,127.81 48.69,127.68 48.26,127.25 48.26,123.98 47.95,123.68 47.95,122.9 v2(47.78,122.72) 47.16,122.1 47.16,118.85 47.68,118.33 48.44,118.33 49.3,117.46 v2(49.3,116.88) ; v2(35.62,57.35) 35.43,57.16 35.43,50.63 32.71,47.92 31.3,47.92 v2(31.11,48.11)
  IN3 w0.254: v7(61.06,95.72) 61.06,95.85 v2(61.26,96.05) 61.29,96.05 61.59,95.75 v7(61.59,95.2) ; v2(49.3,116.88) 49.09,116.67 49.04,116.67 v7(49.02,116.66) ; v2(96.48,121.62) 96.16,121.3 96.16,120.93 v7(96.16,120.92)
  IN3 w0.508: v3(45.57,127.4) 45.47,127.29 42.11,127.29 40.82,128.59 40.82,129.88 40.48,130.22 35.57,130.22 35.07,129.71 31.29,129.71 v13(30.99,129.4) ; 49.47,123.56 48.63,122.72 v2(47.78,122.72) ; 49.45,101.39 49.78,101.72 49.78,104.87 49.38,105.27 v2(49.38,105.88) 49.38,106.49 50.84,107.96 51.77,107.96 52.39,108.57 52.39,109.12 v7(53.73,110.47)
  GND3 w0.381: v15(42.63,108.99) 43.14,108.99 v2(43.23,108.91)
  IN4 w0.254: 52.27,100.4 52.42,100.4 52.65,100.17 52.65,99.91 53.08,99.48 58.95,99.48 59.38,99.91 v4(59.38,100.6) ; 52.27,100.4 52.27,102.82 v4(52.12,102.97) 51.83,103.27 51.83,103.74 52,103.91 53.44,103.91 v4(53.8,103.56) ; 52.27,100.4 51.98,100.4 50.19,98.62 v3(48.77,98.62) ; v7(48.73,100.7) 49.19,100.24 v7(49.19,99.91)
  IN4 w0.508: 62.94,97.35 62.76,97.53 62.76,99.13 62.77,99.13 62.77,99.53 62.76,99.54 62.76,99.69 62.77,99.69 62.77,100.44 v4(62.76,100.45) ; 45.95,127.04 46.66,127.04 46.99,127.37 46.99,129.05 48.59,130.65 ; v4(96.04,105.91) 95.05,104.92 v4(95.05,103.95) 97.21,103.95 v4(97.87,103.3)
  BOTTOM w0.203: v4(52.12,102.97) 52.12,102.76 53.06,101.82 U47.5 ; U47.57 49.89,99.42 49.4,99.91 v7(49.19,99.91) ; U47.30 60.37,97.02 60.5,96.89 60.5,96.28 v7(61.06,95.72) ; U47.51 50.15,97.02 49.99,96.86 49.99,96.1
  BOTTOM w0.254: v7(49.02,116.66) 49.03,116.65 49.58,116.65 49.73,116.5 50.28,116.5 50.29,116.49 50.33,116.49 50.61,116.45 51.31,116.47 51.35,116.48 52.63,116.48 52.81,116.3 RH91.2 ; 49.58,95.7 50.42,94.86 53.33,94.86 R469.2
  BOTTOM w0.305: RH131.2 v7(49.21,102.05)
  BOTTOM w0.381: v7(47.38,96.59) R457.1 47.4,97.54 R451.1 47.4,99.16 R449.1 R446.1 R444.1 R440.1 ; R453.2 62.7,98.02 R455.2
  BOTTOM w0.406: 93.08,105.06 94.03,105.06 95.05,104.04 v4(95.05,103.95)
  BOTTOM w0.508: 91.26,105.65 91.68,105.22 92.66,105.22 92.82,105.06 93.08,105.06 ; v7(96.16,120.92) 96.16,106.03 v4(96.04,105.91) ; v13(23.2,52.04) 22.44,52.81 22.43,52.8 v16(20.8,52.8) 19.58,52.8 RX3.1 ; v4(97.87,103.3) 97.87,96.37 v7(98.45,95.79)
  vias: v1(21.97,42.45) v1(21.93,32.54) v1(22.8,32.54) v1(23.46,48.55) v1(23.65,55.1) v1(23.84,48.55) v1(24.09,55.1) v1(29.27,58.94) v1(29.29,59.74) v1(29.29,59.34) v1(29.9,78.78) v1(48.89,131.74) v1(49.21,131.74) v1(50.8,117.01) v1(51.06,117.02) v1(119.24,112.77) v1(119.24,110.76) v1(119.24,109.64) v1(119.24,108.52) v1(121.67,112.46) v1(131.83,112.56) v1(131.83,112.18) v1(132.87,101.64) v1(133.16,101.66) v1(133.44,101.67) v1(133.73,101.69) v1(193.83,98.95) v1(194.72,98.94) v1(206.15,136.69) v1(206.45,136.69) v2(21.55,41.93) v2(22.38,32.68) v2(47.78,96.56) v2(48.95,96.41) v2(62.64,96.38) v2(83.31,95.36) v2(83.77,95.54) v2(84.07,95.86) v2(84.38,96.18) v2(99.57,95.48) v2(100.06,95.47) v2(100.58,95.48) v2(101.12,95.48) v2(133.34,102.03) v2(133.77,102.05) v2(134.51,96.08) v2(134.8,96.5) v2(134.98,95.76) v2(135.45,95.74) v2(194.43,99.37) v2(219.36,104.58) v2(219.36,104.15) v2(220.66,118.97) v2(220.66,118.54) v3(221.25,118.6) v4(48.95,130.42) v4(49.25,130.44) v4(62.53,100.36) v7(48.96,95.63) v7(50.34,123.71) v7(50.6,123.71) v7(62.94,96.84) v7(62.94,96.59) v7(135.08,96.17) v7(135.22,96.4) v7(135.36,96.17) v7(135.47,96.4) v7(194.43,100.12) v7(194.43,99.74) v7(219.25,103.77) v7(219.52,103.78) v7(219.78,103.78) v7(221.07,118.86) v7(221.45,118.89) v8(49.45,131.54) v8(49.4,131.26) v18(25.04,79.36) v18(25.2,79.14) v18(27.56,70.3) v18(28.24,71.31) v18(28.68,71.03) v18(33.06,62.87) v18(33.93,60.15) v18(34.56,58.26) v18(34.82,64.68) v18(35.76,63.82) v18(35.76,63.44) v18(41.63,58.3) v18(43.53,100.93) v18(43.66,100.68) v18(43.74,64.73) v18(43.74,62.93) v18(43.74,60.29) v18(43.74,58.51) v18(43.8,100.92) v18(43.94,100.68) v18(44.05,100.92) v18(44.21,100.68) v18(44.3,100.92) v18(44.5,100.69) v18(209.37,133.97) v18(209.68,133.97) v21(47.42,96.28) v21(47.73,96.23) v21(49.45,96.05) v21(49.51,96.31) v21(61.26,96.38) v21(61.54,96.26) v21(62.43,96.12) v21(62.69,96.05) v21(83.65,95.22) v21(83.9,95.22) v21(84.22,95.52) v21(84.4,95.69) v21(84.55,95.9) v21(84.73,96.08) v21(84.96,96.29) v21(85.11,96.5) v21(100.2,95.01) v21(100.46,95.01) v21(100.71,95.01) v21(100.96,95.01) v21(101.22,95.01) v21(101.47,95.01) v21(101.73,95.01) v21(133.78,95.66) v21(133.92,95.35) v21(134.1,95.66) v21(134.2,95.35) v21(134.39,95.66) v21(134.48,95.35) v21(134.66,95.63) v21(134.76,95.38) v21(206.32,133.61) v21(206.57,133.61) v21(219.7,104.64) v21(219.7,104.34) v21(219.69,104.09) v21(220.35,118.71) v21(220.34,118.42) v21(220.38,118.16) v21(220.65,118.16)
+3VS_AUDIO: length 415.7
  TOP w0.381: RA36.2 38.79,86.51 v1(38.58,86.72) ; CA14.1 34.43,85.65 34.99,86.21 v1(35.38,86.21) RA31.2
  TOP w0.508: 30.94,85.41 29.91,85.41 v1(29.5,85) ; 136.04,103.55 136.04,101.55 136.46,101.13 R182.1 ; v13(16.32,142.78) 16.32,141.77 19.26,138.83 23.29,138.83 29.35,144.89 47.14,144.89 48.53,146.28 48.53,147.95 50.06,149.47 58.49,149.47 v13(59.93,148.03) ; L24.1 55.28,122.36 54.99,122.06 54.14,122.06 54,121.93 53.99,121.93 53.78,121.72 53.78,121.7 53.71,121.63 53.26,121.63 ; R149.2 23.37,110 C140.1 21.34,110 20.52,110.81 20.52,117.95 21.11,118.53 v13(21.11,122.41) 21.2,122.5 21.2,124.4 LA1.1 ; v1(11.2,163.26) MIC1.2
  IN1 w0.254: v1(31.34,85.44) 31.34,84.19 v1(31.31,84.15) ; v1(121.98,131.36) 121.84,131.5 v2(121.84,131.87)
  IN1 w0.508: v2(48.18,120.18) 48.18,120.61 49.89,122.32 51.61,122.32 52.01,121.93 ; v2(17.75,115.45) 17.75,114.03 18.4,113.39 18.4,110.39 17.5,109.49 17.5,95.05 23.62,88.93 23.62,87.74 27.23,84.13 27.97,84.13 28.84,85 v1(29.5,85) ; v1(35.38,86.21) 35.38,86.44 36.11,87.16 36.73,87.16 37.17,86.72 v1(38.58,86.72) ; v13(16.32,142.78) 16.32,144.56 17.09,145.33 17.09,152.45 12.4,157.15 12.4,160.17 11.2,161.36 v1(11.2,163.26) ; v1(5.64,116.57) 5.64,118.66 v13(6.5,119.52)
  IN2 w0.508: v2(133.45,110.2) 133.45,108.07 135.94,105.58 v2(135.94,104.38) ; v2(81.05,136.97) 70.69,136.97 59.93,147.72 v13(59.93,148.03)
  IN3 w0.203: v2(121.84,131.87) 121.64,131.66 v7(121.64,131.41)
  IN3 w0.508: v13(6.5,119.52) 6.91,119.93 17.7,119.93 ; v2(133.45,110.2) 133.45,114.57 133.07,114.95 133.07,115.61 132.29,116.39 132.29,119.39 132.28,119.4 ; 17.7,119.93 17.75,119.88 v2(17.75,115.45) 19.13,115.45 21.37,113.2 21.91,113.2 23.2,114.49 24,114.49 24.52,113.97 27.3,113.97 28.39,112.87 v3(28.39,112.03) ; 17.7,119.93 18.66,119.93 21.11,122.37 v13(21.11,122.41) ; v3(47.45,119.29) 47.45,119.47 48.16,120.18 v2(48.18,120.18) ; v7(81.89,137.35) 81.5,136.97 v2(81.05,136.97)
  IN4 w0.305: v4(12.73,140.57) 11.9,140.57 11.31,141.16 11.31,141.59 11.7,141.98 15.52,141.98 v13(16.32,142.78)
  IN4 w0.508: 18.62,123.09 18.47,123.25 18.47,139.8 17.09,141.17 17.09,142.31 16.62,142.78 v13(16.32,142.78) ; 18.62,123.09 20.42,123.09 v13(21.11,122.41) ; 18.62,123.09 17.23,123.09 ; v3(28.39,112.03) 29.01,112.64 32.87,112.64 33.25,112.26 v4(33.3,112.26) 34.08,112.26 36.19,110.15 40.97,110.15 41.88,111.06 42.59,111.06 43.14,111.62 43.14,115.1 44.98,116.94 44.98,118.3 45.97,119.29 v3(47.45,119.29) ; v4(150.72,129.43) 151.1,129.43 v4(152.61,130.94) ; 108.56,130.72 109.64,130.72 113.77,126.6 114.99,126.6 115.62,125.97 117.54,125.97 118.01,125.5 118.01,123.8 118.2,123.62 118.2,122.86 120.83,120.23 120.83,116.3 122.2,114.92 122.81,114.92 124.33,116.45 125.31,116.45 126.74,117.88 127.2,117.88 128.3,118.97 128.3,119.41 128.73,119.85 131.37,119.85
  BOTTOM w0.305: QA2.2 v4(12.73,140.57)
  BOTTOM w0.381: v13(16.32,142.78) 16.32,144.16 16.33,144.17 CA33.1 ; Q17.2 Q17.5 33.74,112.21 33.35,112.21 v4(33.3,112.26)
  BOTTOM w0.508: v7(81.89,137.35) 82.47,137.93 103.03,137.93 108.58,132.37 108.58,131.88 ; 121.23,131.69 121.13,131.79 117.92,131.79 117.66,132.06 114.13,132.06 111.96,129.89 110.65,129.89 109.25,131.29 ; 122.08,129.72 122.81,129 125.25,129 128.26,132.01 131.17,132.01 131.44,131.73 131.44,130.28 132.49,129.24 145.1,129.24 145.29,129.43 v4(150.72,129.43)
  vias: v1(52.44,121.5) v1(52.69,121.66) v1(135.79,104.06) v1(136.07,104.04) v3(132.21,120.06) v3(132.21,119.78) v4(108.38,131.18) v4(108.74,131.18) v7(16.62,123.19) v7(16.62,122.93) v14(5.99,119.92)
+3VS_CAM: length 61
  TOP w0.127: 146.51,130.74 v14(146.51,129.81)
  IN3 w0.61: v2(104.39,130.19) 104.27,130.32 104.27,130.37 104.14,130.5 104.14,135.4 103.35,136.18 101.89,136.18 101.37,136.71
  IN4 w0.61: v3(104.83,129.91) 104.93,130.01 104.93,131.36 106.35,132.78 111.3,132.78 111.89,132.2 117.31,132.2 117.55,131.96 120.22,131.96 121.5,130.67 121.5,129.93 123.61,127.83 126.23,127.83 128.59,125.47 129.41,125.47 130.2,126.25 132.77,126.25 133.38,125.64 143.59,125.64 144.35,126.41 144.35,128.58 144.74,128.97 145.88,128.97 146.61,129.7 146.61,130.42
  vias: v1(104.06,130.24) v1(104.09,129.99) v1(145.93,131.07) v1(145.94,130.82) v1(146.2,131) v1(146.46,130.99) v2(146.25,131.42) v2(146.66,131.41) v3(104.6,129.78) v3(146.05,131.11) v3(146.3,131.06) v3(146.56,131.07) v3(146.82,131.08) v7(100.85,137.09) v7(100.84,136.77) v7(100.84,136.46)
+3VS_CR:
  vias: v13(217.94,122.74) v13(217.95,122.15) v13(217.93,121.56) v16(211.68,124.22)
+3VS_CRRP: length 37.8
  TOP w0.254: R497.2 208.43,109.9 208.05,110.28 208.05,111.93 208.75,112.63 209.64,112.63 210.04,113.03 U14.13 ; U14.1 212.54,118.32 212.88,118.66 214.74,118.66 v1(214.99,118.9)
  TOP w0.381: v1(213.86,108.24) 212.43,108.24 210.8,109.88 U52.5 209.53,109.88 209.51,109.9 R497.2
  TOP w0.508: v1(214.99,118.9) 215.12,118.9 216.31,117.71 v1(216.94,117.71) ; v1(216.85,108.21) R153.1 R152.1 214.31,108.21 214.27,108.24 v1(213.86,108.24) ; R133.1 v1(211.43,120.34)
  IN1 w0.508: v1(213.86,108.24) 213.73,108.37 v1(213.73,110.78) ; v1(214.99,118.9) 214.67,118.9 v1(213.22,120.35) 211.44,120.35 v1(211.43,120.34) ; v1(216.94,117.71) 216.94,115.23 217.32,114.85 217.32,108.68 v1(216.85,108.21)
+3VS_HP: length 1.5
  TOP w0.254: U21.14 140.85,101.69 141.02,101.51 141.02,101.03 C179.1
  vias: v1(138.02,101.44) v1(138.3,101.44) v1(139.95,101.08) v1(140.23,107.3) v1(140.21,101.08) v1(140.41,107.51)
+3VS_NFC: length 10.8
  TOP w0.508: R187.2 210.72,99.93 210.21,100.43 210.21,102.89 v14(210.27,102.95) 210.87,103.55 R501.1 211.72,103.93 R502.1
  BOTTOM w0.203: v7(213.7,98.85) 213.7,98.78 213.48,98.56 JNFC1.2 ; 208.17,95.14 208.34,94.96 JNFC1.19 ; v7(208.38,98.68) 208.5,98.56 JNFC1.1
  BOTTOM w0.254: v7(207.95,96.84) 207.8,96.69 207.8,95.51 208.17,95.14
  vias: v1(207.82,98.69) v1(207.8,97.93) v1(207.8,97.51) v1(210.85,98.86) v1(211.12,98.87) v1(211.72,98.86) v2(208.07,97.75) v2(211.44,98.63) v8(210.82,99.1) v8(210.82,98.85) v8(211.07,99.1) v8(211.07,98.85) v8(211.68,99.12) v8(211.68,98.87)
+3VS_TPM: length 70.9
  TOP w0.254: C6.1 52.76,142.23 U2.14 ; U2.22 50.16,137.77 49.93,137.53 v1(49.81,137.53)
  TOP w0.508: R36.2 56.72,132.26 C50.1 57.34,132.23 57.75,132.64 57.75,136.19 57.73,136.21
  IN1 w0.381: v1(49.81,137.53) 51.38,139.11 52.07,139.11 53.56,140.59 53.56,141.14 53.87,141.14 54.1,141.37 55.68,141.37 57.73,139.31 57.73,138.34
  IN1 w0.508: v1(25.96,129.81) 26.21,130.06 26.21,131.41 25.54,132.08 25.54,134.75 38.99,148.2 46.38,148.2 47.43,149.25 56.56,149.25 57.15,148.66 57.15,147.41 54.84,145.1 54.84,142.95 54.19,142.31 53.86,142.31
  vias: v1(53.45,142.41) v1(53.45,142.13) v1(57.71,137.94)
+3VS_TS: length 190.7
  TOP w0.508: v1(83.49,91.77) 83.49,92.11 83.05,92.56 45.96,92.56 44.78,91.38 44.06,91.38 43.69,91.74 43.69,92.56 45.01,93.88 46.38,93.88 v1(46.75,94.25) ; v1(59.61,106.34) 59.35,106.08 59.35,95.47 59.05,95.18 53.52,95.18 51.47,97.22 v1(50.08,97.22)
  IN1 w0.508: v2(54.08,114.53) 54.08,113.93 54.89,113.11 54.89,111.82 57.15,109.57 57.28,109.44 57.28,108.67 v1(59.61,106.34) 59.95,106 v2(60.57,106) ; v2(83.31,92.27) 83.31,91.95 v1(83.49,91.77) ; v1(46.75,94.25) 47.51,95.01 49.4,95.01 50.27,95.87 50.27,97.03 v1(50.08,97.22)
  IN2 w0.508: v2(83.31,92.27) 83.31,93.06 83.93,93.68 83.93,94.36 85.84,96.27 97.61,96.27 99.56,94.32 119.06,94.32 119.55,93.82 135.61,93.82 137.06,95.26 137.06,101.43 138.79,103.17 141.02,103.17 142.57,101.62 148.86,101.62 149.57,102.33 156.82,102.33 159.66,99.49 163.69,99.49 164.68,100.48 v2(173.9,100.48)
  IN3 w0.254: v2(60.57,106) 60.79,105.77 v7(60.93,105.77)
  BOTTOM w0.127: v14(174.74,104.79) 174.74,104.59 174.21,104.05 174.21,103.63 R432.2
  vias: v4(173.41,101.49) v4(173.74,101.49) v4(173.71,100.14) v4(174.08,100.13) v6(173.47,100.65) v15(53.72,114.35)
+3VS_WLAN: length 14.6
  TOP w0.305: U8.5 51.03,129.38 51.21,129.55 51.21,129.89 50.77,130.32 50.77,131.03 v14(51.32,131.57) 51.33,131.59 51.33,133.2 50.37,134.17 v1(50.01,134.17)
  IN3 w0.508: v2(49.59,134.26) 46.34,134.26 45.67,134.93 45.67,138.15
  vias: v1(44.37,138.85) v1(44.3,138.45) v1(44.48,139.44) v1(44.5,139.08) v1(44.5,138.62) v1(44.86,140.25) v1(44.86,139.97) v1(44.91,139.64) v2(44.81,139.21) v2(44.81,138.78) v2(45.19,139.44) v2(45.19,138.98) v2(45.19,138.55) v15(44.48,138.19) v15(44.6,138.45) v15(44.73,138.19) v15(44.86,138.45) v15(44.98,138.19) v15(45.24,138.19) v15(45.52,138.45) v15(45.49,138.19)
+3VS_WWAN:
  vias: v13(211.66,144.38) v13(211.96,143.77) v13(211.95,130.8) v13(211.95,130.18) v13(212.24,144.36) v13(212.47,130.52) v16(212.66,132.92)
+5V_DOCK: length 20.3
  TOP w0.127: 151.17,101.26 149.95,101.26 149.78,101.43 149.78,104.71 v16(149.43,105.07)
  BOTTOM w1.016: 136.4,100.73 137.02,101.35 137.04,101.35 138.55,102.86 150.6,102.86
  vias: v1(151.33,100.63) v1(151.69,100.85) v1(151.95,100.86) v1(152.2,100.84) v2(151.89,100.52) v2(152.3,100.5) v7(151.51,102.4) v7(151.76,102.4) v7(152.02,102.4) v7(152.27,102.4)
+5V_USB_P1: length 7.5
  BOTTOM w0.381: 17.22,37.66 16.56,37 16.56,32.94 17.3,32.21 MD2.8
  vias: v4(17.93,42.43) v4(17.93,42.14) v4(18.21,42.44) v4(18.21,42.15) v4(18.49,42.43) v4(18.5,42.15) v4(18.81,42.43) v4(18.79,42.13) v4(22.94,46.39) v4(22.95,46.12) v4(23.26,46.39) v4(23.24,46.09) v13(25.49,61.45) v13(25.49,60.81) v13(25.74,62.02) v13(26.12,61.45) v13(26.12,60.81) v13(26.33,62.02) v14(20.79,44.33)
+5VALW: length 120.1
  TOP w0.127: v14(213.4,105.79) 213.91,106.3 v1(214.43,106.3)
  TOP w0.203: U18.4 216.02,105.79 v1(216.12,105.89) ; v1(50.85,103.67) 50.57,103.67 50.32,103.42 49.87,103.42 ; U20.4 v18(35.52,102.33) ; v9(28.88,111.63) U15.4
  TOP w0.254: PU1100.6 107.72,108.9 v13(107.95,109.13) ; v1(49.89,135.24) 49.72,135.24 49.45,134.98 R28.2 49.35,134.93 49.35,135.43 49.05,135.73 U3.4 ; U26.4 41.89,72.98 42.29,73.38 42.29,73.8 ; v18(30.81,62.74) 30.72,62.65 US1.1
  TOP w0.508: v13(35.62,73.93) 38.67,73.93 40.03,75.29 41.69,75.29 42.29,74.69 42.29,73.8 ; PR1556.2 109.54,120.82 v1(109.54,121.99)
  IN1 w0.254: v21(49.66,102.99) 50.35,103.68 50.85,103.68 v1(50.85,103.67) ; v1(109.54,117.03) v2(109.92,117.03) ; v2(50.58,137.6) 49.89,136.91 v1(49.89,135.24)
  IN1 w0.305: v1(107.87,129.56) v2(107.87,129.2)
  IN1 w0.508: v21(26.28,68.3) 27.79,68.3 28.18,67.91 32.49,67.91 35.56,70.98 35.56,73.87 v13(35.62,73.93) ; v1(109.54,121.99) 110.2,122.65 v2(110.2,123.04)
  IN2 w0.508: v2(112.32,122.66) 110.58,122.66 v2(110.2,123.04) 109.12,123.04 108.29,122.21 108.29,117.77 109.03,117.03 v2(109.92,117.03) 111.2,115.75 v2(111.2,112.82)
  IN3 w0.254: v7(68.91,96.19) 68.91,96.73 v2(69.11,96.93) 69.34,96.7 v7(69.34,96.18) ; v2(64.98,96.73) 64.98,96.22 v7(64.92,96.17)
  IN3 w0.508: v2(50.58,137.6) 50.59,137.61 50.6,137.61 50.83,137.84 50.83,139.66 50.7,139.79 50.7,143.86 v13(50,144.56) ; v2(112.32,122.66) 112.41,122.57 v3(112.9,122.57)
  IN4 w0.254: v4(117.35,115.18) 117.04,115.18 115.67,116.55 113.3,116.55 112.24,115.49 112.02,115.49
  IN4 w0.508: v3(112.9,122.57) 112.76,122.57 112.29,123.05 112.29,123.16 111.66,123.79 111.62,123.79 108.97,126.44 108.97,127.7 108.1,128.56 ; 110.9,113.48 110.9,114.37 112.02,115.49
  BOTTOM w0.254: PR409.2 120.17,115.03 119.58,114.44 118.47,114.44 117.73,115.18 v4(117.35,115.18)
  BOTTOM w1.016: 25.59,90.93 23.33,88.67 23.33,78.39 18.29,73.34 18.29,64.12 19.24,63.17 19.24,60.95
  vias: v1(27.85,66.25) v1(31.38,64.9) v1(150.43,106.37) v1(151.23,107.13) v1(151.43,106.95) v1(151.64,107.13) v1(151.76,106.9) v1(195.6,100.37) v1(195.61,99.61) v1(214.41,105.82) v1(214.83,105.83) v1(214.91,106.3) v2(71.86,96.66) v2(179.77,101.84) v2(195.27,99.91) v2(216.15,118.81) v3(108,128.84) v3(108.25,128.89) v4(41.58,118.63) v4(41.65,116.09) v4(41.87,118.63) v4(41.92,116.09) v4(42.27,118.38) v4(42.27,118.1) v4(42.27,117.82) v4(42.27,117.52) v4(42.27,117.21) v4(42.27,116.91) v4(42.27,116.6) v4(42.52,118.15) v4(42.52,117.9) v4(42.52,117.64) v4(42.52,117.34) v4(42.52,117.03) v4(42.52,116.73) v4(42.52,116.47) v4(42.75,117.77) v4(42.75,117.46) v4(42.75,117.16) v4(42.75,116.88) v7(72.21,96.76) v7(72.23,96.5) v7(110.9,112.94) v7(110.9,112.69) v7(179.33,102.24) v7(179.59,102.24) v7(194.93,99.9) v7(194.94,99.63) v7(216.51,118.89) v7(216.78,118.7) v13(25.22,92.32) v13(25.65,92.73) v13(34.04,118.63) v13(34.05,118.02) v13(34.03,117.41) v13(34,116.82) v13(34,116.23) v13(34.66,118.6) v13(34.65,117.99) v13(34.68,117.4) v13(34.68,116.77) v13(34.66,116.17) v13(35.25,118) v13(35.28,117.38) v13(35.29,118.6) v13(35.28,116.78) v13(35.31,116.19) v13(35.87,118.56) v13(35.86,117.98) v13(35.88,117.38) v13(35.92,116.79) v13(35.92,116.19) v18(28.21,113.31) v18(28.46,113.1) v18(28.52,113.39) v18(30.44,64.07) v18(30.44,63.79) v18(30.44,63.52) v18(30.71,64.07) v18(30.71,63.79) v18(30.72,63.52) v18(31.09,64.44) v18(31.09,64.16) v18(31.09,63.87) v18(31.09,63.59) v18(31.09,63.31) v18(33.12,110.84) v18(33.12,110.58) v18(33.12,110.33) v18(33.48,110.84) v18(33.48,110.58) v18(33.48,110.33) v18(33.73,110.71) v18(33.73,110.45) v18(35.81,137.91) v18(35.81,137.66) v18(35.81,137.4) v18(36.07,137.91) v18(42.07,33.49) v18(42.07,33.18) v18(42.37,33.49) v18(42.37,33.18) v18(42.68,33.49) v18(42.68,33.18) v18(42.98,33.49) v18(42.98,33.18) v18(151.41,128.21) v18(151.54,127.96) v18(151.54,127.4) v18(151.55,127.1) v18(151.66,128.21) v18(151.82,127.96) v18(151.82,127.68) v18(151.83,127.4) v18(151.92,128.21) v18(195.45,102.07) v18(195.78,102.1) v18(204.93,125.8) v18(205.21,125.8) v19(179.86,102.28) v19(180.12,102.29) v21(64.82,97.03) v21(65.18,97.03) v21(68.71,96.98) v21(69.44,96.97) v21(71.65,96.99) v21(72.03,96.99) v21(111.31,112.5) v21(111.53,112.92) v21(111.51,112.66) v21(205.8,120.04) v21(205.8,119.7) v21(205.8,119.37) v21(205.8,119.05)
+5VALW_PD: length 13.6
  IN1 w0.381: 39.4,37.2 39.42,37.2 39.9,36.72 39.9,33.23 39.38,32.71 37.72,32.71 37.19,33.24 37.19,33.78 36.74,34.23 36.74,36.65 37.3,37.21 37.3,37.75 36.89,38.16 v1(36.19,38.16)
  vias: v1(39.04,37.18)
+5VALWP: length 13.2
  IN3 w0.305: v7(39.27,120.67) 37.95,121.99 29.51,121.99 27.92,120.4 v7(27.92,119.75)
  vias: v13(39.9,119.65) v13(39.9,119.04)
+5VS: length 60.3
  TOP w1.27: 189.17,107.44 v14(189.17,105.77) 189.17,103.67 190.06,102.78 190.09,102.78
  IN1 w0.254: v2(122.28,130.62) 122.14,130.76 v1(121.97,130.76)
  IN2 w1.27: 148.64,126.13 150.29,126.13 150.6,126.43 166.2,126.43 167.31,125.33 167.31,122.8 168.25,121.86 168.25,114.4 169.42,113.24 171.41,113.24 172.78,111.86 176.81,111.86 178.46,113.52 185.84,113.52 189.08,110.28
  IN3 w0.305: v2(122.28,130.62) 122.59,130.62 v7(122.66,130.55)
  vias: v1(146.41,125.02) v1(146.63,124.68) v1(146.63,124.4) v1(146.7,125.03) v1(146.89,124.68) v1(146.89,124.4) v1(147.01,125.05) v1(190.04,108.68) v1(190.19,108.91) v1(190.45,108.91) v1(190.73,108.91) v1(190.83,108.35) v1(194.27,100.22) v1(194.52,100.21) v2(146.58,126.61) v2(146.81,126.25) v2(146.99,126.63) v2(147.45,126.66) v2(147.42,126.25) v2(190.19,108.37) v2(190.55,108.57) v2(190.55,108.14) v2(193.93,100.22) v7(193.93,99.84) v7(193.93,99.56)
+5VS_AUDIO: length 50.9
  IN2 w2.032: 20.03,106.5 20.05,106.53 20.05,115.72 21.46,117.13 21.46,119.81 18.12,123.15 18.12,126.69 17.13,127.68 17.13,133.81
  IN3 w2.032: 31.28,88.18 30.73,88.18 28.04,90.87 24.69,90.87 23.86,91.7 23.86,94.81 22.97,95.7 22.97,97.01 21.34,98.64 21.34,102.94
  vias: v1(21.19,115.17) v1(21.19,114.86) v1(21.19,114.56) v1(33.32,87.82) v1(33.31,87.47) v1(33.65,87.8) v1(33.65,87.45) v2(17.2,135.7) v2(17.2,135.24) v2(20.44,104.91) v2(20.4,104.4) v2(21.51,115.03) v2(21.51,114.42) v2(32.05,87.89) v2(32.42,88.28) v7(10.95,140.29) v7(11.2,140.43) v7(11.23,140.17) v7(11.23,139.84) v7(13.74,136.95) v7(14.02,137.12) v7(14.02,136.79) v7(14.05,136.39) v7(16.45,136.02) v7(16.45,135.71) v7(16.76,136.01) v7(16.76,135.73) v16(23.95,115.18)
+5VS_NFC: length 13.6
  TOP w0.119: v16(207.34,100.97) 207.91,100.4 v1(207.96,100.4)
  IN1 w0.084: v1(212.4,97.89) 212.4,98.66 210.66,100.4 v1(207.96,100.4)
  IN3 w0.381: v7(208.4,95.48) 212.47,95.48 v2(212.48,95.47) 212.6,95.35 v7(213.72,95.35)
  BOTTOM w0.203: v7(208.4,95.48) 208.52,95.36 JNFC1.17 ; v7(213.72,95.35) 213.71,95.36 JNFC1.18
  vias: v1(212.41,97.54) v1(212.67,97.54)
+AVDD1: length 1.9
  BOTTOM w0.508: LA10.1 9.56,139.44 CA36.1
  vias: v4(10.39,138.78) v4(10.41,138.5) v4(11.12,136.54) v4(11.4,136.54)
+AVDD2: length 3.3
  TOP w0.508: RA19.1 9.86,123.11 v13(9.56,123.41)
  BOTTOM w0.508: CA63.1 10.57,123.74 10.57,124.37 10.83,124.64
+DVDD: length 13
  TOP w0.508: LA1.2 21.5,126.72 21.14,127.09 v13(21.14,127.82)
  IN2 w0.508: v2(18.9,130.11) 18.9,136.86 17.49,138.27 v2(15.75,138.27)
  IN3 w0.381: v2(15.75,138.27) v7(15.75,138.9)
  vias: v1(20.35,130.48) v1(20.32,129.85) v7(16.99,130.38) v7(17.32,130.37) v7(20.59,128.6)
+DVDDIO: length 4.4
  BOTTOM w0.203: 13.86,125.59 13.86,125.93 13.78,126.01 UA3.19
  BOTTOM w0.508: RA56.2 14.19,124.04 CA62.1 13.86,124.18 CA56.1 13.86,125.59
+PVDD:
  vias: v1(40.28,80.23) v1(40.6,85.86) v1(40.6,85.58) v1(40.69,80.1) v1(40.88,85.86) v1(40.88,85.61) v1(42.24,82.54) v1(42.24,82.26)
+VBUS1: length 230.3
  IN1 w0.508: v2(84.54,92.23) 84.54,92.7 86.97,95.13 98.46,95.13 99.74,93.84 117.49,93.84 117.92,93.41 169.82,93.41 169.9,93.49 178.5,93.49 181.46,96.44 201.37,96.44 v2(201.39,96.42)
  BOTTOM w0.508: 35,29.58 37.62,29.58 44.09,36.06 44.09,64.81 40.08,68.82 40.08,70.35 43.22,73.48 43.22,89.29 44.84,90.92 v16(46.81,90.92) 83.96,90.92 84.4,91.37
  vias: v4(16.13,24.73) v4(17.02,24.73) v4(18.06,24.7) v4(18.26,23.43) v4(18.95,24.73) v4(19.3,23.79) v4(19.99,24.7) v4(20.29,23.41) v4(21.26,24.6) v4(21.36,23.43) v4(22.4,24.88) v4(22.4,24.37) v4(22.53,24.63) v4(22.66,24.88) v4(22.66,24.37) v4(22.78,24.63) v4(22.91,24.88) v4(22.91,24.37) v4(23.04,24.63) v7(84.44,91.77) v7(84.78,91.76) v13(12.95,22.34) v13(13.36,22.77) v13(13.36,21.91) v13(13.74,23.23) v13(13.8,22.32) v13(14.17,22.77) v13(32.89,29.56) v13(33.48,29.58) v13(33.48,29) v13(34.07,29.61) v13(34.09,28.97) v13(34.7,28.97) v16(12.55,20.44)
+VBUS1_IN: length 231.4
  TOP w0.119: v14(41.05,36.81) 41.3,36.81 42.18,37.68 PC124.1
  TOP w0.381: v1(31.95,29.25) 31.98,29.28 31.98,30.14 PR121.1
  IN1 w0.203: v2(98.04,91.48) 98.04,91.49 96.82,92.71 88.16,92.71 87.62,92.16 87.62,90.81 86.26,89.45 46.24,89.45 45.52,88.73 45.52,88.56 44.44,87.48 44.44,85.02 44.98,84.47 44.98,76.66 44.21,75.89 44.21,58.7 45.05,57.86 45.05,43 43.16,41.11 v1(43.05,41.11)
  IN3 w0.254: v7(186.5,106.43) 180.8,106.43 180.13,105.76 167.91,105.76 167.44,105.29 159.12,105.29 158.81,105.6 154.32,105.6 154.01,105.29 153.07,105.29 152.42,105.93 v6(151.6,105.93)
  GND3 w0.203: v15(98.88,91.79) 98.35,91.79 v2(98.04,91.48)
  IN4 w0.203: v4(100.28,100.5) 100.87,100.5 101.84,101.47 106.67,101.47 107.78,100.36 108.99,100.36 109.09,100.47 111.05,100.47 111.19,100.61 113.23,100.61 116.15,103.53 118.53,103.53 120.25,101.81 122.5,101.81 125.47,104.78 126.45,104.78 126.97,105.3 127.46,105.3 128.11,105.96 128.61,105.96 130.35,107.7 130.87,107.7 131.35,108.19 132.25,108.19 v7(135.05,110.99) 135.37,110.99 136.85,109.5 136.85,108.24 137.1,108 139.32,108 139.51,108.19 142.47,108.19 145.33,105.33 146.63,105.33 146.66,105.3 147.27,105.3 147.54,105.56 147.54,105.82 147.68,105.96 148.15,105.96 148.54,106.36 151.17,106.36 v6(151.6,105.93)
  BOTTOM w0.203: PD103.2 199.31,106.23 199.01,106.53 194.44,106.53 193.69,105.78 192.99,105.78 192.62,105.41 v14(190.78,105.41) 187.51,105.41 186.5,106.43 v7(186.5,106.43) ; v4(100.28,100.5) 99.57,100.5 98.83,99.76 98.83,97.2 98.99,97.04 98.99,91.89 v15(98.88,91.79)
  vias: v1(16.26,19.12) v1(16.28,18.74) v1(16.28,18.43) v1(16.59,19.12) v1(16.59,18.76) v1(16.59,18.46) v1(17.55,19.01) v1(17.53,18.71) v1(17.53,18.4) v1(17.83,19.01) v1(17.83,18.71) v1(17.83,18.4) v1(41.73,31.44) v1(41.71,31.16) v1(41.71,30.88) v1(41.99,31.54) v1(41.99,31.26) v1(41.99,31) v1(43.05,40.78) v1(43.03,40.45) v1(43.05,40.12) v1(43.06,39.76) v1(43.08,39.39) v1(43.06,39.02) v1(43.05,38.69) v1(43.06,38.36) v14(17.51,21.45)
+VBUS1_PD: length 4.2
  TOP w0.119: v16(37.93,33.2) 37.44,33.2 37.01,33.63 33.99,33.63 PC107.1
  vias: v1(35.23,37.3) v1(35.48,37.3) v1(39.19,38.16) v1(39.69,38.16)
+VCC_CORE: length 60.8
  GND3 w0.254: v2(69.52,119.6) v8(69.52,119.26)
  BOTTOM w0.203: v5(77.1,112.35) 77.1,112.65 v5(77.23,112.79) 77.23,112.86 v5(77.48,113.11) 77.73,112.86 UC1.P58 ; v5(77.1,112.35) 77.12,112.37 77.39,112.37 v10(77.48,112.47) 77.73,112.22 v10(77.73,112.14) ; v5(77.1,112.35) 77.1,112.15 v5(77.26,111.98) ; 79.81,110.35 79.81,110.34 v12(79.23,110.34) ; v12(79.23,111.5) v10(78.96,111.82) 79.23,112.09 v10(79.23,112.14) 79.83,112.14 ; v12(79.23,111.5) 79.89,111.5 ; v12(79.23,111.5) v12(78.96,111.18) v12(79.23,110.8) ; 79.89,112.79 v12(79.23,112.79) v5(78.96,113.11) ; v12(79.23,110.34) v12(79.23,109.89) ; v12(79.23,110.34) v12(79.23,110.8) ; v12(79.23,109.89) 79.84,109.89 ; v12(79.23,109.89) v12(79.23,109.43) 79.86,109.43 ; v5(76.36,112.17) 76.61,111.92 v10(76.68,111.92) ; v5(76.36,112.17) 76.58,112.39 v5(76.7,112.39) ; v5(76.36,112.17) 76.29,112.17 v10(76.04,111.92) 75.79,112.17 UC1.M51 75.64,112.17 v10(75.4,111.92) 75.15,112.17 v5(75.07,112.17) 75,112.17 v10(74.75,111.92) 74.5,112.17 v5(74.43,112.17) 74.35,112.17 v10(74.11,111.92) ; 79.93,111.5 79.93,111.5 ; v10(73.14,112.17) 72.89,112.42 v10(72.82,112.42) 72.74,112.42 v5(72.5,112.17) 72.25,112.42 v10(72.17,112.42) 72.1,112.42 v5(71.85,112.17) 71.61,112.42 v10(71.53,112.42) 71.45,112.42 v5(71.21,112.17) 70.96,112.42 UC1.N36 70.81,112.42 v5(70.56,112.17) 70.32,112.42 UC1.N34 70.17,112.42 v5(69.92,112.17) 69.67,112.42 v5(69.6,112.42) 69.52,112.49 v5(69.52,112.87) ; v12(79.23,110.8) 79.85,110.8 79.85,110.8
  BOTTOM w0.254: 103.43,114.47 103.43,113.94 PH1102.2 ; 103.43,114.47 103.15,114.47 102.74,114.87 102.74,117.26 102.56,117.44 101.02,117.44 PL1104.2 ; 103.43,114.47 104.83,114.47 105.16,114.14 110.72,114.14 111.07,113.78 114.6,113.78 PC1132.2 115.2,114.4 PR1144.2 116.41,114.4 PC1129.2 116.48,114.47 PC1130.2 116.4,115.26 115.72,115.26 PR1146.2
  BOTTOM w0.356: v5(72.49,116.22) v10(72,116.22) v5(71.5,116.22) v7(71.01,116.22) v5(70.51,116.22) v10(70.02,116.22) ; v5(72.49,116.22) v5(72.49,115.66) v5(72.49,115.1) v10(72.49,114.55) v5(72.49,113.99) UC1.T41 UC1.R41 ; v5(72.49,116.22) UC1.AF41 v5(72.49,117.34) v10(72.49,117.9) v5(72.49,118.46) v5(72.49,119.02) v5(72.49,119.58) v10(72.49,120.13) v5(72,120.13) v10(71.5,120.13) v5(71.01,120.13) v10(70.51,120.13) v5(70.02,120.13) v10(69.52,120.13) v5(69.52,119.58) v5(69.52,119.02) v5(69.52,118.46) v10(69.52,117.9) v5(69.52,117.34) v5(69.52,116.78) v5(69.52,116.22) v4(69.52,115.66) v4(69.52,115.1) v10(69.52,114.55) v5(69.52,113.99) v5(69.52,113.43) v5(69.52,112.87)
  vias: v1(69.72,113.74) v1(72.86,119.32) v1(72.83,118.76) v1(72.86,118.2) v1(72.86,117.64) v1(72.86,117.08) v1(72.86,116.53) v1(72.89,115.97) v1(72.89,115.41) v1(72.89,114.85) v1(72.89,114.29) v1(72.89,113.73) v1(72.89,113.17) v1(72.89,112.61) v1(73.27,111.53) v1(73.84,111.52) v1(74.37,111.52) v1(74.97,111.53) v1(76.11,111.53) v1(76.72,111.52) v1(77.24,111.52) v1(77.88,112.13) v1(78.51,112.13) v1(79.15,112.13) v2(69.52,118.49) v2(69.52,117.44) v2(69.52,116.25) v2(69.52,115.13) v2(69.52,114.01) v2(70.11,120.13) v2(70.45,116.22) v2(71.09,120.13) v2(71.51,116.22) v2(71.85,112.42) v2(72.08,120.13) v2(72.49,119.6) v2(72.49,118.48) v2(72.49,117.37) v2(72.49,116.25) v2(72.49,115.13) v2(72.49,114.01) v2(72.49,112.42) v2(72.83,112.1) v2(73.78,111.93) v2(74.43,111.92) v2(75.08,111.9) v2(76.36,111.91) v2(76.99,111.98) v2(77.82,112.47) v2(78.24,112.46) v2(78.65,112.46) v2(79.28,112.47) v2(98.42,116.45) v2(98.42,115.61) v2(98.63,116.04) v2(98.65,115.2) v2(98.83,116.42) v2(98.86,115.61) v2(99.06,116.02) v2(99.09,115.2) v2(99.26,116.42) v2(99.29,115.61) v2(99.49,116.02) v2(99.52,115.2) v2(99.67,116.45) v2(99.72,115.64) v2(99.9,116.02) v2(99.95,115.23) v2(100.13,116.45) v2(100.18,115.64) v2(100.33,116.02) v2(100.41,115.23) v2(100.53,116.45) v2(100.61,115.61) v2(100.79,116.02) v2(100.84,115.2) v2(100.96,116.45) v2(101.07,115.64) v2(101.22,116.04) v2(101.29,115.23) v2(101.4,116.42) v2(101.47,115.61) v2(101.65,116.04) v2(101.7,115.2) v2(101.83,116.42) v2(101.9,115.61) v2(102.13,115.2) v5(72.17,111.92) v5(72.49,113.4) v5(72.82,111.92) v5(73.78,112.17) v5(77.97,113.11) v5(78.47,113.11) v7(91.49,111.39) v7(91.49,111.01) v7(91.49,110.63) v7(91.49,110.25) v7(91.49,109.87) v7(91.74,111.39) v7(91.74,111.01) v7(91.74,110.63) v7(91.74,110.25) v7(91.74,109.87) v7(92.07,111.93) v7(92.07,111.67) v7(92.13,111.39) v7(92.13,111.01) v7(92.13,110.63) v7(92.13,110.25) v7(92.13,109.87) v7(92.38,111.39) v7(92.38,111.01) v7(92.38,110.63) v7(92.38,110.25) v7(92.38,109.87) v7(92.61,111.99) v7(92.61,111.73) v7(92.71,112.44) v7(92.76,111.39) v7(92.76,111.01) v7(92.76,110.63) v7(92.76,110.25) v7(92.76,109.87) v7(92.86,111.99) v7(92.86,111.73) v7(92.96,112.44) v7(93.01,111.39) v7(93.01,111.01) v7(93.01,110.63) v7(93.01,110.25) v7(93.01,109.87) v7(93.12,111.99) v7(93.12,111.73) v7(93.22,112.44) v7(93.47,112.44) v7(93.4,111.39) v7(93.4,111.01) v7(93.4,110.63) v7(93.4,110.25) v7(93.4,109.87) v7(93.65,111.39) v7(93.65,111.01) v7(93.65,110.63) v7(93.65,110.25) v7(93.65,109.87) v7(93.73,112.44) v7(93.82,111.99) v7(93.82,111.73) v7(93.98,112.44) v7(94.08,111.99) v7(94.08,111.73) v7(94.03,111.39) v7(94.03,111.01) v7(94.03,110.63) v7(94.03,110.25) v7(94.03,109.87) v7(94.23,112.44) v7(94.33,111.99) v7(94.33,111.73) v7(94.28,111.39) v7(94.28,111.01) v7(94.28,110.63) v7(94.28,110.25) v7(94.28,109.87) v7(94.49,112.44) v7(94.82,112.44) v7(94.82,112.18) v7(94.82,111.67) v7(94.82,111.42) v7(94.82,110.91) v7(94.82,110.66) v7(94.82,110.15) v7(94.82,109.9) v7(95.07,112.44) v7(95.07,112.18) v7(95.07,111.67) v7(95.07,111.42) v7(95.07,110.91) v7(95.07,110.66) v7(95.07,110.15) v7(95.07,109.9) v7(100.08,117.06) v7(100.1,118.46) v7(100.1,118) v7(100.1,117.54) v7(100.22,118.23) v7(100.23,117.77) v7(100.23,117.31) v7(100.2,116.8) v7(100.36,117.03) v7(100.38,118.43) v7(100.38,117.97) v7(100.38,117.52) v7(100.53,118.2) v7(100.51,117.74) v7(100.51,117.29) v7(100.66,118.43) v7(100.66,117.97) v7(100.66,117.52) v7(100.63,117.03) v7(100.81,118.2) v7(100.79,117.74) v7(100.79,117.29) v7(100.79,116.8) v7(100.94,118.43) v7(100.94,117.97) v7(100.94,117.52) v7(100.91,117.03) v7(101.07,117.74) v7(101.07,117.29) v7(101.09,118.2) v7(101.22,118.43) v7(101.22,117.97) v7(101.22,117.52) v7(101.19,117.03) v7(101.37,118.2) v7(101.35,117.74) v7(101.35,117.29) v7(101.35,116.8) v7(101.47,117.03) v7(101.5,118.43) v7(101.5,117.97) v7(101.5,117.52) v7(101.65,118.2) v7(101.63,117.74) v7(101.63,117.29) v8(69.52,118.15) v8(69.52,117.03) v8(69.52,114.79) v8(69.52,113.68) v8(69.77,120.13) v8(70.75,120.13) v8(71.74,120.13) v8(72.49,119.26) v8(72.49,118.14) v8(72.49,117.03) v8(72.49,115.91) v8(72.49,114.8) v8(72.49,113.67) v9(69.75,118.15) v9(69.7,117.13) v9(69.73,116.51) v9(69.84,119.71) v9(70.83,120.34) v9(98.25,114.67) v9(98.25,114.26) v9(98.35,115.05) v9(98.45,114.49) v9(98.58,113.88) v9(98.68,114.65) v9(98.65,114.26) v9(98.83,113.91) v9(98.88,114.47) v9(99.09,113.88) v9(99.29,114.9) v9(99.31,114.47) v9(99.29,114.06) v9(99.54,114.65) v9(99.52,114.26) v9(99.52,113.88) v9(99.75,114.92) v9(99.75,114.47) v9(99.72,114.06) v9(99.92,114.67) v9(99.9,114.26) v9(99.91,113.87) v9(100.18,114.92) v9(100.15,114.47) v9(100.13,114.06) v9(100.36,114.67) v9(100.33,114.26) v9(100.33,113.87) v9(100.53,114.06) v9(100.61,114.92) v9(100.58,114.47) v9(100.74,114.26) v9(100.76,113.91) v9(100.84,114.67) v9(100.96,114.06) v9(101.07,114.9) v9(101.07,114.47) v9(101.17,113.88) v9(101.27,114.7) v9(101.24,114.23) v9(101.45,114.9) v9(101.42,114.49) v9(101.41,114.02) v9(101.57,114.24) v9(101.63,114.67) v10(73.46,111.92) v10(78.22,112.14) v10(78.71,112.14) v10(78.97,112.47) v12(77.73,112.79) v12(78.22,112.79) v12(78.71,112.79) v16(100.05,111.76) v18(70.36,111.2) v18(70.92,111.2) v18(71.48,111.2) v18(72.03,111.2) v18(72.67,111.51) v18(80.42,109.84) v18(80.68,109.84) v18(81.21,112.1) v18(81.32,109.83) v18(81.47,112.1) v18(81.57,109.83) v18(82.1,112.12) v18(82.18,109.84) v18(82.35,112.12) v18(82.43,109.84) v18(82.98,112.11) v18(83.07,109.83) v18(83.24,112.11) v18(83.32,109.83) v21(69.47,113.68) v21(69.49,118.15) v21(69.5,116.97) v21(69.48,114.8) v21(69.86,116.27) v21(70.61,120.2) v21(71.42,120.21) v21(72.83,119.58) v21(72.83,118.48) v21(72.84,117.36) v21(72.83,116.25) v21(72.83,115.13) v21(72.83,114) v21(72.82,111.73) v21(73.01,112.38) v21(73.07,111.73) v21(73.46,111.72) v21(73.87,112.44) v21(74.08,111.71) v21(74.1,112.07) v21(74.61,111.65) v21(74.75,112.44) v21(74.76,112.03) v21(75.06,112.44) v21(75.25,111.62) v21(75.39,112.07) v21(76.03,112.02) v21(76.09,112.41) v21(76.41,111.57) v21(76.66,112.06) v21(76.68,111.78) v21(76.8,112.41) v21(77.1,112.41) v21(77.37,111.99) v21(77.5,111.73) v21(77.81,111.73) v21(78.11,111.73) v21(78.2,112.11) v21(78.42,111.73) v21(78.72,111.73) v22(70.77,116.22)
+VCC_GT: length 48.3
  GND1 w0.254: v9(76.43,118.09) 76.23,118.09 v2(76.04,117.9) ; v2(79.22,114.72) v5(79.23,114.72) v9(79.56,114.39) 79.25,114.08 v2(79.23,114.08) ; v9(76.43,115.7) 76.09,115.7 v2(76.05,115.66) ; v2(78.28,114.72) 78.32,114.72 v9(78.67,114.37) 78.38,114.08 v2(78.21,114.08) ; v2(77.23,114.08) 77.48,114.08 v9(77.78,114.37) 77.78,114.44 77.5,114.72 v2(77.27,114.72)
  BOTTOM w0.127: v5(75.4,112.42) 75.29,112.52 74.84,112.52 74.75,112.43 v5(74.75,112.42) 74.67,112.42 74.58,112.51 74.2,112.51 v5(74.11,112.42) 74.04,112.42 73.92,112.53 73.58,112.53 v5(73.46,112.42) ; v5(75.96,112.87) 75.95,112.79
  BOTTOM w0.229: v5(75.96,112.87) UC1.T51 v5(75.96,113.43)
  BOTTOM w0.254: PR1147.1 PR1145.1 115.34,123.75 115.34,126.53 115.01,126.86 PC1128.2 PC1127.2 PR1143.2 112.37,127.35 104.7,127.35 104.27,126.91 102.72,126.91 PH1101.2 102.67,125.95 102.67,123.38 102.39,123.1 100.89,123.1 ; UC1.AT50 74.97,120.13 v5(74.97,120.13)
  BOTTOM w0.279: v5(72.99,113.43) v12(73.48,113.43) v5(73.98,113.43) v12(74.48,113.43) v5(74.97,113.43) 75.47,113.43 ; UC1.Y50 v5(74.97,114.55) v10(74.48,114.55) v5(73.98,114.55) v12(73.48,114.55) v5(72.99,114.55) ; v5(72.99,115.66) UC1.AC50 ; v5(74.97,120.13) v12(74.48,120.13) v5(73.98,120.13) v12(73.48,120.13) v5(72.99,120.13)
  BOTTOM w0.305: v5(75.96,116.78) UC1.AG53 ; v5(72.99,116.78) UC1.AF44 v5(73.98,116.78) UC1.AF47 v5(74.97,116.78) UC1.AF50 ; UC1.AK50 v5(74.97,117.9) v10(74.48,117.9) v5(73.98,117.9) UC1.AK44 v5(72.99,117.9) ; UC1.AN50 v5(74.97,119.02) UC1.AN47 v5(73.98,119.02) UC1.AN44 v5(72.99,119.02)
  vias: v1(76.07,119.37) v1(76.42,119.35) v1(76.75,119.23) v1(76.8,118) v1(76.78,116.81) v1(77,119.23) v1(77.1,118) v1(77.09,116.81) v1(77.26,119.23) v1(77.41,118) v1(77.39,116.81) v1(77.44,116.34) v1(77.71,118) v1(77.7,116.81) v1(77.75,116.34) v1(78.05,116.34) v1(78.69,116.45) v1(79.01,118.55) v1(79,116.45) v1(79.31,118.55) v1(79.3,116.45) v1(79.62,118.55) v1(79.66,114.81) v1(79.92,118.55) v1(79.96,114.92) v1(79.91,114.66) v1(79.91,114.39) v1(80.16,114.39) v1(80.21,114.9) v1(80.24,114.65) v1(81.62,118.48) v1(81.92,118.48) v1(82.22,118.48) v1(82.53,118.48) v1(83.37,117.92) v1(83.67,117.92) v1(83.97,117.92) v1(84.28,117.92) v1(85.74,116.89) v1(85.97,118.35) v1(86.05,116.89) v1(86.27,118.35) v1(86.35,116.89) v1(86.58,118.35) v1(86.66,116.89) v1(86.88,118.35) v2(74.06,120.13) v2(74.05,119.02) v2(74.06,117.9) v2(74.05,116.78) v2(74.06,115.66) v2(74.07,114.55) v2(74.03,113.43) v2(75.05,120.13) v2(75.05,119.02) v2(75.05,117.9) v2(75.04,116.78) v2(75.05,115.66) v2(75.06,114.55) v2(75.01,113.43) v2(76.04,119.02) v2(76.04,116.78) v2(76.05,114.55) v2(76.02,113.43) v2(77.21,116.01) v2(77.27,115.36) v2(78.21,116.01) v2(78.27,115.36) v2(79.22,116.01) v2(79.3,115.36) v2(99.17,122.64) v2(99.16,122.21) v2(99.16,121.8) v2(99.21,123.92) v2(99.2,123.49) v2(99.18,123.07) v2(99.62,123.95) v2(99.61,123.52) v2(99.6,123.1) v2(99.58,122.67) v2(99.59,122.24) v2(99.59,121.83) v2(99.97,124.17) v2(99.97,123.75) v2(99.97,123.3) v2(99.95,122.87) v2(99.96,122.45) v2(99.96,121.6) v2(99.98,122.03) v2(100.38,123.93) v2(100.37,123.49) v2(100.36,123.05) v2(100.34,122.62) v2(100.36,122.21) v2(100.32,121.78) v2(100.3,121.35) v2(100.77,121.56) v2(101.25,121.6) v2(101.7,124.17) v2(102.06,123.33) v2(102.05,122.91) v2(102.03,122.48) v2(102.04,122.06) v2(102.01,121.64) v2(102.08,123.76) v2(102.47,123.95) v2(102.45,123.52) v2(102.46,123.08) v2(102.44,122.65) v2(102.43,122.2) v2(102.41,121.77) v4(77.97,113.75) v4(78.22,116.01) v4(78.96,113.75) v5(73.98,115.66) v5(74.97,115.66) v5(75.96,119.02) v5(75.96,117.9) v5(75.96,115.66) v5(75.96,114.55) v5(77.23,116.01) v5(77.23,115.36) v5(77.23,114.72) v5(77.23,114.08) v5(77.48,113.75) v5(78.22,115.36) v5(78.22,114.72) v5(78.22,114.08) v5(78.47,116.33) v5(78.47,113.75) v5(79.23,116.01) v5(79.23,115.36) v5(79.23,114.08) v7(77.48,116.33) v7(77.48,115.69) v7(78.47,115.69) v7(78.47,114.4) v7(78.71,116.01) v7(79.65,115.88) v7(79.67,114.52) v7(79.75,115.41) v7(79.96,115.88) v7(79.98,114.52) v7(80.05,115.41) v7(80.26,115.88) v7(80.36,115.41) v7(80.28,114.52) v7(80.57,115.88) v7(80.66,115.41) v7(80.59,114.52) v7(80.87,115.88) v7(80.97,115.41) v7(80.89,114.52) v7(82.05,114.54) v7(82.11,115.21) v7(82.36,114.54) v7(82.42,115.21) v7(82.66,114.54) v7(82.72,115.21) v7(82.97,114.54) v7(83.02,115.21) v7(83.27,114.54) v7(83.33,115.21) v8(73.72,120.13) v8(73.72,119.02) v8(73.72,117.9) v8(73.72,116.78) v8(73.73,115.66) v8(73.73,114.55) v8(74.72,120.13) v8(74.71,119.02) v8(74.72,117.9) v8(74.71,116.78) v8(74.72,115.66) v8(74.73,114.55) v9(74.31,119.25) v9(74.37,118.09) v9(74.4,116.89) v9(74.42,115.67) v9(74.47,114.57) v9(74.42,113.34) v9(75.29,119.26) v9(75.37,118.09) v9(75.37,116.88) v9(75.41,115.72) v9(75.41,113.36) v9(76.38,116.83) v9(76.48,114.57) v9(76.48,113.32) v9(98.77,120.76) v9(98.79,121.17) v9(99.08,121.3) v9(99.05,121.02) v9(99.03,120.76) v9(99.33,121.15) v9(99.29,120.77) v9(99.56,121.36) v9(99.53,120.93) v9(99.73,121.14) v9(99.77,120.78) v9(100.01,121.13) v9(100.06,120.79) v9(100.31,120.97) v9(100.58,121.11) v9(100.55,120.81) v9(100.67,123.69) v9(100.66,123.26) v9(100.64,122.83) v9(100.65,122.43) v9(100.86,123.89) v9(100.85,123.46) v9(100.84,123.04) v9(100.84,122.63) v9(100.85,121.21) v9(100.82,120.93) v9(101.07,123.67) v9(101.04,123.24) v9(101.04,122.84) v9(101.05,122.41) v9(101.09,121.07) v9(101.08,120.79) v9(101.25,123.89) v9(101.24,123.43) v9(101.24,123.03) v9(101.23,122.62) v9(101.37,121.26) v9(101.35,120.95) v9(101.44,120.56) v9(101.57,120.79) v9(101.59,121.06) v9(101.71,120.57) v9(101.79,121.26) v9(101.86,120.8) v9(101.98,121.05) v10(74.48,119.02) v10(74.47,116.78) v10(74.48,115.66) v10(76.49,117.62) v10(76.49,116.97) v10(76.74,116.01) v10(76.74,115.36) v10(76.74,114.72) v10(76.74,114.08) v10(76.99,116.33) v10(76.99,115.69) v10(76.99,114.4) v10(77.48,114.4) v10(77.73,116.01) v10(77.73,115.36) v10(77.73,114.72) v10(77.73,114.08) v10(77.97,116.33) v10(77.97,115.69) v10(77.97,114.4) v10(78.71,115.36) v10(78.71,114.72) v10(78.71,114.08) v10(78.96,116.33) v10(78.96,115.69) v10(78.96,114.4) v12(73.46,119.02) v12(73.48,117.9) v12(73.48,116.78) v12(73.48,115.66) v12(75.96,120.13) v13(83.91,114.48) v13(84.18,115.02) v13(84.58,115.46) v13(84.66,114.67) v13(85.08,115.94) v13(85.08,115.09) v13(85.5,115.51) v13(85.92,115.93) v13(92.25,116.91) v13(92.53,116.35) v13(92.86,116.91) v13(93.17,116.35) v13(93.45,116.91) v13(93.78,118.29) v13(93.78,116.35) v13(94.08,116.93) v13(94.36,118.28) v13(94.36,116.35) v13(94.44,117.69) v15(99.16,121.41) v15(99.24,121.07) v15(99.52,121.43) v15(99.64,121.1) v15(100,121.07) v15(100.52,121.05) v15(100.71,124.22) v15(100.72,123.94) v15(100.69,123.67) v15(100.69,123.4) v15(100.69,123.14) v15(100.7,122.86) v15(100.7,122.59) v15(100.71,122.32) v15(100.74,122.06) v15(100.78,121.2) v15(100.94,124.07) v15(100.94,123.79) v15(100.94,123.52) v15(100.96,123.25) v15(100.96,122.99) v15(100.97,122.72) v15(100.98,122.44) v15(100.98,121.85) v15(100.99,122.17) v15(101,121.02) v15(101.22,124.2) v15(101.22,123.92) v15(101.23,123.64) v15(101.23,123.37) v15(101.22,123.1) v15(101.22,122.84) v15(101.23,122.57) v15(101.24,122.29) v15(101.24,122.02) v15(101.23,121.2) v15(101.5,121.04) v15(101.68,123.81) v15(101.66,123.53) v15(101.65,123.2) v15(101.65,122.88) v15(101.64,122.56) v15(101.64,122.29) v15(101.65,122.01) v15(101.66,121.33) v15(101.8,121.05) v15(101.98,121.27) v16(94.59,121.29) v21(74.21,117.07) v21(74.29,115.9) v21(74.34,114.35) v21(74.54,119.14) v21(74.5,117.86) v21(75.34,114.37) v21(75.3,113.6) v21(76.33,113.54) v22(73.71,113.43) v22(74.7,113.43)
+VCC_SA: length 42.1
  TOP w0.254: PL1102.2 103.62,107.18 102.44,108.36 v13(102.44,108.68)
  IN4 w0.254: v13(102.44,108.68) 102.44,108.52 102.84,108.12 106.22,108.12 106.6,107.74 111.9,107.74 115.26,111.09 115.26,112.29 116.07,113.1 116.44,113.1 116.44,113.1 116.49,113.1 118.36,114.97 118.36,118.97 v4(117.96,119.37)
  BOTTOM w0.203: v4(68.95,111.92) v5(69.28,112.17) v10(68.95,112.42) v10(68.53,112.87)
  BOTTOM w0.254: PC1112.2 117.09,119.34 PC1115.2 ; PR1124.2 117.07,118.53 PC1115.2 ; PC1115.2 117.04,119.4 PC1113.2 PR1119.2
  BOTTOM w0.356: v5(69.03,114.55) v5(68.53,114.55) ; v5(68.53,114.55) v5(68.53,115.1) v4(68.53,115.66) ; v5(68.53,114.55) v10(68.53,113.99) v5(68.53,113.43) ; v5(68.53,116.78) v5(68.53,117.34) v5(68.53,117.9) ; v5(68.53,116.78) v10(68.53,116.22) v4(68.53,115.66) ; v5(68.53,116.78) v5(69.03,116.78) ; v5(68.53,119.02) v10(68.53,118.48) UC1.AL29 v5(68.53,117.9) ; v5(68.53,119.02) v5(69.03,119.02) ; v5(68.53,119.02) UC1.AR29 ; v4(68.53,115.66) UC1.AC30 ; v10(68.53,112.87) v5(68.53,113.43) ; v5(68.53,113.43) v5(69.03,113.43) ; v5(68.53,117.9) v5(69.03,117.9)
  vias: v1(68.59,115.08) v1(68.59,113.96) v1(68.59,112.82) v2(68.53,119.01) v2(68.53,117.89) v2(68.53,116.68) v2(68.53,115.64) v2(68.53,114.52) v2(68.53,113.4) v2(69.27,112.42) v5(68.53,119.6) v5(69.03,115.66) v8(68.53,119.34) v8(68.53,118.23) v8(68.53,117.08) v8(68.53,115.98) v8(68.53,114.85) v8(68.53,113.74) v13(99.44,108.94) v13(99.73,108.39) v13(100.04,108.92) v13(100.37,108.38) v13(100.68,108.93) v13(100.96,108.39) v13(101.27,108.94) v13(101.59,108.38) v13(101.85,108.94) v16(74.51,107.62) v18(68.59,115.64) v18(68.59,114.52) v18(68.61,110.53) v18(68.61,110.28) v18(68.61,110.02) v18(68.61,109.31) v18(68.61,109.06) v18(68.61,108.8) v18(69.19,111.2) v18(69.25,110.79) v18(69.25,110.49) v18(69.25,110.18) v18(69.93,108.22) v18(69.93,107.71) v18(69.93,107.2) v18(69.93,106.7) v18(69.93,106.19) v18(69.93,105.68) v18(70.43,108.22) v18(70.43,107.71) v18(70.43,107.2) v18(70.43,106.7) v18(70.43,106.19) v18(70.43,105.68) v18(71.81,105.73) v18(71.81,105.35) v18(71.81,104.97) v18(72.19,105.73) v18(72.19,105.35) v18(72.19,104.97) v18(72.57,106.11) v18(72.57,105.73) v18(72.57,105.35) v18(72.57,104.97) v21(68.45,116.3) v21(68.45,115.97) v21(68.45,115.3) v21(68.45,114.85) v21(68.48,114.19) v21(68.46,113.73) v21(68.51,113.06) v21(68.93,112.41)
