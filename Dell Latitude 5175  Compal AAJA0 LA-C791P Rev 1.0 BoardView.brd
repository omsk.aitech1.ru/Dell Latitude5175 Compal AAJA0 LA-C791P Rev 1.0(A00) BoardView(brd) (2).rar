# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1.2V_DDR_OT: length 2.6
  BOTTOM w0.254: PR701.2 127.94,121.94 127.69,121.68 127.69,120.59 127.46,120.36 PU700.11
1.2V_DDR_PG: length 4.3
  TOP w0.254: PR712.1 v1(124.07,118.79)
  IN1 w0.254: v2(124.46,118.81) 124.43,118.79 v1(124.07,118.79)
  IN3 w0.254: v7(127,119.86) 126.4,119.86 125.32,118.79 124.49,118.79 v2(124.46,118.81)
1.8V_PRIM_PG: length 2.8
  TOP w0.254: PU1000.2 33,112.61 32.59,113.02 31.82,113.02 R143.2 31.74,114 PR1001.2
3.3V_NGFF1_EN: length 18.7
  TOP w0.119: D6.3 v1(201.86,127.51)
  IN1 w0.084: v2(200.28,127.57) 201.8,127.57 v1(201.86,127.51)
  IN3 w0.084: v10(193.32,134.74) 193.32,135.22 193.6,135.5 193.92,135.5 194.03,135.6 194.36,135.6 194.55,135.41 194.9,135.41 194.99,135.5 195.16,135.5 195.49,135.83 196.27,135.83 197.07,136.63 198.51,136.63 198.88,136.26 198.88,133.78 199.66,133 199.66,130.96 199.66,130.79 200.32,130.13 200.32,127.62 v2(200.28,127.57)
3V_EN: length 3.5
  GND3 w0.254: v15(193.6,112.11) 193.5,112.11 v15(192.66,111.26)
  BOTTOM w0.254: v15(192.66,111.26) 192.54,111.26 191.68,112.12 PU600.11
3V_PRIM_PG: length 3.5
  BOTTOM w0.254: R364.2 PR905.1 27.45,129.61 27.81,129.24 27.81,128.54 PU900.3
3VALW_PG: length 72.7
  TOP w0.119: D3.1 197.65,134.98 v1(197.41,134.74)
  IN1 w0.084: v1(197.41,134.74) 197.56,134.89 v2(197.74,134.89)
  IN2 w0.079: v2(210.62,135.96) 210.49,135.96 210.42,136.03 210.41,136.03 210.08,136.36 200.69,136.36 199.16,134.83 197.8,134.83 v2(197.74,134.89)
  IN3 w0.084: v7(210.57,116.45) 210.35,116.66 210.35,123.23 210.57,123.44 210.57,124.15 210.43,124.28 210.43,125.81 210.87,126.25 210.87,127.53 210.9,127.56 210.9,135.6 210.62,135.88 v2(210.62,135.96)
  IN4 w0.089: v4(194.46,116.07) 194.46,115.46 189.41,110.4 186.75,110.4 186.4,110.76 v4(186.4,111.57)
  BOTTOM w0.119: v7(210.57,116.45) 208.01,116.45 208,116.44 PR130.1 207.99,116.31 207.61,115.93 206.78,115.93 206.31,115.46 PQ112.2 206.32,115.3 206.32,114.29 203.06,111.03 202.07,111.03 201.68,110.64 198.88,110.64 198.07,111.45 198.07,112.56 197.81,112.82 197.28,112.82 197.1,112.99 197.1,115.7 195.9,116.91 194.61,116.91 194.46,116.76 v4(194.46,116.07)
  BOTTOM w0.254: v4(186.4,111.57) 186.45,111.62 PU600.3
3VP_EN: length 4.4
  BOTTOM w0.254: PR906.1 28.11,122.24 PC912.1 28.86,122.45 PR915.2 28.3,123.67 PU900.11
3VP_VIN:
  vias: v13(26.26,125.82) v13(26.24,125.24)
5V_EN: length 3.6
  BOTTOM w0.254: PU601.11 27.42,115.35 27.32,115.24 PR612.1 27.79,114.77 28.56,114.77 29.08,114.25 PR607.2
5VALW_PG: length 2.9
  BOTTOM w0.254: R388.2 25.74,121.91 PR618.1 25.74,120.95 26.39,120.31 26.77,120.31 26.92,120.16 PU601.3
+0.6VSP: length 1.1
  TOP w0.119: v16(122.36,120.23) 122.66,120.23 v9(122.96,120.54)
  GND1 w0.084: v2(122.71,120.28) v9(122.96,120.54)
  vias: v7(122.69,120.91) v7(122.69,120.62) v7(122.69,118.37) v7(122.69,118.12)
+0.85VS_VCCIO: length 125.1
  TOP w0.508: v1(88.41,108.23) 88.63,108.02 94.16,108.02 96.9,110.76 97.22,110.76 v1(97.23,110.75)
  IN1 w0.508: 77.03,120.63 77.03,120.64 78.43,120.64 79.87,119.2 92.58,119.2 93.26,119.88 95.19,119.88 95.38,119.69 95.38,116.04 v2(94.51,115.18) ; v2(75.36,105.98) 75.73,106.35 79.27,106.35 79.59,106.67 81.33,106.67 82.88,108.22 86.04,108.22 86.55,108.73 88.16,108.73 88.41,108.48 v1(88.41,108.23) ; v1(97.23,110.75) 97.48,110.5 v2(97.48,110.46)
  IN2 w0.508: v2(97.48,110.46) 94.51,113.43 v2(94.51,115.18)
  IN3 w0.508: v2(45.24,132.31) 45.02,132.53 v3(43.97,132.53)
  GND3 w0.254: v2(75.4,120.79) v10(75.07,120.79) ; v10(72.5,120.79) v2(72.81,120.79) v10(73.14,120.79) ; v10(69.92,120.79) v2(70.24,120.79) v10(70.56,120.79) ; v10(71.21,120.79) v2(71.53,120.79) v10(71.85,120.79) ; v10(74.43,120.79) v2(74.11,120.79) v10(73.78,120.79) ; v10(69.28,120.79) v2(68.96,120.79) v10(68.63,120.79)
  IN4 w0.508: v13(37.63,111.31) 37.63,111.35 34.57,114.42 29.17,114.42 28.82,114.77 26.62,114.77 26.6,114.76 26.2,114.76 25.92,115.04 25.92,115.24 25.29,115.88 24.53,115.88 23.6,116.81 23.6,120.11 23.01,120.69 23.01,123.18 23.28,123.45 23.79,123.45 24.07,123.73 24.07,124.36 24.29,124.59 24.29,129.01 26.52,131.24 27.04,131.24 30.82,135.01 43.13,135.01 43.97,134.17 v3(43.97,132.53)
  BOTTOM w0.127: v16(37.63,112.17) v13(37.63,111.31)
  BOTTOM w0.203: UC1.AV26 67.54,120.42 v5(67.54,120.13) v10(67.54,119.58)
  BOTTOM w0.356: v4(67.05,116.22) v10(67.05,115.66) v10(66.55,115.66) v4(66.55,116.22) v4(67.05,116.22) ; v4(67.05,116.22) v10(67.05,116.78) ; v10(67.54,119.58) v5(67.54,119.02) v10(67.54,118.46) v5(67.54,117.9) v10(67.54,117.34) v4(67.54,116.78) v4(67.54,116.22)
  BOTTOM w0.508: R406.1 35.61,110.29 36.63,111.31 v13(37.63,111.31)
  vias: v1(45.05,131.94) v1(69.21,121.03) v1(70.37,121.1) v2(66.55,116.24) v2(67.05,116.24) v2(67.54,118.98) v2(67.54,117.87) v2(67.54,116.7) v2(67.66,120.01) v2(76.96,129.4) v4(68.31,120.55) v4(68.95,120.55) v4(69.6,120.55) v4(70.24,120.55) v4(70.89,120.55) v4(71.53,120.55) v4(72.17,120.55) v4(72.82,120.55) v4(74.75,120.55) v5(67.99,120.79) v5(73.46,120.55) v5(74.11,120.55) v5(75.4,120.55) v7(75.03,106.24) v7(75.03,105.98) v8(66.55,115.9) v8(67.05,115.9) v8(67.54,119.32) v8(67.54,118.21) v8(67.54,117.09) v8(67.67,120.36) v9(72.67,121.11) v9(72.71,120.48) v9(73.2,121.07) v9(73.28,120.52) v9(73.86,120.57) v9(74.45,120.53) v9(75.03,120.59) v9(76.15,120.53) v15(76.76,129.07) v15(76.76,128.82) v15(77.01,129) v18(44.5,130.09) v18(44.48,129.83) v18(44.49,129.56) v18(44.5,129.25) v18(44.72,130.22) v18(44.73,129.94) v18(44.73,129.66) v18(44.73,129.38) v18(44.73,129.11) v18(56.64,129.43) v18(68.58,121.08) v18(68.59,119.93) v18(68.59,119.34) v18(68.59,118.79) v18(68.59,118.2) v18(68.59,117.62) v18(68.59,117.06) v19(77.14,129.1) v19(77.24,129.61) v19(77.31,129.33)
+0.85VS_VCCIOP: length 17.4
  TOP w0.254: v1(41.25,136.44) 41.53,136.16 PR808.1
  TOP w0.508: PL802.2 38.7,130.62 35.28,130.62 34.59,131.31 34.59,134.64 35.3,135.35 36.86,135.35 37.87,136.36 38.46,136.36
  IN1 w0.254: v1(41.25,136.44) v1(41.25,133.26)
+0.95V_PRIM: length 167.2
  TOP w1.118: 38.95,102.45 39.98,103.48 v16(39.98,104.36)
  TOP w1.27: 37.85,96.1 51.04,96.1 53.07,94.07 150.02,94.07 151.04,93.06 163.78,93.06 167.84,97.12 167.84,111.78 ; 47.24,117.62 46.68,117.06 46.68,110.6 42.98,106.9 41.2,106.9 39.98,105.68 v16(39.98,104.36)
  vias: v18(36.32,96.36) v18(36.32,96.1) v18(36.32,95.85) v18(36.52,95.7) v18(38.23,100.95) v18(38.53,100.95) v18(38.81,100.95) v18(39.09,100.95) v18(49.56,117.96) v18(49.55,117.69) v18(51.7,117.96) v18(51.69,117.69) v18(167.52,113.1) v18(167.59,112.82) v18(167.79,113.1) v18(167.86,112.82) v18(168.05,113.09) v18(168.12,112.79) v18(170.42,113.43) v18(170.42,113.13) v18(170.43,112.85) v18(170.69,113.43) v18(170.69,113.13) v18(170.72,112.83)
+0.95V_PRIMP: length 13.1
  TOP w0.254: PU901.1 175.34,106.06 v1(175.51,106.24)
  TOP w0.305: 171.81,108.09 171.78,108.12 171.73,108.07 171.12,108.07 170.03,106.98 170.03,105.32 170.2,105.15 170.21,105.15 PR917.2
  IN1 w0.305: v1(175.51,106.24) 177.74,108.46 177.74,111.92 177.04,112.62 v1(177.04,112.72)
+1.0V_APLL: length 4.1
  TOP w0.305: CC75.1 55.98,113.88 CC124.1 55.43,113.06 L11.2
  TOP w0.508: CC79.1 55.98,114.09 CC75.1
  BOTTOM w0.254: v10(65.56,115.11) v5(65.06,115.11)
  vias: v2(65.02,115.12) v3(65.33,115.23) v18(57.28,114.26) v18(57.28,114.01) v19(65.3,115.3) v19(65.32,114.98)
+1.0V_MPHYGT: length 7.4
  IN1 w0.711: v2(59.46,113.19) 60.74,114.47 62.33,114.47 62.64,114.16
  IN3 w0.254: v10(64.57,113.43) 64.33,113.43 v2(64.26,113.5) ; v2(59.46,113.19) 59.38,113.11 v7(58.95,113.11) v7(58.55,113.11)
  GND3 w0.254: v2(59.46,113.19) 59.38,113.11 v7(58.95,113.11) v7(58.55,113.11) ; v10(64.57,113.43) 64.33,113.43 v2(64.26,113.5)
  IN4 w0.254: v5(64.07,113.43) v10(64.57,113.43)
  BOTTOM w0.203: v10(64.57,113.43) v5(64.07,113.43)
  vias: v1(62.73,113.35)
+1.0V_MPHYPLL: length 15.6
  TOP w0.254: v18(63.47,113.91) CC76.1
  VCC w0.305: v18(55.32,106.11) 55.32,106.54 55.78,107 55.78,108.65 57.53,110.4 61.56,110.4 63.13,111.98 63.13,113.57 v18(63.47,113.91) 64.03,113.91 v21(64.29,114.16)
  IN1 w0.254: v21(64.29,114.16) 64.38,114.16 v2(64.62,113.92)
  vias: v5(64.57,113.99) v8(64.31,114.06) v12(64.07,113.99)
+1.0V_PRIM: length 133
  TOP w4.064: 83.08,96.89 151.12,96.89 152.19,95.82 162.23,95.82 165.02,98.62 165.02,121.14
  IN1 w0.508: v1(59.97,101.48) 57.53,103.93 57.53,104.49 57.15,104.87 56.84,104.87 55.61,106.1
  IN2 w0.508: v2(81.48,103.94) 81.48,103.88 81.47,103.86 81.47,103.74 75.42,97.69 75.49,97.62 75.49,97.22
  IN3 w0.254: v7(83.07,104.02) 82.99,103.94 v2(81.48,103.94)
  BOTTOM w0.127: 68.27,103.7 69.85,103.7 70.51,104.36 v16(70.51,105.83)
  BOTTOM w0.508: v7(83.07,104.02) 83.09,104.04 88.03,104.04 RC103.1
  vias: v1(54.97,108.3) v1(54.97,107.18) v1(55.22,108.3) v1(55.22,107.18) v1(72.57,96.89) v1(72.57,96.61) v1(73.23,96.87) v1(73.23,96.61) v1(74.02,96.87) v1(74.02,96.61) v1(74.78,96.87) v1(74.78,96.61) v1(76.3,96.92) v1(76.33,96.64) v1(76.56,96.92) v1(76.58,96.61) v2(72.9,96.69) v2(73.66,96.69) v2(74.42,96.69) v2(75.18,96.69) v2(75.64,96.71) v2(174.82,125.59) v2(175.23,125.59) v2(175.21,125.17) v2(175.66,125.59) v2(175.67,125.17) v2(176.1,125.59) v2(176.1,125.16) v2(176.53,125.57) v2(176.53,125.16) v3(72.58,96.81) v3(72.6,96.54) v3(72.82,96.36) v3(73.08,96.36) v3(73.3,96.79) v3(73.3,96.54) v3(73.33,96.26) v3(73.89,96.41) v3(74.09,96.84) v3(74.09,96.59) v3(74.85,96.79) v3(74.85,96.54) v4(63.75,102.94) v4(63.74,96.63) v4(64.01,102.94) v4(64.01,96.63) v4(64.03,96.08) v4(64.26,102.94) v4(64.3,96.63) v4(64.29,96.08) v4(65.61,102.53) v4(65.61,102.28) v4(66.37,96.08) v4(66.67,102.83) v4(66.67,102.58) v4(66.67,102.33) v4(66.62,96.08) v4(67.59,103.9) v4(67.59,103.65) v4(67.59,103.22) v4(72.16,99.1) v4(72.16,98.59) v4(72.16,98.08) v4(72.8,99.15) v4(72.8,98.64) v4(72.8,98.14) v4(73.56,99.15) v4(73.56,98.64) v4(73.56,98.14) v4(73.62,96.31) v7(174.47,126.23) v7(174.47,125.92) v7(174.4,125.64) v7(174.52,125.42) v7(174.75,126.23) v7(175.01,126.23) v7(175.29,126.23) v7(175.56,126.23) v7(175.84,126.23) v7(176.12,126.23) v7(176.4,126.23) v7(176.68,126.23) v7(176.99,126.23) v7(176.99,125.92) v7(176.99,125.42) v7(177.11,125.67) v7(177.24,125.92) v7(177.27,125.42) v7(177.29,126.25) v18(54.63,121.4) v18(54.63,121.14) v18(54.63,120.89) v18(59.22,121.16) v18(59.22,120.86) v18(59.22,120.55) v18(59.22,120.25) v18(163.58,124.6) v18(163.55,124.3) v18(163.6,125.21) v18(163.6,124.91) v18(163.86,125.08) v18(163.86,124.73) v18(163.86,124.42) v18(163.86,124.15) v18(164.16,125.24) v18(164.13,124.91) v18(164.11,124.55) v18(164.11,124.3) v18(164.08,123.97) v18(164.36,124.45) v18(164.34,124.17) v18(164.34,123.87) v18(164.41,125.06) v18(164.39,124.7) v21(173.96,125.3) v21(174.09,125.53) v21(174.19,125.81) v21(174.22,125.27) v21(174.35,125.53) v21(174.35,125.03) v21(174.45,125.81) v21(174.47,125.29) v21(174.6,125.06) v21(174.78,125.25) v21(174.9,125.02) v21(175.03,125.87) v21(175.44,125.87) v21(175.87,125.87) v21(176.33,125.85) v21(176.73,125.85) v21(176.86,125.29) v21(176.89,125.59)
+1.0V_PRIMP: length 8.4
  IN3 w0.305: v7(171.07,116.65) 171.18,116.65 172.16,117.63 172.16,118.52 173.18,119.54 173.18,122.73 v7(173.53,123.08)
  BOTTOM w0.508: v7(171.07,116.65) 171.04,116.63 PC816.1
+1.0V_VCCPLL: length 6.6
  IN1 w0.305: v2(68.04,112.82) 68.04,112.38 67.15,111.49 67.15,107.44 v2(67.36,107.23)
  BOTTOM w0.254: UC1.T27 v5(68.04,112.87)
  vias: v7(67.67,107.36) v7(67.64,107.05) v8(68.04,113.18) v12(68.04,113.43)
+1.0V_VCCST: length 158.8
  TOP w0.508: PC1111.1 116.85,120.36 v1(116.41,120.36) PR1108.1 PR1106.1 116.41,118.18 116.05,117.82 114.93,117.82 114.63,117.52 113.98,117.52 113.21,116.74 113.21,105.68 v1(113.14,105.61) ; 66.27,100.83 66.27,105.13
  IN1 w0.508: v2(116.08,121.17) 116.41,120.84 v1(116.41,120.36) ; 187.05,131.03 187.05,130.65 180.73,124.33 173.47,124.33 173.39,124.25 165.93,124.25 v2(165.29,124.89) ; v2(84.89,106.29) 84.98,106.2 87.88,106.2 87.96,106.27 89.6,106.27 90.22,106.9 95.3,106.9 97.26,104.94 102.39,104.94 104.18,103.15 105.06,103.15 105.39,102.82 110.97,102.82 113.14,104.99 v1(113.14,105.61) ; v2(127.1,119.43) 127.11,119.42 130.16,119.42 130.54,119.04 133.69,119.04 134.04,119.38 134.04,120.05 136.61,122.62 137.67,122.62 137.9,122.85 141.52,122.85 143.32,124.65 v2(145.34,124.65)
  IN2 w0.508: v2(127.1,119.43) 126.82,119.71 117.82,119.71 116.41,121.12 116.13,121.12 v2(116.08,121.17) ; v2(165.29,124.89) 165.03,125.15 157.81,125.15 157.44,124.78 145.39,124.78 145.34,124.73 v2(145.34,124.65) ; v2(84.89,106.29) 83.48,106.29 82.02,104.83 81.51,104.83 81.07,104.38 v2(80.46,104.38)
  IN3 w0.254: v2(189.61,137.54) 189.82,137.34 v7(189.82,137.24)
  IN3 w0.508: v3(80.01,98.09) 79.11,98.09 78.37,97.35 71.34,97.35 69.13,99.56 68.26,99.56
  IN4 w0.508: v3(80.01,98.09) 80.16,98.24 80.16,98.9 80.78,99.52 80.78,101.86 80.75,101.9 80.75,102.64 80.41,102.99 80.41,103.39
  BOTTOM w0.508: C323.1 67.18,100.68 R445.2
  vias: v1(66.27,100.24) v1(66.24,99.96) v1(66.32,110.2) v1(66.32,109.92) v1(66.28,106.64) v1(66.28,106.39) v1(187.18,131.44) v1(187.3,131.69) v1(189.56,137.07) v1(189.76,137.23) v2(66.09,111.7) v2(66.57,100.05) v2(66.78,106.54) v2(67.54,113.93) v3(67.54,114.29) v3(80.14,104.26) v4(80.17,103.93) v5(67.54,113.99) v7(66.88,100.19) v7(66.89,99.94) v7(67.07,106.33) v7(67.2,106.1) v7(80.14,104.51) v7(86.07,105.97) v12(67.54,114.55)
+1.0V_XDP: length 6.2
  BOTTOM w0.762: 88.92,104.52 88.66,104.77 83.51,104.77 RC77.1
+1.0VA_GATE:
  vias: v1(54.28,115.48) v1(54.28,115.15) v1(54.43,114.92) v1(57.05,102.17) v1(57.03,101.87) v1(57.05,101.56) v1(57.05,101.26) v1(57.05,100.95) v2(54.84,115.51) v2(55.21,115.79) v2(55.75,101.77) v2(56.16,101.77) v2(56.21,101.36) v2(56.57,101.77) v2(56.62,101.36) v3(57.56,100.52) v3(57.71,100.29) v3(57.89,100.8) v3(57.89,100.52) v3(58.09,100.32) v4(59.69,103.36) v4(59.69,103.1) v4(59.69,102.85) v4(59.95,103.1) v4(59.95,102.85) v15(55.37,115.28) v15(55.6,115.56) v15(55.63,115.2)
+1.0VS_VCCSTG: length 89.6
  TOP w0.508: PR1114.1 115.09,116.91 114.24,116.91 113.82,116.49 113.82,105.4 v9(113.28,104.87)
  GND1 w0.508: v11(112.06,104.79) 113.21,104.79 v9(113.28,104.87)
  IN1 w0.508: v2(78.92,104.37) 79.62,104.37 80.2,104.94 82.33,104.94 84.35,106.96 86.37,106.96 86.74,107.33 88.8,107.33 88.86,107.39 v2(89.62,107.39) 89.74,107.51 95.55,107.51 97.51,105.55 102.64,105.55 104.43,103.76 105.31,103.76 105.64,103.43 110.67,103.43 112.03,104.79 v11(112.06,104.79)
  IN2 w0.508: v2(78.21,101.53) 78.21,103.65 v2(78.92,104.37) ; v2(66.29,109.25) 66.83,109.79 66.83,111.84 v2(67.54,112.56)
  IN3 w0.254: v2(78.21,101.53) 80.03,101.53 v7(80.06,101.56)
  IN3 w0.381: v3(88.61,106.87) 89.13,106.87 89.62,107.37 v2(89.62,107.39)
  IN4 w0.508: 89.93,106.22 89.28,106.87 v3(88.61,106.87)
  BOTTOM w0.254: UC1.T26 UC1.R26
  BOTTOM w0.508: C321.1 73.76,101.26 R441.2 ; C321.1 74.28,101.93 74.45,101.77 RC123.1 76.1,101.56 RC120.1 RC119.1 v7(80.06,101.56) ; C321.1 72.29,101.93 71.63,102.59 71.63,105.41 71.09,105.95 71.09,107.64 71.36,107.9 71.36,108.62 71.01,108.97 70.23,108.97 70.21,108.94 69.34,108.94 69.32,108.96 68.93,108.96 68.91,108.94 68.14,108.94 68.07,108.88 66.49,108.88 ; v4(89.93,105.71) 90.58,105.07 RC95.1 RC94.1 92.4,104.61 92.66,104.36 RC98.1 RC97.1
  vias: v5(67.54,113.43) v7(66.12,108.96) v7(66.12,108.7) v8(67.54,113.12) v12(67.54,112.87)
+1.2V_DDR: length 203.6
  TOP w0.508: 79.65,123.18 79.65,123.81 78.92,124.55 74.09,124.55 L10.1 ; 41.34,70.92 40.21,69.79 v13(37.81,69.79) ; R76.1 84.67,128.32 84.73,128.39 ; R64.1 85.72,129.96 84.73,128.97 84.73,128.39 ; R119.1 91.44,122.95 89.81,121.33 88.04,121.33 ; 84.73,128.39 84.73,126.33 84.17,125.76 84.17,125.48 83.03,124.34
  IN1 w0.508: v2(94.14,119.27) 93.75,119.27 91.88,117.4 84.87,117.4 83.66,116.18 v1(79.76,116.18)
  IN2 w0.508: v2(41.01,87.72) 40.47,87.19 40.47,74.44 37.81,71.77 v13(37.81,69.79) ; v2(79.63,93.11) 80.92,94.4 v2(80.92,95.55) 80.92,97.02 85.31,101.41 86.91,101.41 87.55,102.05 94.53,102.05 95.21,101.36 95.92,101.36 96.95,100.33 v2(97.89,100.33)
  IN3 w0.254: v10(73.14,121.29) v2(73.71,121.29) v10(74.43,121.29) v2(75,121.29) 75.72,121.29 v7(75.72,121.29) ; v2(67.66,121.29) v2(68.57,121.29) v2(69.87,121.29) v2(71.15,121.29)
  IN3 w0.457: v2(97.89,100.33) 98.06,100.17 v7(98.48,100.17)
  IN3 w0.508: v3(120.48,115.42) 120.48,115.68 120.97,116.17 120.97,117.4 121.74,118.17 121.74,118.9 119.55,121.09 119.55,122.68 ; v3(80.35,95.56) 80.36,95.55 v2(80.92,95.55) ; v7(40.12,92.78) 40.13,92.76 40.13,90.13 40.49,89.78 40.49,88.24 v2(41.01,87.72)
  GND3 w0.127: v2(68.57,121.29) v12(69.28,121.29) v8(69.53,121.29) v2(69.87,121.29) v12(70.56,121.29) v8(70.82,121.29) v2(71.15,121.29) ; v10(73.14,121.29) v8(73.38,121.29) v2(73.71,121.29)
  GND3 w0.254: v15(86.93,121.15) 87.21,121.15 v2(87.26,121.19)
  IN4 w0.102: v7(75.72,121.29) 75.72,121.29 v5(75.07,121.29) v10(74.43,121.29) v5(73.78,121.29) v8(73.38,121.29) v10(73.14,121.29) v5(72.5,121.29) ; v5(71.21,121.29) v8(70.82,121.29) v12(70.56,121.29) v5(69.92,121.29) v8(69.53,121.29) v12(69.28,121.29) v5(68.63,121.29) v12(67.99,121.29) v12(67.34,121.29)
  IN4 w0.508: v3(120.48,115.42) 120.48,115.04 117.21,111.76 117.21,110.65 116.41,109.85 116.41,109.42 114.73,107.74 114.73,106.26 113.78,105.31 112.51,105.31 112.31,105.51 111.2,105.51 109.83,104.13 99.48,104.13 99.27,103.92 v4(99.27,103.17) ; 70.26,95.22 71.75,95.22 71.96,95.02 73.82,95.02 74.19,95.39 75.02,95.39 75.88,96.26 77.29,96.26 77.92,95.62 80.29,95.62 v3(80.35,95.56)
  BOTTOM w0.508: v7(98.48,100.17) 98.63,100.32 98.63,102.53 v4(99.27,103.17) ; 69.29,98.64 69.98,99.33 70.49,99.33 70.89,99.73 70.89,101.67 70.57,102 R437.1 ; v7(40.12,92.78) 42.51,92.78 42.8,93.07 79.25,93.07 79.31,93.13
  vias: v1(68.58,122.28) v1(69.14,122.28) v1(69.75,122.28) v1(70.33,122.27) v1(70.89,122.28) v1(71.48,122.28) v1(74.44,121.19) v2(64.15,141) v2(64.47,141.32) v2(64.81,141.66) v2(66.21,136.57) v2(66.62,136.57) v2(66.82,137.71) v2(67.03,136.57) v2(67.23,137.71) v2(67.43,136.57) v2(69.38,139.06) v2(69.8,139.07) v2(70.17,132.93) v2(71.46,128.95) v2(72.07,137.73) v2(72.52,137.73) v2(73,131.87) v2(73.27,132.24) v2(73.28,131.56) v2(81.69,123.87) v2(89.55,129.01) v2(89.58,128.37) v2(90.01,128.37) v2(93.77,124.05) v2(100.22,125.58) v2(100.62,125.58) v2(101.03,125.58) v2(119.23,124.96) v2(119.23,124.53) v2(119.23,124.09) v2(119.25,123.66) v2(119.61,124.78) v2(119.61,124.32) v2(119.61,123.89) v2(119.58,123.38) v4(69.74,95.59) v4(70.01,95.59) v7(80.09,93.16) v7(80.47,93.16) v9(82.19,123.99) v9(82.58,124.12) v9(87.53,121.45) v9(87.66,121.2) v9(99.43,126.15) v9(100,126.15) v9(101.31,126.16) v9(118.64,124.83) v9(118.64,124.53) v9(118.64,124.2) v9(118.67,123.84) v9(118.62,123.51) v9(118.62,123.21) v9(118.87,124.68) v9(118.87,124.37) v9(118.87,124.04) v9(118.87,123.64) v9(118.87,123.33) v9(118.87,123.05) v10(89.39,129.29) v10(90.39,129.29) v10(91.89,130.79) v11(64.09,140.61) v11(64.37,140.61) v11(64.47,140.88) v11(64.73,140.88) v11(64.8,141.26) v11(65.06,141.26) v11(65.14,141.65) v11(65.98,136.93) v11(66.23,137.62) v11(66.23,136.93) v11(66.48,137.62) v11(66.53,136.93) v11(66.78,136.93) v11(67.1,136.93) v11(67.35,136.93) v11(67.57,137.82) v11(67.67,136.91) v11(67.82,137.82) v11(67.92,136.91) v11(69.1,139.42) v11(69.36,139.42) v11(69.57,132.91) v11(69.61,139.42) v11(69.86,139.42) v11(69.82,132.91) v11(70.12,139.42) v11(70.51,132.93) v11(70.76,132.93) v11(71.68,128.69) v11(71.73,137.36) v11(71.85,128.51) v11(71.99,137.36) v11(72.24,137.36) v11(72.5,137.36) v11(72.65,132.24) v11(72.75,137.36) v11(72.9,132.24) v11(73.39,131.91) v11(73.59,132.35) v11(73.64,131.91) v11(73.63,131.6) v11(73.85,132.35) v11(73.88,131.6) v11(89.44,128.03) v11(89.71,128.03) v11(89.98,128.03) v11(90.31,128.54) v11(90.57,128.53) v11(93.43,124.18) v11(93.45,123.9) v11(94.08,123.92) v11(94.1,124.2) v12(91.39,131.79) v15(63.94,141.29) v15(63.9,140.72) v15(64.11,141.5) v15(64.14,140.61) v15(64.32,141.68) v15(64.39,140.75) v15(64.52,141.88) v15(64.56,140.94) v15(64.75,141.13) v15(64.93,141.33) v15(65.12,141.52) v15(65.32,136.69) v15(65.32,136.43) v15(65.58,136.69) v15(65.58,136.43) v15(65.83,136.69) v15(65.83,136.43) v15(66.04,136.91) v15(66.22,136.22) v15(66.29,136.91) v15(66.47,136.22) v15(66.55,136.91) v15(66.72,136.22) v15(66.78,137.28) v15(66.8,136.91) v15(67.06,136.91) v15(71.49,128.62) v15(71.49,128.36) v15(73.27,132.57) v15(73.5,132.47) v15(73.54,132.04) v15(73.54,131.79) v15(90.05,128.71)
+1.2V_DDRP: length 19.8
  IN3 w0.254: v13(119.65,126.24) 119.65,126.5 120.5,127.35 125.53,127.35 126.67,126.2 v7(126.67,125.43)
  IN4 w0.762: 122.01,123.23 122.05,123.19 122.05,119.85
  BOTTOM w0.254: PR704.1 129.17,120.23 PC720.1 129.53,121.06 129.67,121.2 129.67,122.98 128.87,123.78 128.56,123.78 128.35,123.99 128.35,124.42 127.34,125.43 v7(126.67,125.43)
  vias: v4(122.29,119.03) v4(122.76,119.03) v13(120.26,126.24) v13(120.87,126.24) v13(121.46,126.25) v13(122.06,126.13) v13(122.06,125.54) v13(122.06,124.93) v13(122.06,124.28) v16(122.35,123.79)
+1.2V_UF_DVDD: length 33
  TOP w0.127: v1(124.96,123.8) 123.32,123.8 123.02,123.51 123.02,122.75 v14(122.29,122.01)
  TOP w0.381: C57.1 118.91,130.53 v1(118.24,130.53) 117.96,130.25 C356.1
  IN1 w0.508: v2(114.88,133.16) 114.88,132.51 115.53,131.87 v2(115.53,131.42) 115.53,131.36 115.91,130.98 116.29,130.98 116.74,130.53 v1(118.24,130.53)
  IN2 w0.508: v2(125.45,124.04) 125.45,124.92 123.23,127.14 119.95,127.14 119.56,127.53 113.77,127.53 113.24,128.06 v2(112.5,128.06)
  IN3 w0.508: v2(112.5,128.06) 112.5,130.97 113.09,131.56 114.82,131.56
  GND3 w0.254: v7(113.36,134.3) 114.5,133.16 v2(114.88,133.16)
  vias: v1(124.96,124.12)
+1.2V_VCCPLL_OC: length 10.3
  TOP w0.508: 65.61,110.85 65.07,110.31 65.07,102.43 65.61,101.89 v1(65.61,101.89)
  IN3 w0.254: v2(68.04,116.82) 68.02,116.8 68.02,116.5 v3(68.04,116.48)
  BOTTOM w0.254: v15(68.04,116.22) v5(68.04,116.78)
  vias: v1(65.66,111.67) v1(65.66,111.39) v2(65.18,101.92) v7(68.45,101.92) v7(68.45,101.54)
+1.2V_WF_DVDD: length 25
  TOP w0.305: C62.1 C63.1
  TOP w0.508: C63.1 138.73,131 v13(138.96,131.23)
  IN4 w0.508: v13(138.96,131.23) 139.56,131.23 139.9,130.89 139.9,130.32 139.65,130.06 133.73,130.06 132.89,129.22 130.69,129.22 130.64,129.17 128.58,129.17 128.13,128.72 127.69,128.72 127.05,129.35 126.29,129.35 125.5,130.14 123.98,130.14 123.59,130.53 123.59,130.92
  BOTTOM w0.305: 140.26,132.88 140.3,132.92 140.3,134.3 JWFC.23
  BOTTOM w0.508: v13(138.96,131.23) 138.96,131.59 140.26,132.88
  vias: v1(122.97,131.35) v1(122.96,131.03) v2(123.41,131.04) v3(123.02,130.98)
+1.2VS: length 2.8
  TOP w0.254: U25.40 29.89,72.18 30.14,71.94 30.14,71.03 CX16.1 ; 25.78,71.52 25.91,71.64 25.91,71.82 26.29,72.21 U25.31
  vias: v1(25.65,71.27) v1(25.67,70.98) v1(26.72,78.93) v1(27.3,78.98) v1(29.2,78.35) v1(29.29,78.77) v1(30.68,71.26) v1(30.96,71.24) v2(26.72,78.58) v2(27.13,78.65) v2(28.85,78.5) v2(31.14,70.9) v3(26.68,79.09) v3(27,79.09) v3(27.33,79.07) v3(28.83,78.83) v3(29.08,78.81) v3(30.92,71.31) v3(30.89,70.51) v3(31.24,71.31) v3(31.24,70.5) v3(31.57,71.3) v3(31.57,70.5) v14(37.26,72.81)
+1.8V_MEM: length 103.2
  TOP w0.508: 89.26,127.04 89.26,128.4 90.51,129.66 92.35,129.66 ; 89.26,127.04 90.14,127.04 91.08,126.1 91.08,125.19 91.47,124.81 C108.1 ; 89.26,127.04 88.01,127.04 87.07,126.1 87.07,125.14 86.46,124.53 ; C107.1 93.51,124.82 93.9,125.21 93.9,125.86 94.08,126.04 98.13,126.04 98.67,125.5 v16(102.45,125.5) 103.36,125.5 103.43,125.57
  IN2 w0.381: v2(76.4,133.16) 71.4,133.16 70.58,132.35 v2(69.74,132.35) 65.45,132.35 v2(62.41,129.3)
  IN3 w0.254: v10(69.28,132.28) 69.67,132.28 v2(69.74,132.35) ; v10(85.39,124.29) 85.4,124.28 v2(85.4,123.94)
  IN3 w0.508: v2(76.4,133.16) 80.11,133.16 v7(81.05,134.1) 83.33,136.38 83.89,136.38 84.18,136.67 90.5,136.67 92.39,134.77 v10(92.39,131.29) 94.2,131.29 v2(95.02,130.47)
  GND3 w0.381: v2(62.41,129.3) 62.26,129.45 v15(62.08,129.45)
  IN4 w0.254: 61.9,139.66 61.93,139.64 61.93,139.64 62.14,139.43 62.14,139.43 v5(62.28,139.28)
  IN4 w0.305: v4(70.71,142.53) 64.01,142.53 63.38,143.17 v4(63.12,143.17) 61.9,141.95 61.9,139.66
  BOTTOM w0.203: U33.T1 U33.R1
  BOTTOM w0.254: U35.R1 U35.T1
  BOTTOM w0.305: U33.A15 U33.A16 70.68,139.28 70.68,142.5 v4(70.71,142.53)
  BOTTOM w0.381: v7(81.05,134.1) 81.05,133.44 81.34,133.16 C251.1 82.51,133.16 84.37,131.29 U35.T1 ; v15(62.08,129.45) 61.82,129.2 C270.1 62.38,128.79 62.79,129.2 62.79,131.77 U33.R1
  BOTTOM w0.508: 75.89,133.95 74.92,134.93 C243.1 74.43,135.63 72.57,135.63 71.3,136.9 71.3,138.66 70.68,139.28
  vias: v1(94.61,130.52) v1(94.61,130.24) v2(92.15,123.56) v9(85.98,124.12) v9(86,123.87) v9(92.05,123.89) v9(92.33,123.87) v10(91.89,123.79) v10(92.39,123.79) v15(76.28,133.52) v15(76.53,133.49)
+1.8V_PCH_GPP: length 5.7
  IN1 w0.508: 61.83,116.08 59.84,116.08 59.36,116.56 59.36,118.38 59.33,118.4
  IN3 w0.254: v2(63.78,116.12) 63.88,116.22 v10(64.07,116.22)
  GND3 w0.254: v2(63.78,116.12) 63.88,116.22 v10(64.07,116.22)
  BOTTOM w0.254: v10(64.07,116.22) UC1.AE15 v5(64.57,116.22)
  vias: v2(59.36,118.86) v7(59.69,118.96) v7(59.94,118.96) v11(62.23,116.5) v11(62.36,116.22)
+1.8V_PRIM: length 201
  TOP w0.254: v1(48.21,118.51) 47.62,118.51 47.4,118.73 47.4,120.46 47.09,120.77 44.61,120.77 ; RH10.2 122.11,129.47 121.49,130.09 119.48,130.09 v1(119.25,129.86)
  TOP w0.381: RH2.2 v1(117.65,132.08) ; v1(52.98,119.34) 53.11,119.22 RH36.2 ; R52.1 204.69,131.19 204.44,130.94 203.04,130.94 202.79,130.7 202.79,129.25 201.54,127.99 194.2,127.99 v1(193.34,127.14)
  TOP w0.762: 43.94,109.79 43.78,109.63 42.87,109.63 42.38,109.13 41.1,109.13 v16(39.81,107.84) 38.58,106.62 38.58,103.93 38.23,103.57
  TOP w1.778: 62.26,138.04 68.78,138.04 71.7,135.12 78.43,135.12 80.52,133.04 104.01,133.04
  IN1 w0.254: v1(52.98,119.34) 52.98,119.31 51.42,117.74 48.98,117.74 v1(48.21,118.51)
  IN1 w0.381: v1(193.34,127.14) v2(193.83,127.14)
  IN1 w0.508: v2(120.55,127.83) 120,127.83 119.25,128.58 v1(119.25,129.86) 119.25,130.41 117.65,132.01 v1(117.65,132.08) 117.65,132.65 116.41,133.9 112.08,133.9 v2(112.01,133.83) ; v1(124.04,130.25) 124.07,130.22 124.07,130.22 124.29,130 v2(124.29,129.99)
  IN2 w0.381: v2(193.83,127.14) 193.45,127.52 185.59,127.52 v2(185.14,127.07)
  IN3 w0.254: v3(45.44,114.32) 45.44,114.04 45.31,113.91 v2(45.31,113.91) ; v2(107.85,132.68) 107.9,132.73 107.9,133.01
  IN3 w0.508: v7(132.63,129.96) 132.63,130.04 133.95,131.36 138.07,131.36 139.04,132.32 141.28,132.32 141.8,131.8 143.5,131.8 146.21,129.09 146.21,128.74 146.66,128.29 150.06,128.29 151.19,127.16 151.92,127.16 156.95,132.19 165.28,132.19 167.2,130.28 173.1,130.28 175.31,128.07 184.14,128.07 v2(185.14,127.07) ; 123.84,127.96 120.68,127.96 v2(120.55,127.83) ; 123.84,127.96 127.15,127.96 ; 123.84,127.96 123.84,129.54 v2(124.29,129.99) 124.46,129.99 v7(124.81,129.64) ; v2(112.01,133.83) 108.12,133.83 108.05,133.9 107.9,133.75 107.9,133.01
  IN4 w0.508: 51.71,116.39 51.54,116.39 51.53,116.4 49.53,116.4 49.2,116.06 49.2,115.48 48.86,115.14 48.35,115.14 47.38,114.18 46.7,114.18 46.56,114.32 v3(45.44,114.32)
  BOTTOM w0.508: v7(124.81,129.64) 125.51,130.34 125.68,130.34 127.96,132.63 131.76,132.63 132.63,131.76 v7(132.63,129.96)
  vias: v1(45.34,113.55) v1(45.57,113.68) v1(106.15,132.96) v1(106.45,132.37) v1(106.4,129.48) v1(106.68,132.96) v1(106.96,132.37) v1(107.06,130.01) v1(107.16,132.96) v1(107.47,132.37) v1(107.64,132.96) v1(108.79,130.04) v1(109.55,129.45) v1(109.55,129.2) v2(106.48,132.7) v2(106.83,129.4) v2(106.9,132.7) v2(107.24,129.4) v2(107.41,132.7) v2(108.79,129.38) v2(109.22,129.38) v4(53.08,116.93) v4(53.31,116.83) v9(106.4,129.23) v9(106.4,128.97) v18(42.7,120.84) v18(42.7,120.54) v18(42.7,120.23) v18(42.7,119.93) v18(42.7,119.62) v18(42.89,121.14) v18(43.12,121.36) v18(61.44,137.86) v18(61.44,137.58) v18(61.44,137.3) v18(61.42,137.02) v18(61.42,136.77) v18(61.42,136.51)
+1.8V_PRIMP: length 11
  TOP w0.254: 42.47,114.17 42.47,114.86 41.77,115.56 v1(40.13,115.56)
  TOP w0.559: v1(33.5,115.22) 33.49,115.21 PR1004.1 PC1002.1
  IN1 w0.254: v1(33.5,115.22) 33.6,115.32 37.71,115.32 37.95,115.56 v1(40.13,115.56)
+1.8V_UF_VDD: length 30.3
  TOP w0.508: C357.1 130.09,123.34 C119.1 129.18,123.36 R117.2 129.01,123.18 127.63,123.18 127.57,123.24 127.56,123.24 127.55,123.26 127.2,123.26 127.19,123.24 127.17,123.24 127.05,123.13 126.39,123.13 124.5,121.24 120.84,121.24 v14(120.64,121.44) 120.55,121.53 v13(120.55,122.63)
  IN3 w0.508: 113.44,129.64 113.21,129.42 v3(113.21,128.73)
  GND3 w0.254: v2(114.4,130.85) 113.64,131.61 v15(112.95,131.61)
  IN4 w0.508: v3(113.21,128.73) 113.65,128.29 118.49,128.29 119.01,127.76 119.01,123.81 120.19,122.63 v13(120.55,122.63)
  BOTTOM w0.305: JUFC.3 113.96,133.41 112.95,132.4 v15(112.95,131.61)
  vias: v1(114.85,131.55)
+1.8V_WF_DOVDD: length 39.1
  TOP w0.381: 136.87,130.09 136.58,130.39 C45.1 C355.1 136.28,132.11 v13(136.3,132.12)
  TOP w0.508: v13(134.04,123.43) 134.42,123.05 138.89,123.05 v14(139.04,123.21) 139.32,123.48 139.32,126.79 138.53,127.57 138.53,128.44 136.87,130.09
  IN4 w0.508: 124.76,126.81 125.02,126.56 126.56,126.56 128.31,124.81 129.77,124.81 130.55,125.59 132.3,125.59 132.92,124.96 132.92,124.77 133.24,124.44 133.44,124.44 133.46,124.42 133.58,124.42 134.04,123.97 v13(134.04,123.43)
  BOTTOM w0.305: JWFC.24 140.6,130.33 140.24,129.97 133.75,129.97 133.5,130.22 133.5,131.1 134.2,131.8 135.98,131.8 v13(136.3,132.12)
  vias: v2(124.49,126.91) v8(124.31,127.29) v8(124.56,127.29) v9(124.29,127.55) v9(124.55,127.55)
+1.8VD_LDO_PD: length 11.1
  IN2 w0.508: v2(41.3,42.48) 41.3,35.75 40.41,34.86 v2(37.31,34.86)
  vias: v1(37.17,35.38) v1(37.4,35.2) v1(41.22,43.17) v1(41.38,42.94)
+1.8VS: length 261.8
  TOP w0.254: U4.5 44.9,133.99 45.29,134.38 v1(45.29,134.43) ; 47.43,133.29 45.61,133.29 v1(45.58,133.26)
  TOP w0.305: v1(207.92,136.85) v16(208.62,137.54) 208.62,142.63 R1.1
  TOP w0.508: 60.65,139.33 60.71,139.28 60.71,135.85 61.82,134.74 66.03,134.74 67.02,133.75 67.36,133.75 v1(67.72,134.1)
  IN1 w0.254: v1(45.29,134.43) 45.52,134.2 v2(45.52,134.03) 45.58,133.96 v1(45.58,133.26)
  IN1 w0.508: v1(67.72,134.1) 67.72,133.46 v2(67.64,133.39) ; 207.85,135.75 207.92,135.83 v1(207.92,136.85) 207.92,139.56 207.21,140.27 204.65,140.27 203.58,141.34 203.58,141.67 200.97,144.27 196.68,144.27 195.29,142.88 191.47,142.88 188.39,139.8 187.2,139.8 185.94,138.55 185.94,137.5 185.1,136.65 184.31,136.65 182.52,134.86 182.52,133.71 181.25,132.45 v2(181.25,131.64) ; 61.42,139.77 61.67,140.02 64.67,140.02 65.18,140.53 70.92,140.53 73.87,137.58 81.56,137.58 82.13,137.01 v2(83.49,137.01)
  IN2 w0.508: v2(60.4,140.21) 60.11,140.5 51.08,140.5 50.06,139.48 50.06,138.32 49.4,137.66 49.4,137.12 46.79,134.51 46,134.51 v2(45.52,134.03) ; 54.69,122.45 54.69,123.15 54.43,123.41 54.43,126.3 55.5,127.37 57.03,127.37 57.55,127.9 58.21,127.9 59.64,129.33 61.21,129.33 65.27,133.39 v2(67.64,133.39)
  IN3 w0.254: v7(54.54,122.1) 54.28,121.84 v2(54.28,121.81) 54.65,121.44 v7(54.76,121.44)
  IN3 w0.508: v2(181.25,131.64) 181.18,131.64 180.42,132.4 179.15,132.4 178.69,131.94 167.71,131.94 165.89,133.76 150.08,133.76 148.41,132.1 v3(147.85,132.1) ; v3(100.72,127.54) 98.77,127.54 98.35,127.96 98.35,131.4 97.33,132.42 97.33,135.59 95.01,137.91 83.95,137.91 83.49,137.45 v2(83.49,137.01)
  IN4 w0.508: v3(147.85,132.1) 147.83,132.07 147.61,132.07 147.21,131.66 145.77,131.66 145.49,131.39 145.49,129.86 145.26,129.63 144.46,129.63 143.69,128.86 143.69,127.8 143.03,127.14 132.58,127.14 132.33,127.4 131.4,127.4 131.38,127.38 129.81,127.38 129.3,126.86 128.14,126.86 126.52,128.49 123.88,128.49 122.16,130.21 122.16,132.16 121.26,133.06 116.95,133.06 116.71,133.3 115.9,133.3 115.46,132.86 112.16,132.86 111.58,133.44 106.08,133.44 105.69,133.05 105.69,133.05 102.82,130.19 101.73,130.19 100.72,129.19 v3(100.72,127.54) 100.72,127.15 101.57,126.3 105.51,126.3 106.73,127.52 106.73,129.61 107.24,130.11 109.39,130.11 110.47,129.03 110.47,127.44
  vias: v1(60.6,139.77) v1(60.73,140.02) v1(109.83,126.35) v1(110.17,125.88) v1(207.96,135.13) v2(110.37,126.2) v3(110.71,126.27) v3(111,126.27)
+1.8VS_AUDIO: length 74.9
  TOP w0.508: 31.97,84.72 30.1,84.72 29.82,84.44 29.82,84.27 ; 28.55,91.25 24.97,91.25 v16(19.84,96.38) 17.8,98.42 17.8,108.88 ; RA19.2 8.41,121.65 v13(8.23,121.47)
  IN1 w0.508: 28.93,90.73 28.26,90.06 28.26,86.36 28.99,85.63 29.81,85.63 30.18,85.25 30.18,84.65 29.79,84.27
  IN2 w0.508: v2(23.49,109.49) 25.91,109.49 29.62,113.2 32.97,113.2 35.92,110.25 v2(35.92,109.9)
  IN3 w0.508: v2(23.49,109.49) 18.35,109.49 ; 18.35,109.49 v13(18.26,109.4) ; 18.35,109.49 18.71,109.84 18.71,113.63 16.87,115.47 v13(16.87,115.99)
  IN4 w0.508: v13(8.23,121.47) 8.23,121.21 9.17,120.26 12.59,120.26 16.87,115.98 v13(16.87,115.99)
  vias: v1(29.02,91.24) v1(29.36,91.24) v1(29.69,83.45) v1(29.95,83.45) v1(36.69,109.57) v1(36.84,109.34) v1(36.95,109.57)
+1.8VSP_ON: length 3.2
  TOP w0.254: PU1000.7 36.14,112.61 36.37,112.84 36.37,113.89 PC1000.1 PR1000.1
+2.8V_UF_AVDD: length 32.7
  TOP w0.381: C51.1 114.12,130.91 v1(113.92,130.71)
  IN3 w0.508: v7(113.66,130.55) 113.36,130.85 v2(113.36,130.86) ; v2(142.07,132.76) 141.85,132.98 134.45,132.98 132.8,131.33 130.54,131.33 129.63,132.25 126.63,132.25 125.2,133.68 125.2,133.69 124.29,134.59 114.77,134.59 113.92,133.74 113.92,133.34 v2(113.79,133.21)
  vias: v1(142.13,131.59) v1(142.48,132.35) v1(142.9,132.37) v1(143.73,131.74) v1(143.87,132.2) v1(144.11,131.74)
+2.8V_VCM_OUT: length 44.6
  TOP w0.305: R40.1 119.44,132.34 v1(119.41,132.37) 119.35,132.32 C359.1 ; R42.1 149.15,132.48 148.81,132.82 v1(145.75,132.82) 145.63,132.69 C38.1
  TOP w0.381: C56.1 119.52,131.64 119.52,131.88 119.41,131.99 v1(119.41,132.37)
  IN1 w0.381: v2(124.05,133.96) 125.15,133.96 126.76,132.36 127.64,132.36 127.85,132.15 130.81,132.15 v2(130.86,132.1)
  IN1 w0.508: v1(145.75,132.82) 145.37,132.82 v2(145.25,132.69) ; v1(119.41,132.37) 119.41,132.6 118.24,133.77 v2(117.97,133.77)
  IN3 w0.508: v2(124.05,133.96) 119.27,133.96 119.07,133.77 v2(117.97,133.77) ; v7(144.68,131.8) 144.87,131.8 145.25,132.18 v2(145.25,132.69) 144.74,133.2 143.85,133.2 142.97,134.08 134.69,134.08 132.55,131.94 131.8,131.94
  BOTTOM w0.305: JWFC.26 141.2,130.55 141.2,130.8 140.81,131.19 140.81,131.79 141.07,132.04 141.68,132.04
  BOTTOM w0.508: 141.68,132.04 142.69,132.04 142.86,131.88 144.6,131.88 v7(144.68,131.8)
  vias: v1(131.15,132.36) v1(131.25,132.02)
+2.8V_WF_AVDD: length 26.2
  TOP w0.356: C44.1 138.15,131.57 C360.1 138.38,131.8 139.56,131.8 139.85,131.51 v13(140.26,131.51)
  TOP w0.381: C367.1 137.26,131.57 C44.1
  IN3 w0.508: v3(128.43,127.51) 128.38,127.51 127.52,126.65 127.52,125.53 126.95,124.96 v2(126.81,124.96)
  IN4 w0.508: v13(140.26,131.51) 140.33,131.51 141.25,130.59 141.25,129.76 139.91,128.42 131.02,128.42 130.97,128.37 128.95,128.37 128.63,128.04 128.63,127.76 128.43,127.57 v3(128.43,127.51)
  BOTTOM w0.305: JWFC.25 140.9,134.3 140.9,133.17
  BOTTOM w0.508: v13(140.26,131.51) 140.26,131.99 140.9,132.63 140.9,133.17
  vias: v1(126.59,124.5) v1(126.97,124.5)
+3.3V_BBAT_LDO: length 96.8
  TOP w0.508: v1(193.19,103.11) 192.33,103.98 v1(192.33,108.26) ; D9.2 171.43,115.84 170.57,116.71 v1(170.57,118)
  IN1 w0.508: v1(193.19,103.11) 192.91,103.11 192.27,102.48 190.92,102.48 190.4,103 180.13,103 178.18,101.04 166.7,101.04 165.88,101.87 143.43,101.87 141.78,100.22 v2(141.78,99.86) ; v1(170.57,118) v2(170.57,118.37) ; v1(192.33,108.26) v2(192.99,108.26)
  IN2 w0.508: v2(170.57,118.37) 170.57,115.99 172.87,113.68 177.22,113.68 178.05,114.51 186.5,114.51 190.8,110.2 190.8,109.29 191.83,108.26 v2(192.99,108.26)
  BOTTOM w0.508: 142.15,98.81 142.15,96.97 141.24,96.05
  vias: v7(141.69,99.32) v7(141.98,99.33)
+3.3V_LDO_PD: length 11.1
  IN1 w0.381: 36.17,52.61 34.51,50.94 34.51,50.78 34.06,50.33 34.06,48.68 33.74,48.36 33.74,47.28 34.06,46.97 34.06,46.11 33.45,45.5 33.45,45.01 v1(32.49,44.05) 32.47,44.03 v1(31.71,44.03)
  vias: v1(36.02,53.94) v1(36.27,53.94) v14(36.16,57.19) v18(37.39,44.54) v18(37.49,44.29) v18(39.49,45.19) v18(39.8,50.82) v18(42.72,51.02) v18(42.72,50.69) v18(42.72,50.33) v18(43.03,46.19) v18(43.92,56.02) v18(43.97,55.57) v21(38.43,51.83) v21(38.43,51.58)
+3.3V_PCH_GPP: length 14.6
  IN1 w0.508: v2(63.77,119.5) 62.5,118.24 62.5,118.07 62.32,117.89 62.32,117.2 62.51,117.01 62.53,117.01 62.84,116.7 62.84,115.92 62.36,115.43 59.03,115.43 v2(58.78,115.18) 58.69,115.26 58.69,116.41 58.67,116.42 58.67,116.63 v2(58.09,117.21) 58.09,118.46 58.32,118.69 58.32,119.7 58.45,119.83 v2(58.45,120.17)
  IN3 w0.254: v7(58.42,117.26) 58.14,117.26 v2(58.09,117.21)
  vias: v5(63.59,119.23) v7(57.69,120.19) v7(57.96,120.21) v7(58.52,114.95) v7(59.03,115.41) v8(63.79,118.98) v15(64.07,119.02)
+3.3V_SPI: length 102.6
  TOP w0.254: v1(46.28,108.65) 46.18,108.65 45.31,107.78 RH56.1
  IN1 w0.508: v2(34.86,107.39) 34.86,111.56 v2(36.09,112.79) ; v2(46.38,107.99) 46.38,108.55 v1(46.28,108.65) 46.28,109.35 45.14,110.5 45.14,111.04 46.28,112.18 46.28,112.84 46.85,113.41 47.41,113.41 47.75,113.76 ; 55.52,143.25 55.52,144.87 56.9,146.24 v13(57.12,146.24)
  IN3 w0.508: v3(35.36,106.82) 34.86,107.32 v2(34.86,107.39) ; v3(34.92,113.2) 35.69,113.2 v2(36.09,112.79)
  IN4 w0.508: 45.49,108.02 45.49,108 43.76,106.26 35.92,106.26 v3(35.36,106.82) ; v13(57.12,146.24) 56.11,147.26 48.03,147.26 47.83,147.06 46.36,147.06 45.89,147.53 41.35,147.53 22.82,129 22.82,127.21 22.02,126.42 22.02,120.26 22.6,119.68 22.6,116.07 24.86,113.81 34.32,113.81 v3(34.92,113.2)
  BOTTOM w0.508: 51.82,114.52 51.82,114.52 U39.8
  vias: v1(48.08,114.04) v1(48.67,114.04) v1(55.37,142.48) v1(55.37,142.2) v2(48.03,113.71) v3(46.28,108.4) v3(46.58,108.32) v3(48.21,113.99) v3(48.36,113.78) v4(51.31,115.89) v4(51.31,115.64)
+3.3V_TBAT_LDO: length 45
  IN1 w0.254: v1(174.37,115.84) 173.06,115.84 v2(172.34,115.13)
  IN2 w0.254: v2(179.79,124.89) 179.59,124.69 173.32,124.69 171.03,122.41 171.03,118.72 172.34,117.41 v2(172.34,115.13)
  IN3 w0.254: v2(179.79,124.89) 179.81,124.88 v7(179.81,124.38) ; v2(172.34,115.13) 171.45,115.13 170.76,114.44 170.76,113.65 167.24,110.13 166.46,110.13 162.16,105.83 159.35,105.83 159.04,106.14 153.88,106.14 v7(153.57,105.83)
  BOTTOM w0.254: PR109.2 153.11,106.54 153.57,106.09 v7(153.57,105.83)
+3.3V_VCCSPI: length 10
  VCC w0.508: 63.51,121.11 63.36,121.26 63.26,121.26 61.84,122.68 55.98,122.68 55.44,122.14 55.21,122.14
  IN3 w0.254: v7(64.07,120.13) 64.34,120.13 v2(64.41,120.06)
  BOTTOM w0.254: UC1.AV15 64.04,120.17 v7(64.07,120.13)
  vias: v2(54,122.32) v15(54.01,122.89) v15(54.23,122.62) v19(53.78,122.07) v19(54.33,122.32) v21(63.73,120.54) v21(63.88,120.77)
+3.3V_VOUT_PD: length 2.8
  TOP w0.254: U32.H2 36.19,42.02 35.94,41.77 v1(35.71,41.77)
  IN1 w0.508: 33.17,42.98 33.48,42.98 34.18,42.28 34.57,42.28 34.81,42.04
  vias: v1(32.72,42.89) v1(32.7,42.5)
+3.3VDX_SSD: length 28
  TOP w0.127: 40.89,101.13 40.79,101.13 40.41,101.51 40.41,102.89 41.48,103.96 v14(41.48,105.4)
  IN1 w0.508: 33.29,107.1 33.29,105.2 34.14,104.35 36.32,104.35 39.71,100.95 41.31,100.95
  IN4 w0.305: 25.58,97.86 25.58,95.39 24.24,94.06 24.24,92.61 v4(24.22,92.59)
  BOTTOM w0.305: v4(24.22,92.59) 21.91,92.59 21.56,92.93 20.45,92.93 19.95,92.43 U51.5
  vias: v1(33.96,108.93) v1(33.96,108.68) v1(33.96,108.42) v1(34.04,107.86) v1(34.21,108.93) v1(34.21,108.68) v1(34.21,108.42) v1(34.29,107.86) v1(40.94,100.5) v1(41.2,100.5) v1(41.48,100.5) v1(42.11,101.01) v1(42.11,100.75) v2(33.18,108.65) v2(33.2,108.22) v2(33.2,107.81) v2(33.6,108.63) v2(33.6,108.19) v2(33.6,107.79) v2(40.77,100.22) v2(40.74,99.81) v2(41.12,99.99) v4(24.69,108.79) v4(25.51,108.73) v4(25.64,108.96) v4(28.47,108.83) v7(25.65,99.13) v7(25.63,98.84) v7(25.63,98.57) v7(25.63,98.29) v7(25.91,99.13) v7(25.89,98.84) v7(25.88,98.57) v7(25.88,98.29) v7(33.38,109.36) v7(33.53,109.03) v7(33.69,109.4) v7(33.78,109.03) v7(33.95,109.32) v7(33.88,108.42) v7(33.93,108.14) v7(34.19,108.14) v7(38.78,97.22) v7(38.79,95.95) v7(39.04,95.95) v7(39.28,97.22) v7(39.29,95.95) v7(39.55,95.95) v7(39.78,97.22) v7(40.28,97.22)
+3V_1.8V_HDA: length 10.7
  IN2 w0.508: v2(66.67,120.7) 66.67,121.53 65.96,122.24 63.97,122.24 63.69,121.96 63.5,121.96 63.28,121.75 60.96,121.75 60.31,121.1 58.55,121.1 v2(58.19,121.46)
  BOTTOM w0.254: v12(66.55,120.13) 66.38,120.31 v4(66.38,120.55)
  vias: v1(57.67,121.42) v1(57.86,121.58) v8(66.57,120.37)
+3V_LDO: length 345.4
  TOP w0.381: PR301.1 150.83,120.19 150.12,120.19 149.85,119.92 v1(149.85,119.38)
  IN1 w0.508: 198.89,139.22 199.12,139.22 200.29,138.05 200.29,134.47 196.79,130.97 v2(196.79,129.99) ; v1(147.52,121.69) 147.97,121.69 149.75,119.91 v2(149.85,119.91) v1(149.85,119.38)
  IN2 w0.508: v2(117.13,93.14) 116.52,92.53 99.58,92.53 97.06,95.05 86.78,95.05 85.38,93.65 85.38,92 v2(85.36,91.98) ; v2(132.82,113.91) 135.69,113.91 136.96,112.64 136.96,111.11 137.59,110.48 138.3,110.48 141.18,107.6 145.82,107.6 v2(146.95,106.47) 147.41,106.01 151.79,106.01 152.17,106.39 159.49,106.39 159.87,106.01 165.81,106.01 v2(165.89,106.09)
  IN3 w0.508: v2(149.85,119.91) v3(149.85,119.09) ; 179.15,107.04 179.8,107.04 179.91,106.92 186.4,106.92 190.23,110.75 190.23,111.23 196.37,117.38 196.58,117.38 ; 179.15,107.04 173.95,107.04 v7(171.53,109.46) 169.27,109.46 v2(165.89,106.09) ; 179.15,107.04 179.15,108.24 177.13,110.26 170.84,110.26 170.08,111.02 170.08,112.29 171.55,113.76 172.08,113.76 172.95,114.62 172.95,115.46 172.49,115.92 170.89,115.92 170.38,116.42 170.38,117.34 171.16,118.11 171.16,119.61 172.49,120.95 172.49,123.1 173.23,123.84 177.97,123.84 v7(178.51,124.38) ; v3(37.67,52.16) 37.67,52.14 42.01,47.8 v2(42.01,44.74)
  IN4 w0.508: v7(40.69,69.81) 40.13,69.81 37.67,67.35 v3(37.67,52.16) 37.67,37.29 33.68,33.3 33.68,32.2 35,30.88 36.59,30.88 37.25,30.22 37.25,26.65 36.6,26 31.04,26 29.29,24.25 ; v3(147.42,106.45) 147.42,107.42 147.76,107.76 147.76,109.9 149.58,111.71 149.58,115.69 149.86,115.97 149.86,119.08 v3(149.85,119.09) ; 133.65,102.23 133.36,101.95 131.1,101.95 130.74,102.3 ; 133.91,104.49 133.91,102.78 133.83,102.71
  BOTTOM w0.381: PR131.1 196.04,120.06 197.27,118.82 197.27,118.65 198.38,117.54 PQ108.3
  BOTTOM w0.508: v7(40.69,69.81) 43.99,73.12 43.99,88.85 45.45,90.31 84.38,90.31 85.2,91.14 ; 133.1,105.63 132.64,106.09 132.64,112.54 ; RTCD1.2 28.72,19.03 29,19.31 29,23.59 ; 117.96,93.6 118.38,94.02 118.38,97.96 120.5,100.08 128.05,100.08 129.71,101.74
  vias: v1(41.91,44.03) v1(42.11,44.26) v1(147.29,106.34) v1(194.97,139.03) v1(195.2,138.85) v4(28.93,24.35) v4(28.93,24.09) v4(130.1,102.26) v4(130.38,102.25) v4(133.6,104.94) v4(133.88,104.94) v4(134.71,102.47) v4(134.71,102.16) v7(85.27,91.53) v7(85.6,91.53) v7(117.56,93.2) v7(117.89,93.2) v7(132.74,113.2) v7(132.74,112.94) v7(196.65,130.31) v7(196.9,130.32) v7(197.15,117.52) v7(197.14,117.25) v7(197.15,116.99) v7(197.37,117.37) v7(197.38,117.11) v7(197.38,117.64) v14(196.9,138.97)
+3V_LDOP: length 2.7
  BOTTOM w0.119: v16(205.09,116.96) 204.24,116.96 203.25,115.97 PQ107.1
+3V_PRIM: length 222.2
  TOP w0.254: PR800.1 34.59,130.39 34.9,130.09 v18(36.83,130.09) ; R186.1 69.2,100.56 69.65,100.12 74.14,100.12 ; U24.5 74.68,102.34 74.34,102 74.34,100.32 74.14,100.12 ; 74.14,100.12 79.35,100.12 79.62,100.39 U23.5
  TOP w0.305: 30.58,109.67 30.61,109.69 30.61,110.99 30.35,111.24 R145.1
  TOP w0.381: v1(75.74,104.05) 75.78,104.02 75.78,103.22 75.44,102.87 75.44,102.48 U24.5
  TOP w0.457: 60.27,140.78 59.32,139.82 59.32,134.54 59.31,134.53
  TOP w0.508: R73.1 33.53,128.64 v14(33.93,129.05) PR800.1 ; 59.34,133.2 59.34,131.5 61.37,129.48 66.45,129.48 ; UH2.5 70.93,103.61 71.51,104.19 72.97,104.19 73.23,104.45 75.35,104.45 v1(75.74,104.05) ; RC11.1 47.14,123.87 RC12.1
  TOP w2.286: 73.55,137.45 79.78,137.45 81.23,136.01
  TOP w2.54: 63.12,141.75 63.14,141.72 69.28,141.72 73.55,137.45 ; 81.23,136.01 119.81,136.01
  IN1 w0.254: v1(38.84,142.31) 38.89,142.36 v1(43.71,142.36)
  IN1 w0.305: v2(56.3,107) 56.26,106.96 v21(56.26,106.6) ; v21(59.61,105.08) v2(59.61,104.71)
  IN1 w0.508: v1(75.74,104.05) 75.74,104.38 v2(76.4,105.04) ; v1(30.81,114.01) 35.38,114.01 36.12,114.75 v21(36.93,114.75) ; 43.33,106.77 43.33,105.04 45.36,103.01 45.36,99.94 45.86,99.44 46.02,99.44 ; 50.44,128.56 50.51,128.5 50.51,127.43 v2(50.52,127.42) 50.11,127.02 49.25,127.02 48.52,126.29 48.52,125.15 ; v2(56.29,120.19) 56.08,119.98 56.08,118.89 56.36,118.61 56.36,117.97 56.27,117.88 56.27,117.3 ; v1(67.14,129.48) v1(70.14,129.48) ; 69.77,102.22 69.18,102.81 66.9,102.81 66.85,102.86 65.65,102.86 65.3,103.2 65.3,103.37 v2(65.25,103.42)
  IN2 w0.508: v2(76.4,105.04) 76.45,104.99 80.81,104.99 81.31,105.49 81.81,105.49 83.28,106.95 87.22,106.95 v2(87.4,106.77)
  IN3 w0.254: v7(87.82,106.9) 87.69,106.77 v2(87.4,106.77) ; v7(59.21,105.1) 59.21,105.1 59.6,104.71 v2(59.61,104.71) ; v2(65.25,103.42) 65,103.42 v3(64.87,103.29)
  IN3 w0.305: v7(56.45,107.46) 56.39,107.4 56.39,107.22 56.3,107.13 v2(56.3,107) ; v2(52.69,107.14) v7(52.69,106.77)
  IN3 w0.381: v7(48.01,102.06) 48.47,102.52 48.81,102.52 49.21,102.92 v7(49.21,103.22)
  IN3 w0.508: 52.99,126.79 52.8,126.98 51.6,126.98 51.31,127.27 50.67,127.27 v2(50.52,127.42) ; v2(36.96,114.11) 30.61,114.11 27.05,117.67 22.81,117.67 21.11,119.37 v3(21.11,119.8)
  GND3 w0.508: v15(60.38,104.57) 59.75,104.57 v2(59.61,104.71)
  IN4 w0.254: v4(62.66,105.15) 62.66,104.16 63.22,103.6 64.57,103.6 v3(64.87,103.29)
  IN4 w0.381: v3(21.11,119.8) 19.53,121.38 v4(16.65,121.38)
  IN4 w0.508: v15(87.99,108.68) 88.04,108.68 88.13,108.77 93.96,108.77 v4(94.5,108.23) 94.3,108.02 94.3,103.63 v4(94.77,103.16)
  BOTTOM w0.203: 54.26,125.88 54.46,125.68 RH75.2
  BOTTOM w0.254: RH75.2 55.14,125.68 RH72.2 ; v7(52.69,106.77) 52.69,106.61 51.69,105.61 51.13,105.61 50.63,105.11 RH122.2 50.21,104.66 49.99,104.44 RH126.2 RH128.1 49.81,103.29 49.29,103.29 v7(49.21,103.22) RH127.2 RH123.2 RH117.2 ; RH109.2 62.61,105.2 v4(62.66,105.15)
  BOTTOM w0.381: v7(48.01,102.06) RC113.1 ; v13(39.22,111.22) RH105.1 ; RH72.2 RH76.2
  BOTTOM w0.406: v13(41.45,114.94) 41.49,114.9 42.85,114.9 43.27,114.48 U38.5
  BOTTOM w0.508: RH76.2 55.07,125.02 55.07,124.46 RC40.1
  vias: v1(46.87,100.14) v1(46.87,99.88) v1(48.29,123.74) v1(48.41,123.99) v1(50.44,128.95) v1(50.57,129.2) v1(56.81,134.69) v1(57.02,134.51) v1(59.54,134.08) v1(59.54,133.82) v1(70.32,102.18) v1(70.58,102.18) v2(48.52,123.41) v2(56.59,116.98) v4(42.42,130.18) v4(42.42,129.86) v4(42.42,129.58) v4(42.69,130.18) v4(42.7,129.86) v4(42.7,129.58) v4(42.96,130.18) v4(42.97,129.86) v4(42.96,129.58) v4(42.96,129.28) v4(42.96,128.97) v4(42.96,128.67) v4(42.96,128.36) v4(42.96,128.06) v4(43.23,130.18) v4(43.23,129.86) v4(43.23,129.58) v4(43.23,129.25) v4(43.23,128.95) v4(43.23,128.64) v4(43.23,128.34) v4(43.23,128.03) v7(53.44,126.61) v7(53.7,126.61) v9(146.96,123.9) v9(147.27,123.92) v13(36.8,129.33) v13(37.31,129.63) v13(37.29,128.95) v13(37.87,128.95) v13(37.9,129.63) v13(38.46,128.97) v13(38.48,129.61) v13(39.06,129.61) v13(39.04,128.97) v13(39.65,129.61) v13(39.62,129) v13(40.23,129.61) v15(48.54,123) v15(48.79,123.18) v15(55.72,120.27) v15(55.97,120.27) v15(56.18,117.43) v15(56.53,117.5) v18(33.27,102.81) v18(33.27,102.56) v18(33.27,102.3) v18(33.3,103.06) v18(33.48,109.25) v18(33.53,102.94) v18(33.53,102.68) v18(33.53,102.4) v18(33.71,109.41) v18(33.78,102.68) v18(43.14,135.36) v18(43.33,135.17) v18(46.43,136.41) v18(46.38,135.8) v18(46.58,136.18) v18(46.63,135.8) v18(46.71,136.41) v18(46.89,135.8) v18(54.56,142.51) v18(54.56,142.23) v18(56.11,110.84) v18(56.11,110.58) v18(57.96,145.2) v18(58.22,145.05) v18(60.43,142.1) v18(60.45,141.82) v18(60.45,141.52) v18(60.45,141.24) v18(60.68,142.23) v18(60.68,141.95) v18(60.68,141.67) v18(60.68,141.39) v18(122.02,137.07) v18(122.05,136.79) v18(122.3,137.1) v18(122.35,136.79) v18(122.61,137.1) v18(122.66,136.82) v18(122.94,137.1) v18(122.99,136.79) v18(123.24,137.1) v18(123.27,136.79) v18(123.57,136.77) v18(123.55,136.46) v18(151.51,131.43) v18(151.64,131.18) v18(151.79,131.43) v21(36.83,113.78) v21(37.08,113.78) v21(43.33,107.84) v21(43.33,107.58) v21(43.33,107.33) v21(52.58,107.46) v21(52.86,107.43) v21(56.76,115.04) v21(56.76,114.79) v21(56.76,114.53) v21(62.81,104.43) v21(63.08,104.38)
+3V_PRIMP: length 15.2
  IN3 w0.305: v7(41.35,128.84) 41.4,128.89 41.4,130.01 40.69,130.72 35.36,130.72 34.86,130.22 30.23,130.22 28.81,128.8 v7(28.8,128.44)
  vias: v13(39.9,124.37) v13(39.9,123.74)
+3V_SKYCAM: length 6.5
  TOP w0.076: U6.H5 v9(128.56,128.98) ; v1(128.16,126.58) v1(128.56,126.98)
  TOP w0.254: v1(128.56,126.98) U6.B5
  TOP w0.61: 138.81,122.32 136.3,122.32 135.46,121.48
  VCC w0.203: v18(128.88,129.97) 128.79,129.97 128.48,129.66 128.48,129.06 v9(128.56,128.98)
  vias: v1(127.94,124.7) v1(127.99,125.9) v1(128.24,125.9) v1(128.22,124.63) v1(128.31,130.85) v1(128.57,130.84) v1(130.2,122.54) v1(130.5,122.54) v1(130.78,122.57) v1(131.47,127.41) v1(131.8,127.42) v1(132.23,131.1) v1(132.49,131.36) v1(139.04,122.32) v1(139.32,122.32) v1(139.65,122.32) v1(144.87,122.37) v1(145.17,122.37) v1(145.5,122.35) v2(127.94,124.35) v2(129.5,122.68) v2(139.06,121.99) v2(139.5,121.99) v2(145.25,122.77) v2(145.71,122.77) v3(127.61,124.25) v3(127.81,124.02) v3(129.47,123.04) v3(129.72,123.01) v13(133.69,121.24) v13(134.06,121.69)
+3V_TPM_S0: length 58.9
  TOP w0.254: R73.2 R70.2 29.39,129.67 30.38,130.66 30.38,132.29 29.81,132.86 v1(24.61,132.86)
  IN1 w0.254: v1(57.19,142.36) 57.19,145.27 57.82,145.9 57.82,148.93 56.83,149.92 47.15,149.92 46.13,148.9 38.32,148.9 24.66,135.24 24.66,132.91 v1(24.61,132.86)
+3VALW: length 172.4
  TOP w0.254: v18(182.91,108.41) 182.91,110.08 PU151.8 ; PU150.8 v18(185.46,109.01)
  TOP w0.305: 67.87,128.67 68.14,128.94 JAPS2.16
  TOP w0.381: 121.09,118.77 121.09,120.21 118.81,122.49 118.26,122.49 117.83,122.93 117.83,123.87 117.37,124.32 PR1105.1 ; 121.09,118.77 121.12,118.8 PR722.2 ; 121.09,118.77 121.09,116.19 120.57,115.67 v18(119.29,115.67) ; PR135.1 24.99,30.27 25.37,30.65 26.43,30.65 29.51,33.73 PU100.8 31.12,33.73 PC117.1
  TOP w0.457: v13(29.11,84.25) 29.11,84.55 28.6,85.05 28.6,85.3 29.1,85.79 29.1,86.45 28.77,86.78 28.44,86.78 PR137.1
  TOP w0.508: 67.87,128.67 67.51,128.31 64.54,128.31 61.84,125.6 v18(61.84,125.02) ; v13(31.27,36.06) 31.05,35.84 31.05,34.46 31.29,34.22 PC117.1 ; v13(34.43,47.81) 35.01,47.81 R254.1
  VCC w0.508: v21(48.54,112.08) 49.73,113.27 49.73,114.39 49.07,115.05 49.07,115.69 49.42,116.03 49.42,116.87 48.79,117.49 48.79,118.65 48.53,118.91 48.53,120.7 49.66,121.83 49.66,124.2 52.53,127.07 54.59,127.07 55.07,127.55 55.89,127.55 56.51,126.93 56.51,126.5 57.3,125.72 61.14,125.72 v18(61.84,125.02)
  GND1 w0.381: v2(184.96,111.57) 184.93,111.6 v19(184.93,111.98)
  GND1 w0.508: v1(32.21,31.26) v2(32.56,31.61)
  IN1 w0.508: 24.54,60.62 24.6,60.62 25.01,60.21 27.74,60.21 28.35,60.81 31.16,60.81 v13(31.2,60.76) ; v21(48.54,112.08) 48.54,107.99 50.01,106.52 v21(50.01,106.34)
  IN2 w0.508: v13(34.43,47.81) 35.2,47.03 35.2,42.46 31.27,38.52 v13(31.27,36.06)
  IN3 w0.508: v2(32.56,31.61) 31.95,32.22 31.95,35.37 v13(31.27,36.06) ; v13(31.2,60.76) 31.2,60.05 31.12,59.96 31.12,56.79 32.69,55.22 33.24,55.22 34.48,53.98 34.48,47.86 v13(34.43,47.81) ; v7(185.48,111.57) v2(184.96,111.57)
  IN4 w1.016: 24.79,63.99 24.79,64.68 25.78,65.67 25.78,80.66 28.5,83.38 ; 29.97,84.26 32.92,87.21 32.92,98.44 38.56,104.08
  BOTTOM w0.254: U41.6 117.21,109.1 C298.1
  BOTTOM w0.762: 194.92,127.07 195.22,126.76 195.22,118.76 195.83,118.15 PQ108.1
  vias: v1(23.71,60.95) v1(24.43,61.92) v1(199.92,132.63) v1(199.92,132.31) v1(204.58,123.99) v1(204.58,123.73) v1(204.57,123.47) v1(204.62,127.73) v1(204.6,127.45) v1(204.62,126.99) v1(204.69,129.33) v1(204.69,122.98) v1(204.88,127.73) v1(204.88,127.45) v1(204.84,123.98) v1(204.83,123.72) v1(204.83,123.46) v1(205,129.33) v1(205.14,127.72) v1(205.14,127.46) v1(217.04,119.65) v1(217.31,119.59) v2(39.04,105.22) v2(39.85,105.22) v2(118.79,109.26) v2(170.21,114.24) v2(171.94,119.22) v2(175.46,112.82) v2(179.5,109.79) v2(180.11,109.79) v2(187.1,125.8) v2(187.3,126.15) v2(187.53,125.8) v2(187.71,126.18) v2(187.93,125.82) v2(188.14,126.2) v2(188.37,125.82) v2(188.54,126.2) v2(188.8,125.8) v2(188.98,126.2) v2(189.2,125.8) v2(189.38,126.25) v2(189.64,125.82) v2(189.79,126.2) v2(217.12,119.32) v3(38.71,105.12) v3(38.89,104.93) v3(39.57,105.4) v3(39.53,105.14) v7(170.08,113.91) v7(170.33,113.91) v7(171.81,119.55) v7(172.07,119.55) v7(175.34,113.18) v7(175.62,113.18) v7(179.56,109.44) v7(179.77,109.59) v7(180.06,109.46) v7(180.31,109.51) v7(186.52,127.2) v7(186.74,126.94) v7(186.72,126.69) v7(186.79,127.21) v7(187.02,126.96) v7(186.99,126.69) v7(187.15,127.24) v7(187.3,126.99) v7(187.3,126.69) v7(187.45,127.24) v7(187.71,127.24) v7(187.96,127.24) v7(188.24,127.24) v7(188.37,126.99) v7(188.37,126.71) v7(188.49,127.24) v7(188.77,127.24) v7(189.03,127.22) v7(189.28,127.22) v7(189.56,127.22) v7(189.56,126.94) v7(189.56,126.66) v7(189.81,127.22) v7(189.81,126.94) v7(216.76,119.56) v7(216.76,119.29) v13(24.54,62.52) v13(24.66,63.1) v13(197.21,99.02) v13(197.79,99) v14(198.04,107.74) v15(118.44,109.41) v15(118.44,109.11) v18(50.82,104.99) v18(50.82,104.73) v18(50.82,104.47) v18(51.15,104.99) v18(51.15,104.73) v18(51.32,104.41) v18(51.41,104.97) v18(51.41,104.71) v18(52.12,102.33) v18(52.43,101.39) v18(52.68,101.39) v18(170.54,106.59) v18(179.34,106.74) v18(180.29,113.68) v18(180.6,106.01) v18(180.6,105.71) v18(180.95,106.01) v18(180.92,105.71) v18(181.2,114.35) v18(181.3,106.01) v18(182.91,107.39) v18(183.97,107.43) v18(186.47,113.22) v18(186.66,114.29) v18(189.47,113.27) v18(189.5,114.33) v18(191.25,112.01) v18(191.35,118.67) v18(191.35,117.5) v18(192.4,114.06) v18(192.48,118.63) v18(192.48,117.48) v18(193.14,107.46) v18(193.14,107.19) v18(193.4,107.45) v18(193.39,107.18) v18(193.65,107.43) v18(193.65,107.17) v18(194.97,113.96) v19(118.34,109.54) v19(118.64,109.55) v21(38.91,105.53) v21(39.19,105.53) v21(39.73,105.53) v21(39.98,105.53) v21(170.03,114.52) v21(170.36,114.54) v21(171.81,118.89) v21(172.06,118.89) v21(175.26,113.1) v21(175.62,113.13) v21(179.2,109.67) v21(179.4,110.15) v21(179.67,110.14) v21(179.81,109.67) v21(179.93,110.15) v21(187.48,125.47) v21(187.5,125.19) v21(187.5,124.93) v21(187.5,124.65) v21(187.73,125.47) v21(187.76,125.19) v21(187.76,124.93) v21(187.76,124.65) v21(187.99,125.47) v21(188.01,125.19) v21(188.01,124.93) v21(188.01,124.65) v21(188.24,125.47) v21(188.26,125.19) v21(188.26,124.91) v21(188.26,124.63) v21(188.49,125.47) v21(188.52,125.19) v21(188.54,124.93) v21(188.52,124.65) v21(188.85,125.44) v21(188.8,125.19) v21(188.82,124.93) v21(188.82,124.65)
