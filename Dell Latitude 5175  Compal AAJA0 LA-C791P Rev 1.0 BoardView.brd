# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC_SA_DDR: length 104
  IN1 w0.254: v2(69.1,120.13) 68.95,120.13 v1(68.59,120.49)
  IN2 w0.305: v2(69.1,120.13) 68.77,120.13 68.36,120.54 67.65,120.54 67.18,121 67.18,123.05 68.44,124.31 v2(69.18,124.31)
  IN2 w0.508: 95.88,126.58 95.33,126.58 94.16,125.41 83.49,125.41 82.45,126.45 80.39,126.45 77.67,123.73 74.3,123.73 73.72,124.31 v2(69.18,124.31)
  IN3 w0.508: v3(96.89,126.71) 96.82,126.65 96.43,126.65 96.37,126.58 v2(96.37,126.55)
  IN4 w0.508: v3(98.25,102.1) 98.25,102.82 98.48,103.05 98.48,103.99 99.23,104.74 109.57,104.74 110.95,106.12 112.57,106.12 112.71,105.97 113.19,105.97 114.12,106.91 114.12,108.6 116.13,110.61 116.13,111.98 116.41,112.26 116.83,112.26 119.69,115.12 119.69,116.51 119.96,116.78 119.96,118.22 119.81,118.37 119.81,120.29 118.22,121.88 117.51,121.88 116.61,122.79 114.94,122.79 113.11,124.61 111.69,124.61 109.64,126.66 109.64,128.72 108.91,129.45 107.54,129.45 107.39,129.3 107.39,127.04 105.92,125.57 98.03,125.57 v3(96.89,126.71)
  BOTTOM w0.203: v12(68.53,120.13) v4(69.03,120.13)
  vias: v1(68.54,124.65) v1(68.8,124.65) v1(69.18,124.65) v1(96.49,102.5) v1(96.77,102.35) v2(97.94,102.28) v3(97.59,102.11) v8(68.77,120.13)
+VCCAPLLEBB_1P0: length 8.9
  TOP w0.254: v1(62.99,105.27) 62.55,105.72 62.55,111.19 62.72,111.36 v1(62.72,112.35)
  IN1 w0.305: v2(62.99,104.94) v1(62.99,105.27)
  IN3 w0.305: v2(62.99,104.94) v7(62.99,104.61)
  GND3 w0.254: v12(64.57,112.87) 64.35,112.87 v2(64.23,113)
  IN4 w0.254: v5(64.07,112.87) v12(64.57,112.87)
  vias: v1(62.73,112.79)
+VCCCLK1: length 11.9
  TOP w0.305: RC24.2 56.79,109.9 CC85.1 v18(57.82,109.9)
  VCC w0.305: v18(57.82,109.9) 61.79,109.9 63.82,111.92 63.82,112.81 64.92,113.91 v21(64.92,114.24)
  GND1 w0.254: v21(64.92,114.24) 64.92,114.38 v2(64.75,114.55)
  BOTTOM w0.254: v10(65.06,114.55) v5(65.06,113.99)
  vias: v6(65.06,114.31)
+VCCCLK2: length 13.1
  TOP w0.305: v18(57.3,108.63) 56.79,108.63 RC26.2
  VCC w0.305: v21(65.33,113.67) 64.76,113.1 64.76,111.99 61.39,108.63 v18(57.3,108.63)
  IN1 w0.254: v21(65.33,113.67) 65.21,113.55 v2(64.97,113.55)
  IN4 w0.203: v10(65.56,114.55) v3(65.56,114.26) v5(65.56,113.99)
  BOTTOM w0.254: v10(65.56,114.55) v5(65.56,113.99)
+VCCCLK3: length 15.2
  TOP w0.305: v9(66.3,113.47) 66.3,110.82 65.58,110.1 65.58,108.27
  GND1 w0.254: v9(66.3,113.47) 66.55,113.72 v2(66.55,113.93)
  IN3 w0.06: v2(65.99,107.69) 66.11,107.8 v7(66.31,107.8)
  GND3 w0.254: v2(66.55,113.93) v8(66.55,114.27)
  IN4 w0.254: v5(66.55,113.99) 66.55,114.27 v8(66.55,114.27)
  BOTTOM w0.254: UC1.Y23 v5(66.55,113.99)
  BOTTOM w0.508: RC91.2 67.83,105.25 69.13,105.25 70.26,106.38 70.26,107.61 70.07,107.8 68.89,107.8 68.76,107.92 67.48,107.92 67.21,108.19
  vias: v1(65.58,107.95) v1(65.58,107.69) v7(66.29,108.07)
+VCCCLK4: length 13.1
  TOP w0.305: v9(65.82,114) 65.82,112.69 65.05,111.92 65.05,111.52 64.31,110.78 64.31,105.31 v1(64.46,105.15)
  GND1 w0.254: v9(65.82,114) 65.82,114 65.82,114 v2(66.05,114.23)
  IN1 w0.305: v1(64.46,105.15) 64.75,105.15 v2(64.89,105.02)
  IN3 w0.254: v7(65.01,104.61) 65.01,104.89 v2(64.89,105.02)
  GND3 w0.254: v2(66.05,114.23) 66.06,114.23 v10(66.06,114.55)
  IN4 w0.254: v10(66.06,114.55) v5(66.06,113.99)
  BOTTOM w0.254: v10(66.06,114.55) v5(66.06,113.99)
  BOTTOM w0.305: RC108.2 65.01,104.16 v7(65.01,104.61)
+VCCCLK5: length 17.4
  TOP w0.254: v9(57.3,106.58) 56.84,106.58 RC29.2
  VCC w0.305: v9(57.3,106.58) 58.31,106.58 58.48,106.76 60.13,106.76 65.91,112.54 66.01,112.54
  GND1 w0.254: v2(57.34,107.03) 57.34,106.61 v9(57.3,106.58)
  IN3 w0.254: v2(57.34,107.03) 57.2,107.17 v3(57.2,107.61)
  IN4 w0.254: v3(57.2,107.61) 56.77,108.04 56.77,109.65 56.95,109.83 56.95,111.14 v4(56.62,111.47)
  vias: v2(66.62,112.87) v5(66.55,112.87) v6(66.29,112.87) v10(66.06,112.87) v19(66.27,112.87) v19(66.4,112.61)
+VCCCLK6: length 10.8
  TOP w0.305: v1(63.93,104.66) 63.8,104.79 63.8,110.85 64.64,111.68 64.64,112.44 v9(65.14,112.94)
  GND1 w0.254: v2(65.4,113.15) 65.34,113.15 v9(65.14,112.94)
  IN1 w0.305: v1(63.93,104.66) v2(64.44,104.66)
  IN3 w0.254: v2(64.44,104.66) 64.44,104.61 v7(64.19,104.36)
  GND3 w0.254: v10(65.56,112.87) 65.4,113.03 v2(65.4,113.15) 65.4,113.27 v10(65.56,113.43)
+VCCCOREG0: length 0.7
  GND3 w0.203: v2(71.5,112.85) v8(71.5,113.18) ; v2(70.51,112.85) v8(70.51,113.18)
  vias: v1(71,115.89) v1(71.03,114.77) v1(71.02,113.63) v1(71.71,114.82) v1(71.7,113.7) v2(70.51,115.08) v2(70.51,113.96) v2(71.5,115.08) v2(71.5,113.96) v4(70.51,112.87) v4(71.5,112.87) v5(70.51,115.11) v5(70.51,113.99) v5(70.51,113.43) v5(71.5,115.1) v5(71.5,113.99) v5(71.5,113.43) v8(70.51,115.42) v8(70.51,114.3) v8(71.5,115.42) v8(71.5,114.31) v12(70.51,115.66) v12(70.51,114.55) v12(71.5,115.66) v12(71.5,114.55) v18(71.03,115.28) v18(71.03,114.14) v18(71.01,113.02) v18(71.63,115.46) v18(71.63,114.27) v18(71.63,113.16) v18(71.69,115.97) v21(70.75,115.8) v21(70.74,114.77) v21(70.76,113.68) v21(70.85,115.02) v21(71.1,115.02) v21(71.15,113.89) v21(71.25,115.82) v21(71.43,113.63) v21(71.57,115.73) v21(71.63,114.54) v21(71.62,113.43)
+VCCCOREG1: length 0.4
  GND3 w0.254: v12(70.51,117.34) v2(70.51,116.99)
  vias: v1(71.08,118.76) v1(71.08,117.64) v1(71.66,118.71) v1(71.6,117.15) v1(71.7,117.6) v2(70.51,118.99) v2(70.51,117.88) v2(71.5,119) v2(71.5,117.88) v2(71.5,116.74) v4(70.51,119.02) v4(70.51,117.9) v4(70.51,116.78) v4(71.5,119.02) v4(71.5,117.9) v4(71.5,116.78) v5(70.51,118.46) v5(71.5,118.46) v8(70.51,119.33) v8(70.51,118.22) v8(71.5,119.34) v8(71.5,118.21) v8(71.5,117.1) v12(70.51,119.58) v12(71.5,119.58) v12(71.5,117.34) v18(71.07,117.07) v18(71.08,119.32) v18(71.08,118.2) v18(71.65,119.33) v18(71.67,118.2) v21(70.51,117.54) v21(70.84,118.86) v21(70.85,118.56) v21(70.79,117.57) v21(71.08,117.36) v21(71.28,118.52) v21(71.55,118.45)
+VCCPRIM_1P0: length 5.6
  IN1 w0.254: v2(64.33,118.66) 64.12,118.87 v1(63.85,118.87)
  IN3 w0.254: v10(64.07,117.34) 64.07,117.71 v2(63.99,117.79)
  GND3 w0.254: v12(66.06,120.13) 66.2,119.99 v2(66.2,119.85) 66.2,119.72 v12(66.06,119.58) ; v12(64.57,115.11) 64.38,115.3 v2(64.32,115.3) 64.27,115.3 v12(64.07,115.11)
  IN4 w0.254: v12(66.06,120.13) v12(66.06,119.58) ; v12(64.07,115.11) v12(64.57,115.11)
  BOTTOM w0.203: UC1.AH13 64.04,117.3 v10(64.07,117.34)
  BOTTOM w0.356: v12(65.06,118.46) v12(65.06,117.9) v12(65.06,117.34) v12(65.56,117.34)
  vias: v1(57.26,120.2) v1(57.61,120.61) v1(57.61,120.36) v1(57.61,120.11) v2(57.18,120.54) v2(57.18,119.83) v2(57.45,119.52) v2(58.77,114.01) v2(65.21,118.18) v2(65.31,117.54) v15(58.6,114.31) v15(58.95,114.31)
+VCCPRIM_3P3: length 8.3
  VCC w0.508: 64.92,117.82 63.3,117.82 63.3,117.82 63.23,117.82 62.97,118.07 v18(62.74,118.07) 62.05,118.07 60.6,116.63 58.95,116.63
  BOTTOM w0.305: v12(66.06,117.34) v5(66.06,117.9) v5(65.56,117.9) v5(65.56,118.46)
  vias: v2(56.92,116.58) v2(57.33,116.58) v2(66.06,118) v8(66.06,117.62) v15(57.54,116.15) v15(57.75,115.98) v15(58,115.92) v18(55.94,117.01) v18(55.94,116.37) v18(56.63,117.01) v19(56.92,116.25) v19(57.05,116.93) v19(57.18,116.25) v19(57.3,116.93) v19(65.71,118.02) v19(65.86,118.28)
+VCCPRIM_CORE: length 3.4
  IN3 w0.254: v2(65.32,116.43) 65.11,116.22 v7(65.06,116.22) ; v2(64.86,119.74) 64.7,119.58 v7(64.57,119.58)
  BOTTOM w0.254: UC1.AT16 v7(64.57,119.58)
  BOTTOM w0.356: v12(65.56,116.78) v12(65.06,116.78) v7(65.06,116.22) v12(65.56,116.22) v12(65.56,116.78)
  vias: v1(64.95,116.55) v1(65.02,116.8) v1(65.65,117.03) v1(65.65,116.78) v2(65.31,116.98) v9(64.22,119.61) v9(64.48,119.42) v18(55.68,118.94) v18(55.93,118.94) v18(56.18,118.94) v18(56.44,118.94)
+VCCSRAM_1P0: length 0.5
  BOTTOM w0.356: v4(66.55,115.11) v12(66.06,115.11)
  vias: v2(66.06,115.43) v2(66.55,119) v2(66.55,117.87) v4(66.55,119.02) v4(66.55,117.9) v8(66.3,115.11) v8(66.55,119.33) v8(66.55,118.21) v9(65.73,115.56) v9(65.73,115.31) v9(66.22,118.96) v9(66.45,119.32) v9(66.57,118.2) v9(66.55,117.54) v12(66.55,119.58) v12(66.55,118.46) v18(57.62,115.66) v18(57.88,115.66) v18(62.64,116.17) v18(62.89,116.17)
+VDDQ_CPU_CLK: length 0.6
  IN3 w0.06: v2(72.17,121.29) 72.17,121.27 72.15,121.29 v10(71.85,121.29)
  GND3 w0.254: v2(72.17,121.29) v10(71.85,121.29)
  vias: v1(72.03,122.3)
AGND: length 590.9
  TOP w0.254: 147.24,100.37 147.04,100.17 146.48,100.17 145.91,100.74 v1(145.91,101.03) ; v1(141.1,103.8) 141.35,103.55 U21.15 141.35,101.8 141.83,101.31 C179.2
  TOP w0.381: 137.67,104.97 137.67,107 138.06,107.39 C144.2 R156.1 139.78,107.79 139.98,107.99 141.22,107.99 141.6,107.61 R159.1 141.93,107.39 142.13,107.58 CA11.2
  IN1 w0.203: 33.83,94.27 v2(33.79,94.3) 33.34,94.76 31.6,94.76 30.12,93.28 27.94,93.28 26.33,91.67 23.94,91.67 19.84,95.77 19.84,106.4 20.43,107 20.43,114.15 19.74,114.85 19.74,116.4 9.55,126.58 v2(7.31,126.58) 6.83,126.58 v2(6.71,126.71) 5.85,127.57 5.85,128.16 v2(6.43,128.73)
  IN1 w0.254: v2(6.43,128.73) 6.88,129.18 6.88,129.59 6.61,129.86 5.5,129.86 4.72,129.09 4.72,126.4 6.24,124.88 9,124.88 18.24,115.65 18.24,114.23 18.94,113.53 18.94,107.62 18.34,107.03 18.34,95.04 23.3,90.07 26.96,90.07 28.68,91.79 30.75,91.79 32.03,93.07 v2(32.55,93.07) 32.82,92.8 33.07,92.8 34,93.73 34,94.1 33.83,94.27 ; v2(146.9,99.77) 147.24,100.12 147.76,100.12 148.27,100.62 148.27,101.12 148.01,101.39 v1(147.74,101.39) v1(147.33,101.39) 146.27,101.39 v1(145.91,101.03) 145.86,101.08 145.12,101.08 144.51,100.47 v2(144.51,99.94) 144.88,99.57 146.7,99.57 v2(146.9,99.77)
  IN2 w0.508: v2(115.9,93.17) 115.37,93.7 99.27,93.7 97.31,95.66 86.09,95.66 84.54,94.11 84.54,93.25 83.97,92.67 v2(83.97,92.26)
  IN3 w0.127: 144.51,99.09 144.17,99.09 142.95,97.87 141.6,97.87 141.5,97.77 141.5,97.79 ; v2(144.51,99.94) 144.25,99.94 143.98,100.21 142.7,100.21 142.44,99.95 142.44,99.28 142.15,98.99 141.07,98.99 v3(141.02,98.94) 141.02,98.02 141.17,97.87 141.43,97.87 141.5,97.79 ; 141.5,97.79 v6(141.5,97.81)
  IN3 w0.254: 32.42,93.2 32.42,93.89 32.96,94.43 33.67,94.43 v2(33.79,94.3) 33.86,94.36 34.23,94.36 35.88,92.71 39.29,92.71 v6(39.41,92.6) 39.65,92.36 39.65,91.24 39.42,91.01 38.39,91.01 v3(38.38,91) 38.37,91.01 35.28,91.01 33.67,92.62 32.99,92.62 v2(32.55,93.07) 32.42,93.2 ; 144.51,99.09 144.51,96.67 144.86,96.33 v3(146.38,96.33) 146.67,96.62 146.67,99.55 v2(146.9,99.77) 146.9,100.13 146.48,100.55 144.89,100.55 144.51,100.17 v2(144.51,99.94) 144.51,99.09
  IN3 w0.381: v2(83.97,92.26) 83.97,92.22 v7(83.62,91.86)
  IN4 w0.102: 83.27,92.19 86.17,92.19 87.65,93.67 97.69,93.67 97.73,93.64
  IN4 w0.127: 86.89,95.07 87.01,95.18 96.3,95.18 96.4,95.28
  IN4 w0.152: 140.96,97.26 134.84,97.26 134.62,97.04 133.98,97.04 v4(133.82,97.21) 133.67,97.36 133.67,97.64 134.29,98.26 140.35,98.26 v3(141.02,98.94) 141.57,98.94 141.77,98.73 141.77,98.07 v6(141.5,97.81) 140.96,97.26
  IN4 w0.203: 97.73,93.64 97.74,93.64 98.41,92.97 116.07,92.97 v7(116.27,93.17) 116.27,93.32 116.5,93.55 118.55,93.55 119.52,92.58 136.89,92.58 137.06,92.75 ; 146.38,97.04 145.88,97.54 144.75,97.54 141.58,94.36 136.4,94.36 136.2,94.16 125.17,94.16 124.68,94.64 123.36,94.64 122.88,94.16 120.22,94.16 119.24,95.14 115.54,95.14 115.42,95.25 105.42,95.25 105.01,94.84 ; 86.89,95.07 85.73,93.9 82.71,93.9 81.19,92.38 42.29,92.38 41.91,92 41.43,92
  IN4 w0.254: 96.4,95.28 98.4,95.28 98.83,94.84 105.01,94.84 ; 137.06,92.75 142.44,92.75 146.02,96.33 v3(146.38,96.33) 146.38,97.04 ; 41.43,92 40,92 v6(39.41,92.6) 38.48,92.6 v4(38.17,92.29) 38.07,92.19 38.07,91.3 v3(38.38,91) 39.01,90.36 42.54,90.36 42.92,90.74 81.83,90.74 83.27,92.19
  IN4 w0.508: v4(22.46,93.89) 22.35,94 22.35,98.08 21.82,98.62 21.82,107.25 20.09,108.98 20.09,113.99 12.75,121.33 12.34,121.33 11.97,121.7
  BOTTOM w0.508: 133.96,103.27 130.34,103.27 127.76,100.69 120.24,100.69 117.65,98.09 117.65,94.2 116.94,93.49 ; 133.96,103.27 134.26,103.27 ; 133.96,103.27 133.96,99.84 ; v7(83.62,91.86) 83.35,92.13 82.03,92.13 81.67,91.78 80.96,91.78 43.54,91.78 43.17,91.4 39.06,91.4 v4(38.17,92.29) 35.76,92.29 34.99,91.52 28.98,91.52 26.18,94.32 24.53,94.32 24.1,93.89 v4(22.46,93.89)
  vias: v1(135.43,103.42) v1(135.46,103.09) v1(137.52,104.18) v1(137.52,102.03) v1(137.82,104.18) v1(139.61,104.05) v1(142.37,102.35) v1(142.52,102.56) v1(144.98,103.29) v1(145.47,103.46) v1(145.48,103.08) v2(14.05,150.55) v2(14.05,148.47) v2(14.08,152.76) v2(135.79,103.16) v4(8.84,122.42) v4(11.12,124.06) v4(11.96,124.08) v4(12.88,124.11) v7(6.15,124.55) v7(6.12,122.8) v7(8.7,123.46) v7(9.03,123.46) v7(11.35,121.78) v7(11.35,121.4) v7(12.42,122.14) v7(116.65,93.17) v7(135.43,103.44) v7(135.43,103.16) v8(9.4,134.1) v9(7.28,142.26) v9(7.28,141.7) v9(7.75,132.96) v9(7.75,132.7) v9(8,129.15) v9(8.25,129.15) v9(8.45,138.55) v9(10.35,144.77) v9(10.73,144.77) v15(8.27,128.01) v15(8.58,128.01) v15(8.81,138.83) v15(8.81,138.57) v15(8.84,137.73) v15(8.84,137.48) v15(8.95,133.14) v15(8.99,136.51) v15(9.3,133.14) v15(9.91,136.4) v15(10.16,136.63) v15(10.39,142.12) v15(10.52,134.89) v15(10.97,142.12) v15(11.62,137.99) v15(11.59,137.71) v15(11.68,135.7) v15(13.08,125.69) v15(13.23,126.04)
GND: length 2754
  TOP w0.127: v9(216.85,110.95) 217.08,111.18 217.08,115.98 216.07,116.99 v9(213.26,116.99) ; 206.99,141.04 207.04,141 207.04,139.09 206.48,138.53 204.09,138.53 203.94,138.39
  TOP w0.203: v9(128.08,113.96) 128.3,114.18 128.3,115.51 128.07,115.74 123.41,115.74 122.15,114.48 v9(122.15,113.82) ; D11.2 130.67,108.38 v9(130.2,108.38) ; v9(127.97,106.16) 127.97,106.58 127.5,107.05 124.73,107.05 ; v9(209.36,113.87) 205.49,113.87 205.16,114.2 205.16,116.96 205.55,117.35 208.67,117.35 209.04,117.71 v9(210.04,117.71) ; UA2.47 39.75,82.89 39.89,83.04 39.89,83.59 v9(39.83,83.66) ; v9(216.03,102.61) 216.02,102.61 U18.11 ; U14.10 208.14,115.49 208.14,115.48 ; v9(32.49,82.62) 32.61,82.62 32.74,82.49 UA2.15 ; U15.11 25.89,111.63 v9(25.73,111.47) ; v13(216.59,111.75) 215.91,111.75 215.18,112.49 215.18,113.67 v13(215.3,113.79) 212.57,113.79 v9(212.54,113.76) ; UA2.38 39.72,79.29 39.93,79.09 v9(39.93,78.7) ; v9(44.3,133.04) U4.7 ; U25.15 28.29,76.62 v13(28.14,76.47) ; v13(214.66,115.29) 214.46,115.49 U14.21 ; v9(44.3,133.44) U4.6 ; 124.73,107.05 122.55,107.05 122.01,106.5 122.01,104.97 122.33,104.65 D19.2 ; 124.73,107.05 124.97,106.81 v9(124.97,106.16) 124.99,106.13 124.99,105.45 125.35,105.1 v9(125.35,103.62) 125.35,103.27 125.49,103.12 125.49,102.8 v9(125.49,102.8) ; v9(123.48,105.39) 123.77,105.1 123.77,103.96 123.91,103.82 v9(123.91,103.62) 123.91,103.01 v9(123.76,102.86) ; U7.11 U7.15 ; v13(200.95,139.48) 200.84,139.59 200.84,142.01 201.17,142.34 v13(201.5,142.34) ; D13.2 131.28,106.76 v9(131.3,106.78) ; v1(126.79,101.5) 126.78,101.51 126.78,102 126.92,102.15 v9(126.92,102.8) 126.92,103.35 v9(127.15,103.58) 127.15,103.8 127,103.95 127,104.96 v9(126.5,105.45) ; v9(27.97,71.8) 27.89,71.87 U25.35 ; U4.16 v9(48.7,133.84) ; v9(35.52,105.7) U20.11 ; v9(44.3,132.64) U4.8
  TOP w0.254: v9(123.76,102.86) 123.76,101.45 v1(123.77,101.43) 123.75,101.41 123.75,101.02 123.62,100.89 ; 125.34,101.07 125.29,101.11 v1(125.29,101.49) 125.29,102.6 v9(125.49,102.8) ; 125.34,101.07 125.16,100.89 123.62,100.89 ; 125.34,101.07 125.52,100.89 126.63,100.89 126.81,101.07 ; D19.2 122.33,102.38 v9(122.38,102.33) 122.38,101.07 122.56,100.89 123.62,100.89 ; C42.2 130.67,132.02 130.37,132.32 v9(130.34,132.32) ; 126.81,101.07 127,100.88 128.09,100.88 128.24,101.03 128.24,101.41 v1(128.27,101.44) 128.27,101.48 128.59,101.79 v9(128.59,103.58) 128.59,105.18 127.97,105.81 v9(127.97,106.16) ; 126.81,101.07 126.81,101.48 v1(126.79,101.5) ; v9(57.63,117.21) 57.43,117.01 CC62.2 ; v9(30.47,72.86) 31.26,72.86 31.7,72.43 31.7,72.28 32.48,71.49 33.48,71.49 33.78,71.8 33.78,76.22 33.48,76.52 32.45,76.52 31.6,77.37 30.63,77.37 30.4,77.6 30.4,79 30.05,79.35 v9(29.9,79.35) ; R3.1 v9(198.65,142.62) ; U6.F4 v9(129.36,128.98) ; C99.2 v9(210.95,125.45) ; C75.2 v9(126.95,129.15)
  TOP w0.305: 206.99,141.04 v13(206.99,141.37) 206.9,141.37 206.32,141.95 v13(205.59,141.95) 205.19,142.34 204.15,142.34 203.97,142.52 202.07,142.52 201.66,142.93 ; v13(200.95,139.48) 200.88,139.41 200.88,139.03 201.52,138.39 203.94,138.39
  TOP w0.33: R184.1 v9(77.09,101.79)
  TOP w0.381: v9(53.61,125.07) 53.43,125.25 CLRP2.1 ; v9(57.3,107.53) CC87.2
  TOP w0.508: v9(146.53,117.57) 146.25,117.57 146.05,117.77 PR302.2 ; v9(52.96,120.44) 53.14,120.44 53.43,120.15 RH33.1 ; R225.1 v9(33.93,62.85) ; C114.2 145.3,124.84 v9(144.64,125.5) ; v9(53.51,138.52) 52.5,137.76 52.5,137.45 v9(52.5,137.45) ; PR921.2 175.06,100.2 v9(175.08,100.22) ; PC115.2 v9(34.71,30.65)
  IN1 w0.127: v2(183.11,99.71) 183.11,99.98 v1(182.97,100.12)
  IN1 w0.203: 33.11,37.49 33.35,37.25 33.35,34.51 28.55,29.71 ; 126.35,111.53 127.75,111.53 128.35,112.13 128.35,112.6 128,112.94 128,114.76 128.33,115.09 128.33,115.43 128.09,115.67 123.42,115.67 123.27,115.52 123.27,115.27 123.08,115.08 v11(123.08,110.29) 123.08,109.87 123.28,109.67 124.49,109.67 126.35,111.53
  IN1 w0.254: v1(182.54,99.12) 182.44,99.01 181.76,99.01 181.5,99.27 ; v2(39.32,66.46) 39.32,65.95 v1(39.24,65.88) 39.24,65.57 v2(39.06,65.39) ; v2(39.32,66.46) 38.81,66.97 37.93,66.97 37.73,66.77 v2(37.72,66.77) 37.72,65.98 v1(37.77,65.93) 37.77,65.89 38.29,65.37 39.04,65.37 v2(39.06,65.39) ; v2(39.32,66.46) 39.94,66.46 v1(40,66.4) 40.37,66.4 40.79,65.98 40.79,65.57 v2(40.88,65.48) 40.88,65.13 40.61,64.86 39.6,64.86 v2(39.06,65.39) ; v2(19.91,41.26) 19.91,40.68 20.28,40.31 20.28,40.15 ; v13(208.57,94.41) 208.37,94.62 208.37,95.89 207.75,96.51 202.89,96.51 202.19,95.8 v2(200.31,95.8) 200.28,95.77 v2(197.95,95.77) 197.81,95.92 181.71,95.92 178.72,92.93 v2(178.22,92.93) 118.94,92.93 118.71,92.7 115.33,92.7 115.25,92.62 109.6,92.62 109.21,93.01 v11(101.4,93.01) ; 31.19,80.97 v2(28.98,83.17) 27.3,83.17 22.96,87.52 22.47,87.52 21.24,88.74 20.73,88.74 20.55,88.56 20.55,87.44 28.57,79.42 29.83,79.42 30.47,78.78 30.99,78.78 31.19,78.98 31.19,80.97 ; 32.79,76.14 32.79,75.3 v21(32.89,75.2) 32.85,75.2 32.67,75.02 32.67,74.3 v21(32.89,74.08) 32.87,74.08 32.65,73.87 32.65,73.5 v21(32.16,73) 32.34,72.81 v21(32.34,71.67) 32.34,71.54 32.92,70.97 34.01,70.97 34.7,71.65 34.7,72.38 v2(34.21,72.86) 34.21,73.47 v2(34.24,73.5) 34.24,74.56 v2(34.29,74.62) 34.29,75.71 v2(34.34,75.76) 34.34,76.24 v2(34.04,76.55) 33.2,76.55 v21(32.92,76.27) 32.79,76.14
  IN1 w0.305: 21.9,33.38 24.37,33.38 25.63,32.12 25.7,32.12 25.7,32.11 27.16,32.11 27.16,32.12 28.19,32.12 v2(29.34,33.26) ; 28.55,29.71 v2(27.03,29.71) 26.99,29.74 24.65,29.74 v2(24.63,29.72) ; 15.75,19.73 v2(17.96,19.73) ; 15.75,19.73 19.43,23.41 20.4,23.41 24.56,27.57 24.56,29.66 v2(24.63,29.72) ; 15.75,19.73 10.77,14.75 9.25,14.75 ; v2(17.68,30.52) 17.63,30.47 17.63,25.42 10.82,18.61 9.46,18.61 ; v2(23.2,35.08) 22.35,34.23 18.52,34.23 ; v2(19.45,25.37) 21.07,26.99 21.07,30.03 v2(21.38,30.34) v11(22.1,30.34) 22.23,30.47 v11(23.56,30.47) 24.07,30.47 24.49,30.05 24.49,29.86 v2(24.63,29.72)
  IN1 w0.381: v2(21.38,30.34) 20.66,31.06 20.66,33.19 20.85,33.38 21.9,33.38
  IN1 w0.508: v13(7.3,157.37) 9.21,155.46 JHP1.6 ; v1(8.84,141.61) 8.86,141.58 11.24,141.58 11.98,142.32 14.19,142.32 14.74,141.76
  IN2 w0.119: 43.51,109.3 43.7,109.11 47.48,109.11 48.37,108.22 49.43,108.22 v2(49.52,108.13) ; v2(55.83,104.18) 55.83,104.1 55.37,103.64 54.78,103.64 v2(54.48,103.34) 54.27,103.55 49.17,103.55 48.61,104.11 47.99,104.11 47.75,104.35 47.35,104.35 47.02,104.69 38.56,104.69 37.11,103.25 37.01,103.25 37,103.24 35.18,103.24 34.83,102.89 v2(33.31,102.89)
  IN2 w0.127: v2(40.45,97.67) 39.45,97.67 36.21,94.43 v2(36.21,94.43) 36.21,94.06 35.15,93 34.75,93 27.08,85.32 27.08,84.78 23.2,80.91 ; 23.19,68.87 22.86,69.2 v2(22.86,75.12) 22.86,80.57 23.2,80.91 ; v2(34.82,98.19) 34.26,98.19 23.36,87.28 23.36,86.27 19.14,82.06 19.14,54.9 ; 131.84,108.64 132.17,108.64 132.38,108.85 132.38,111.01 130.01,113.39 129.48,113.39 128.82,114.05 128.82,114.4 129.06,114.65 ; 59.02,123.87 59.01,123.86 58.51,123.86 ; 44.33,110.95 44.81,110.48 48.06,110.48 49.35,109.18 50.22,109.18 50.31,109.09 57.28,109.09 ; 58.51,123.86 58.51,123.89 59.53,124.91 59.59,124.91 59.65,124.96 60.25,124.96 ; 58.51,123.86 57.46,123.86 57.2,124.13 56.61,124.13 ; 43.12,121.48 43.12,122.07 43.34,122.3 43.34,124.11 42.87,124.58 42.87,126.6 43.94,127.67 43.94,131.82 46.22,134.09 46.96,134.09 49.82,136.95 49.82,137.47 50.49,138.14 52.69,138.14 53.02,137.81 53.02,135.29 v2(53.11,135.19) 53.25,135.05 56.41,135.05 56.72,134.75 56.72,134.2 v2(56.75,134.17) ; H9.1 49.71,121.12 49.71,125.64 50.96,126.89 50.96,127.58 50.79,127.75 50.79,129.95 50.69,130.05 50.69,130.42 52.07,131.8 53.81,131.8 54.02,132.02 54.25,132.02 54.36,132.12 55.62,132.12 56.74,133.24 56.74,134.17 v2(56.75,134.17) ; 23.2,80.91 v2(23.2,80.9) ; v2(56.75,134.17) 56.78,134.2 57.5,134.2 58.52,135.23 59.23,135.23 v2(59.45,135.45) ; v2(88.42,100.78) 88.56,100.92 92.71,100.92 93.1,100.54 95.41,100.54 96.29,99.66 98.61,99.66 102.75,95.52 116.7,95.52 117.44,96.26 ; v2(52.73,133.64) 51.94,133.64 51.36,134.23 v2(51.21,134.23) 50.42,133.44 50.42,132.86 49.43,131.87 47.65,131.87 46.66,130.87 46.66,129.86 46.32,129.51 46.32,126.16 45.62,125.47 45.62,123.19 45.29,122.86 45.29,121.6 44.95,121.27 44.95,120.77 44.8,120.61 44.8,117.19 45.41,116.58 45.41,115.87 46.46,114.82 46.46,114.2 47.76,112.9 48.65,112.9 50,111.55 50,111.47 50.32,111.14 52.65,111.14 53.07,111.56 ; 59.46,124.14 v2(59.49,124.11) 59.23,123.86 ; 95.11,111.89 95.13,111.89 95.13,111.73 98.91,107.95 100.42,107.95
  IN2 w0.152: v2(110.21,105.22) 111.16,106.17 113.02,106.17 120.15,113.3 120.15,113.33
  IN2 w0.203: 41.82,120.71 41.82,128.23 41.82,128.63 42.1,128.91 42.1,129.67 42.84,130.41 42.84,131.43 42.84,131.43 42.84,134.78 44.56,136.49 45.64,136.49 50.63,141.49 51.09,141.49 53.64,141.49 53.89,141.74 ; 56.9,126.91 57.22,126.91 57.74,127.44 58.67,127.44 v2(60,128.77) 61.3,128.77 65.27,132.74 69.35,132.74 70.2,133.59 85.96,133.59 86.33,133.96 98.9,133.96 98.99,134.05 106.17,134.05 106.26,133.96 108.2,133.96 108.2,133.96 110.9,133.96 111.7,134.76 119.63,134.76 119.73,134.66 121.23,133.15 123.18,133.15 124.35,131.99 125.02,131.99 125.94,131.06 129.61,131.06 130.16,130.51 131.88,130.51 132.36,130.99 134.55,130.99 138.27,134.71 144.37,134.71 ; 43.51,109.3 43.47,109.34 36.37,109.34 ; 97.89,130.38 99.82,130.38 100.47,131.03 104.5,131.03 105.71,129.81 ; 97.89,130.38 97.89,128.56 ; 97.89,130.38 97.14,130.38 v2(96.88,130.11) ; v2(95.6,130.47) 94.6,129.47 88.37,129.47 86.72,127.82 84.58,127.82 83.29,129.11 79.5,129.11 77,126.62 65.49,126.62 64.52,125.64 61.67,125.64 60.14,124.11 60.13,124.11 60.07,124.06 ; 36.37,109.34 36.37,109.71 36.37,110.45 33.1,113.73 29.5,113.73 25.9,110.12 23.14,110.12 22.97,109.96 22.97,109.31 23.55,108.74 ; 36.37,109.34 35.78,109.34 35.46,109.67 35.46,110.06 32.78,112.74 29.96,112.74 29.03,111.82 29.03,111.5 v2(29.18,111.34) ; v2(94.03,126.19) 93.83,125.98 83.83,125.98 82.65,127.17 80.24,127.17 77.84,124.77 66.48,124.77 ; 129.06,114.65 129.74,114.65 130.16,114.23 130.16,113.87 133.31,110.72 133.64,110.72 133.98,110.38 133.98,110.04 ; v2(147.45,130.16) 146.94,130.67 143.74,130.67 143.08,130.01 143.08,128.49 142.04,127.45 142.04,125.8 139.37,123.13 134.98,123.13 134.8,122.95 133.2,122.95 132.28,123.87 131.57,123.87 127.84,120.14 127.84,119.16 127.51,118.82 126.83,118.82 126.4,119.26 121.88,119.26 121.19,118.56 120.5,118.56 117.27,115.33 117.27,114.25 111.71,108.69 104.69,108.69 103.94,107.95 100.42,107.95 ; 99.62,130.87 100.27,131.52 105.12,131.52 105.74,130.89 108.5,130.89 ; v2(56.06,124.68) 56.06,124.48 56.4,124.13 56.61,124.13 ; 66.37,128.95 63.57,126.16 61.45,126.16 60.25,124.96 ; 57.28,109.09 57.65,109.46 59.13,109.46 v2(59.58,109.02) ; 210.25,119.15 210.3,119.2 ; 42.34,112.64 42.65,112.64 44.33,110.95
  IN2 w0.254: v13(29.51,76.52) 29.62,76.62 29.62,84.66 34.77,89.82 34.77,89.89 35.45,90.57 35.45,90.6 35.85,91.01 35.89,91.01 40.49,95.61 41.12,95.61 41.88,96.37 v2(42.37,96.37) ; 164.21,129.65 v2(166.32,127.54) ; 164.21,129.65 164.21,129.4 162.69,127.88 154.48,127.88 154.3,128.06 151.97,128.06 151.7,128.32 150.46,128.32 149.33,127.19 146.3,127.19 144.67,125.55 144.67,123.69 144.02,123.04 144.02,122.75 144.04,122.72 ; 164.21,129.65 164.21,130.29 162.4,132.1 152.17,132.1 151.6,131.53 149.29,131.53 147.92,130.16 v2(147.45,130.16) ; 212.66,119.05 v2(212.7,119.09) ; v2(215.58,103.56) 217.42,103.56 218.3,104.43 218.3,105.26 219,105.96 v2(219,106.28) v2(219,115.39) 218.56,115.83 218.56,117.14 218.56,120.06 218.92,120.42 v2(218.92,127.45) ; v2(43.67,92.88) 43.67,92.95 44.49,93.77 46.01,93.77 47.11,92.67 54.07,92.67 54.99,93.59 v2(54.99,94.01) ; v2(35.79,107.63) 36.25,108.09 41.1,108.09 v2(41.17,108.02)
  IN2 w0.305: 208.89,133.26 207.48,133.26 204.45,130.24 202.06,130.24 v2(201.49,130.81) ; 208.89,133.26 v2(208.88,133.25) ; 208.89,133.26 209.54,133.26 209.89,132.91 v2(213.24,132.91) 215.35,132.91 v2(215.88,132.38) ; 130.58,116.02 131.77,114.82 131.77,114.14 132.84,113.07 133.17,113.07 136.6,109.64 138.1,109.64 v2(142.82,104.92) 142.94,105.03 151.88,105.03 152.6,105.76 158.47,105.76 159.19,105.03 168.62,105.03 v2(168.73,104.92) 180.56,104.92 181.14,105.5 193.6,105.5 194.01,105.91 197.78,105.91 199.79,107.92 ; v2(218.92,127.45) 218.92,132.6 v2(218.13,133.39) 218.13,133.4 216.22,135.32 v2(214.11,135.32) 210.67,135.32 210.55,135.44 205.57,135.44 205.34,135.21 205.34,134.64 204.87,134.17 201.23,134.17 201.15,134.09 198.78,134.09 198.44,133.75 197.38,133.75 196.48,134.65 v2(196.01,134.65) 195.5,134.65 194.45,135.69 193.12,135.69 v2(192.65,135.22) 192.59,135.16 189.56,135.16 188.96,134.56 v2(187.74,134.56) 183.97,134.56 181.71,132.3 180.9,132.3 180.49,131.89 180.49,131.56 v2(180.24,131.31) 180.26,131.28 180.26,130.83 179.98,130.55 178.28,130.55 177.79,130.05 173.71,130.05 169.05,134.71 144.37,134.71 ; 172.42,126.08 169.47,126.08 168,127.54 v2(166.32,127.54) ; 25.43,66.64 23.19,68.87 ; v2(134.31,109.43) 134.84,109.43 136.13,108.13 137.6,108.13 v2(138.55,107.18) v2(140.85,104.88) 143.08,102.66 148.43,102.66 149.27,103.49 152.32,103.49 153.2,104.37 157.69,104.37 158.57,103.49 184.04,103.49 184.69,104.15 198.09,104.15 200.03,106.09
  IN3 w0.084: v2(50.44,124.42) 50.33,124.3 49.15,124.3 v3(48.95,124.09)
  IN3 w0.102: v2(60,128.77) 60,128.48 60.27,128.21 60.27,127.74 63.92,124.09 64.01,124.09 65.4,122.7 65.4,122.44 65.53,122.32 65.53,122.06 65.71,121.88 65.71,121.64 66.07,121.29 66.07,120.78 66.06,120.78 66.07,120.78 v2(66.07,120.76)
  IN3 w0.127: v22(138.75,102.04) 138.1,101.39 v22(136.4,101.39) 136.32,101.31 131.6,101.31 v22(130.8,102.11) ; 28.52,108.63 29.06,108.63 29.24,108.45 29.24,105.22 28.98,104.97 28.98,104 29.41,103.57 30.94,103.57 v2(31.26,103.89) ; 28.52,108.63 29.16,109.26 v3(29.16,109.34) ; 28.52,108.63 25.73,105.83 20.57,105.83 19.86,105.12 19.86,104.16 20.07,103.95 20.07,103.24 ; v2(183.11,99.71) 182.7,99.3 180.85,99.3 ; 114.35,97.48 115.29,98.41 117.98,98.41 v22(118.01,98.44) 120.13,98.44 v22(120.22,98.35) ; v22(150.54,96.58) 150.54,97.67 148.59,99.61 ; v2(170.74,97.93) 170.74,97.53 170.85,97.42 173.91,97.42 174.55,98.06 v3(174.55,98.9) ; v22(177.64,96.94) 176.2,96.94 173.98,94.72 v22(173.19,94.72) ; 136.6,96.17 136.6,94.82 136.7,94.72 136.7,96.07 136.6,96.17 ; 136.6,96.17 135.34,97.42 132.46,97.42 v22(132.29,97.26) 132.29,97.12 132.91,96.51 132.97,96.51 134.21,95.27 ; v22(167.15,99.35) 167.82,99.35 167.91,99.44 169.81,99.44 169.94,99.32 v22(170.74,99.32) ; 148.59,99.61 147.36,100.84 140.65,100.84 v2(140.22,100.41) 139.83,100.02 ; 148.59,99.61 v2(148.59,99.61) ; 52.6,136.86 52.26,136.51 51.26,136.51 50.52,135.77 50.52,134.87 51.21,134.18 v2(51.21,134.23)
  IN3 w0.203: 59.42,133.38 59.54,133.26 59.54,132.49 59.42,132.37 v2(59.42,131.75) 59.42,131.74 59.42,129.93 60,129.35 v2(60,128.77) ; 126.97,129.56 128.6,129.56 130.97,127.18 130.97,126.73 130.09,125.84 130.09,122.1 128.27,120.28 128.27,116.82 128.85,116.23 128.85,115.51 129.18,115.18 129.49,115.18 129.62,115.05 129.63,115.05 130.1,114.58 130.1,112.49 129.16,111.55 129.16,109.24 128.59,108.66 128.59,107.95 128.13,107.5 121.22,107.5 120.19,106.47 111.6,106.47 110.35,105.22 v2(110.21,105.22) ; v3(19.08,52.42) 18.87,52.42 18.5,52.05 18.5,45.63 18.82,45.32 19.82,45.32 ; 21.84,34.08 21.84,35.42 25.04,38.62 v2(25.04,39.84) ; 75.99,128.29 v22(76.61,128.29) v22(77.69,129.36) v22(78.64,130.32) v22(79.35,131.03) v22(80.52,132.2) v22(81.93,133.61) v22(82.67,134.34) v22(83.74,135.42) 84.1,135.78 v22(85.38,135.78) v22(87.92,135.78) 89.01,135.78 v22(89.29,135.5) v22(90.23,134.56) v22(91.33,133.46) 91.63,133.17 v2(91.63,132.24) ; v13(102.41,128.49) 102.93,128.49 v22(103.5,129.06) v22(103.5,130.08) v22(103.5,131.45) v22(103.5,132.37) v22(103.5,133.56) 103.5,134.2 v22(103.01,134.7) v22(102.41,135.3) 102.11,135.6 101.12,135.6 v7(101.09,135.58) 100.8,135.58 100.48,135.25 v22(100.48,134.96) 100.43,134.91 100.43,133.57 v22(100.48,133.52) ; v22(74.44,139.3) 74.44,139.3 74.4,139.3 ; 74.4,139.3 71.45,142.25 64.51,142.25 63.46,141.2 v2(63.46,140.88) 62.2,139.62 62.2,138.29 59.46,135.55 59.46,135.46 v2(59.45,135.45) ; 74.4,139.3 75.58,138.12 ; 131.42,106.37 132.56,107.51 132.56,110.96 132.41,111.11 v2(132.41,115.02) 132.41,115.59 131.76,116.23 131.76,120.17 132.97,121.37 132.97,125.08 133.18,125.3 133.18,128.04 129.44,131.79 125.67,131.79 124.04,133.42 121.08,133.42 119.7,132.03 119.7,131.49 v2(119.41,131.19) ; v13(101.56,127.41) 100.94,128.03 v22(100.94,128.06) v22(100.94,129.2) v22(100.94,130.32) v22(100.94,131.67) v22(100.94,132.61)
  IN3 w0.254: v22(188.09,100.71) 188.09,100.9 189.79,102.61 v22(190.43,102.61) ; v22(191.13,101.91) v22(190.43,102.61) ; v22(190.43,102.61) 190.43,103.23 191.02,103.81 192.12,103.81 192.65,103.29 v22(192.65,103.02) ; v2(214.05,113.63) 215.01,112.66 215.01,106.37 212.92,104.27 ; 177.43,92.17 177.36,92.09 v23(125.61,92.09) ; v2(56.39,137.4) 56.18,137.2 56.18,136.03 56.74,135.47 56.74,134.18 v2(56.75,134.17) 56.74,134.17 56.74,133.75 55.97,132.98 v2(55.91,132.98) ; 21.84,34.08 v22(21.89,34.03) ; 208.81,103.25 209.98,103.25 211.18,104.45
  IN3 w0.305: v2(17.96,19.73) 16.69,18.46 9.44,18.46 9.11,18.79 ; v22(167.15,99.35) 166.61,98.81 v22(166.61,97.35) ; 20.07,88.75 20.07,103.24 ; 20.07,88.75 20.07,88.53 ; 20.07,88.75 21.3,88.75 21.45,88.6 ; v22(191.37,97.63) v2(191.37,98.86) 193.19,100.68 197.41,100.68 198.53,101.79 201.43,101.79 201.99,102.35 v2(203.43,102.35) 205.8,102.35 207.43,103.98 207.43,104.55 207.64,104.76 208.6,104.76 208.81,104.55 208.81,102.8 204.75,98.74 198.35,98.74 197.24,97.63 v22(191.37,97.63) ; v22(191.37,97.63) 190.32,97.63 189.62,96.94 v22(177.64,96.94) ; 19.82,45.32 21.71,47.2 21.71,49.65 ; 21.45,88.6 22.09,87.96 22.85,87.96 24.28,86.53 24.31,86.53 26.68,84.15 26.7,84.15 27.67,83.17 v2(28.98,83.17) 30.31,83.17 32.47,81.02 33.35,81.02 v13(34.49,79.87) 35.53,79.87 v13(35.59,79.82) 36.63,79.82 v13(36.68,79.87) 37.77,79.87 v13(37.82,79.82) 38.75,80.75 43.54,80.75 44.2,80.09 44.2,77.8 42.52,76.11 35.09,76.11 34.66,76.55 v2(34.04,76.55) 31.93,76.55 28.5,79.97 26.14,79.97 20.07,86.04 ; 21.45,88.6 20.13,88.6 20.07,88.53 ; v3(54.3,145.71) 53.41,145.71 53.01,145.31 53.01,144.49 52.25,143.73 52.25,143 52.6,142.65 52.6,136.86 ; v3(54.3,145.71) 54.3,145.65 54.26,145.6 54.26,145.19 54.55,144.89 v7(54.76,144.89) 55.86,144.89 v2(56.13,144.62) 56.13,142.53 55.49,141.89 v7(54.76,141.89) 54.3,141.89 54.2,141.8 54.2,136.71 54.18,136.68 v7(54.18,135.39) 54.18,135.39 53.48,135.39 53.28,135.19 v2(53.11,135.19) 52.58,135.19 52.16,134.77 52.15,134.77 51.61,134.23 v2(51.21,134.23) ; v3(54.3,145.71) 54.3,146.27 54.43,146.39 v7(54.76,146.39) 56.19,146.39 57.73,144.85 v2(57.73,144.82) 57.78,144.77 57.78,141.39 56.18,139.79 56.18,137.61 v2(56.39,137.4) ; v22(166.61,97.35) 168.63,97.35 169.21,97.93 v2(170.74,97.93) v22(170.74,99.32) 170.77,99.35 174.1,99.35 v3(174.55,98.9) 174.73,98.9 175.13,99.3 v22(180.13,99.3) 180.85,99.3 181.25,99.71 181.25,99.83 181.79,100.37 184.95,100.37 v22(185.25,100.07) ; v22(166.61,97.35) 164.77,97.35 164,96.58 v2(159.99,96.58) v22(150.54,96.58) 149.91,95.95 141.38,95.95 140.55,96.78 v22(139.61,96.78) ; 221.03,112.92 220.98,112.87 220.66,112.87 219.54,111.75 v13(216.59,111.75) ; 201.53,103.62 203.38,103.62 ; 206.33,142.43 207.09,142.43 207.58,141.94 207.58,140.23 208.73,139.07 209.05,138.75 209.05,133.52 208.88,133.35 v2(208.88,133.25) 208.88,131.74 209.17,131.45 209.18,131.45 v2(210.54,130.09) 210.54,126.34 210.13,125.93 v2(210.13,123.82) 210.06,123.75 210.06,116.19 211.04,115.22 212.46,115.22 v2(214.05,113.63) ; 20.07,88.53 20.07,86.04 ; 20.07,86.04 20.07,53.41 v3(19.08,52.42) ; 221.68,107.47 220.55,106.34 ; 220.55,106.34 220.57,106.34 ; 220.55,106.34 219.06,106.34 v2(219,106.28) 218.94,106.34 218.44,106.34 ; 199.16,94.66 v2(178.51,94.66) 178.51,93.3 178.52,93.29 178.52,93.23 v2(178.22,92.93) ; 203.3,103.96 201.03,103.96 200.69,103.62 197.83,103.62 197.23,103.02 v22(192.65,103.02) 192.24,103.02 191.92,102.71 v22(191.13,101.91) 189.11,99.89 v22(188.64,99.89) 188.64,99.53 188.31,99.2 183.62,99.2 v2(183.11,99.71) ; 21.64,38.06 21.23,37.66 21.23,36.44 20.65,35.86 20.65,34.56 19.19,33.1 19.19,32.55 19.09,32.45 ; 218.44,106.34 218.44,104.02 219.61,102.86 220.11,102.86 220.54,102.42 220.54,98.5 v2(220.16,98.12) 219.45,98.12 218.55,99.02 218.55,99.84 217.63,100.76 217.63,101.36 215.58,103.41 v2(215.58,103.56) 215.58,106.34 215.58,106.34 218.44,106.34 ; v2(119.68,100.22) 119.71,100.24 121.34,100.24 v22(121.6,99.98) 121.89,99.69 139.5,99.69 139.83,100.02 ; 211.18,104.45 213.17,106.44 213.17,112.45 212.78,112.84 210.94,112.84 208.13,115.65 v2(208.13,120.87) v2(208.13,127.27) 206.98,128.41 206.98,132.03 v2(207.06,132.11) ; v22(130.8,102.11) 130.74,102.11 130.74,102.11 127.48,102.11 ; v22(138.75,102.04) 148.58,102.04 v22(148.83,101.79) 148.84,101.79 149.65,100.98 v2(149.65,100.86) 152.17,98.34 v2(153.21,98.34) v2(158.09,98.34) 161.69,98.34 v2(163.65,100.3) 164.47,101.12 180.02,101.12 180.3,101.4 187.15,101.4 190.89,105.15 191.93,105.15 193.13,106.34 197.07,106.34 ; v22(120.22,98.35) 133.64,98.35 134.57,97.42 ; v22(173.19,94.72) 134.76,94.72 134.21,95.27
  GND3 w0.102: 70.31,115.89 71.83,115.89
  GND3 w0.203: v15(202.96,145.71) v2(203.33,145.71)
  GND3 w0.254: v12(90.89,131.79) 91.34,132.24 v2(91.63,132.24) ; v15(202.96,141.71) 202.59,141.71 v2(202.59,141.71)
  GND3 w0.508: 197.21,115.08 197.21,115.43 197.31,115.53
  IN4 w0.06: v12(77.97,119.55) 77.76,119.55 77.52,119.31 77.52,119.15 77.68,118.99 77.89,118.99 v12(77.97,118.91) ; 58.78,128.7 58.78,128.46 60.03,127.21 v8(61.52,127.21) ; v12(62.11,114.72) v12(62.61,114.72)
  IN4 w0.089: v8(58.62,130.57) 58.78,130.42 58.78,130.3 58.78,128.7 58.78,128.7
  IN4 w0.102: v12(77.97,118.91) v12(77.97,118.26) v12(77.97,117.62) v12(77.97,116.97) ; v4(67.02,120.55) v4(67.34,120.79) ; v4(67.02,120.55) v4(66.7,120.79) ; v4(67.02,120.55) v12(67.02,121.04) ; v4(67.34,120.79) v12(67.02,121.04) ; v4(67.34,120.79) v4(67.67,121.04) v4(68.31,121.04) v4(68.95,121.04) v5(70.24,121.04) v5(71.53,121.04) v5(72.17,121.04) v5(72.82,121.04) v5(74.11,121.04) v5(75.4,121.04) ; v4(66.7,120.79) 66.61,120.79 66.52,120.88 66.05,120.88 65.96,120.79 65.41,120.79 v12(65.41,120.8) ; v4(66.7,120.79) v12(67.02,121.04) ; v12(77.97,120.2) v12(77.48,120.2) v12(76.99,120.2) v12(76.74,120.52) ; v12(77.97,120.2) v12(77.97,119.55) ; v12(77.97,120.2) v12(78.47,120.2) ; v12(76.74,120.52) v12(76.04,120.55) ; v12(76.74,120.52) v12(76.68,121.53) v5(76.36,121.29) v12(76.04,121.04) v12(76.04,120.55) ; v12(67.02,121.04) v12(67.02,121.53) v12(66.38,121.53) v5(65.73,121.53) UC1.BD20 v12(65.73,122.03) ; v12(76.04,120.55) v5(76.49,120.2) v4(76.74,119.87) ; v12(75.4,121.53) v12(74.11,121.53) v12(72.82,121.53) v12(71.53,121.53) v12(70.24,121.53) v12(68.95,121.53)
  IN4 w0.127: v12(68.63,121.78) v12(68.95,121.53) ; v12(68.63,121.78) 68.39,121.53 v4(67.67,121.53) ; v12(68.63,121.78) v12(68.63,122.27) ; 214.35,112.08 214.7,111.74 214.7,111.67 214.72,111.64 214.72,111.59 214.76,111.56 214.76,110.56 214.43,110.23 ; v12(68.63,122.27) v12(69.28,122.27) v12(69.92,122.27) v12(70.56,122.27) ; v12(68.63,122.27) v12(68.63,122.77) v12(68.31,123.01) v12(67.67,123.01) v12(67.02,123.01) ; v12(65.73,122.52) v12(65.73,123.01) ; v12(65.73,122.52) 65.01,122.52 64.77,122.76 v12(64.77,122.77) v12(64.12,122.77) ; v12(65.73,122.52) v12(65.73,122.03) 65.01,122.03 v4(64.77,121.78)
  IN4 w0.152: v12(79.23,113.43) v5(78.71,113.43) v12(78.22,113.43) v5(77.73,113.43) v12(77.23,113.43) v12(76.99,113.11) v5(76.74,112.79) ; v12(63.59,113.44) v4(63.59,114.08) ; v12(62.61,114.72) v12(63.1,114.72) v4(63.59,114.72) ; v4(76.74,119.87) v12(76.74,119.23) v4(76.74,118.58) v5(76.49,118.26) v12(76.74,117.94) v15(76.74,117.3)
  IN4 w0.203: v12(76.99,115.04) v5(77.48,115.04) v12(77.97,115.04) v4(78.47,115.04) v12(78.96,115.04) ; v8(75.22,113.99) v12(74.97,113.99) ; v15(59.11,135.78) 59.09,135.79 59.09,136.01 60.53,137.44 60.53,138.06 61.24,138.78 v12(61.78,138.78) v12(62.28,138.78) v12(62.78,139.28) v12(62.78,139.78) ; 78.86,130.27 79.02,130.27 v15(81.09,132.34) 83.44,134.69 88.04,134.69 90.43,132.3 91.46,132.3 ; v12(74.97,117.34) v8(75.22,117.34) ; v12(77.23,116.65) v4(78.22,116.65) ; v4(78.22,116.65) v12(77.97,116.97) ; v4(78.22,116.65) v12(78.71,116.65) v5(79.23,116.65) ; v12(61.87,119.55) v12(62.36,119.55) ; v8(75.22,112.87) v12(74.97,112.87) ; v8(75.22,116.22) v12(74.97,116.22) ; v8(75.21,115.11) v12(74.97,115.11) ; v8(74.22,116.22) v12(73.98,116.22) ; v12(73.98,117.34) v8(74.22,117.34) ; v4(65.06,113.43) v4(65.06,112.87) ; v12(74.97,119.58) v12(75.47,119.58)
  IN4 w0.254: v8(58.62,130.57) 58.62,131.84 v8(58.62,131.84) 58.62,131.85 58.62,133.09 v15(58.6,133.11) 58.62,133.14 58.62,134.82 59.11,135.3 v15(59.11,135.78) ; v8(210.94,140.77) 211.49,140.77 213.66,138.6 213.66,138.14 213.66,132.6 214.25,132.01 214.25,132.01 214.63,131.63 214.63,118.24 214.25,117.86 ; 214.35,112.08 212.93,113.51 212.93,114.68 212.93,115.95 212.67,116.21 212.67,118.96 213.05,119.34 213.05,130.83 211.84,132.04 211.84,138.2 v8(210.52,139.52) ; v12(64.57,119.02) 64.03,119.55 v12(63.35,119.55) v12(62.85,119.55) v12(62.36,119.55) ; 94.21,119.5 96.09,121.37 96.09,129 93.79,131.29 v12(92.89,131.29) ; 92.09,119.05 90.55,117.52 85.62,117.52 84.86,116.75 84.1,116.75 v15(84.09,116.77) ; 214.43,110.23 215.34,109.31 216.23,109.31 216.59,109.67 v13(216.59,111.75) ; v5(79.23,116.65) 79.78,116.58 81.92,116.58 v15(82.12,116.77)
  IN4 w0.305: v12(92.89,131.29) 92.89,131.61 92.71,131.79 v12(92.39,131.79) ; v4(63.59,114.72) v12(64.07,114.55) ; v12(64.07,114.55) v4(63.59,114.08) ; v12(64.07,114.55) v5(64.57,114.55)
  IN4 w0.356: v12(67.02,112.42) v4(67.05,112.87) v12(67.05,113.43) v4(67.05,113.99) v12(67.05,114.55) v4(67.05,115.1)
  IN4 w0.381: v5(64.57,118.46) v12(64.57,119.02) v5(65.06,119.02) ; v5(65.06,119.02) v5(65.56,119.02) v5(66.06,119.02) v12(66.06,118.46) ; v5(65.06,119.02) v5(65.06,119.58)
  IN4 w0.508: v4(11.06,144.24) 11.06,145.46 10.56,145.96 JHP1.7
  BOTTOM w0.06: UC1.A14 UC1.C14 v12(63.8,110.44) UC1.G14 v12(63.8,111.43) v12(64.12,111.68) v12(64.77,111.68) v12(65.41,111.68) UC1.K21 66.7,111.68 v12(66.7,111.68) 67.99,111.68 ; UC1.AF13 UC1.AD13 UC1.AB13 v4(63.59,114.72) ; v12(69.6,123.01) v12(70.24,123.01) v12(70.89,123.01) v12(71.53,123.01) v12(72.17,123.01) v12(72.82,123.01) v12(73.46,123.01) v12(74.11,123.01) ; UC1.BB48 v12(75.4,121.53) ; UC1.E50 v12(74.75,110.44) UC1.E46 UC1.E44 UC1.E42 v12(72.17,110.44) ; 67.99,111.68 UC1.K27 ; 67.99,111.68 68.63,111.68 UC1.K29 UC1.K31 UC1.K33 ; v4(63.59,114.08) v12(63.59,113.44) ; UC1.K33 69.92,111.68 ; UC1.K33 69.92,111.68 ; v12(67.82,136.77) U33.E11 ; v12(68.63,122.27) v12(69.28,122.27) v12(69.92,122.27) v12(70.56,122.27) ; UC1.E52 UC1.E54 ; UC1.BL29 v12(69.28,123.75) v12(69.92,123.75) v12(70.56,123.75) ; 69.92,111.68 70.56,111.68 UC1.K35 v12(71.21,111.68) v12(71.85,111.68) v12(72.5,111.68) UC1.K43 UC1.K45 UC1.K47 UC1.K49 UC1.K51 ; v5(75.4,121.04) UC1.AY48 v5(74.11,121.04) UC1.AY44 v5(72.82,121.04) v5(72.17,121.04) v5(71.53,121.04) UC1.AY36 v5(70.24,121.04) UC1.AY32 v4(68.95,121.04) v4(68.31,121.04) v4(67.67,121.04) ; v12(72.17,110.44) UC1.E38 UC1.E36 UC1.E34 v12(69.6,110.44) v12(68.95,110.44) v12(68.31,110.44) v12(67.67,110.44) v12(67.02,110.44) v12(66.38,110.44) v12(65.73,110.44) v12(65.09,110.44) v12(64.44,110.44) ; v12(72.17,110.44) v12(72.17,109.95) ; v12(68.95,121.53) UC1.BB32 v12(70.24,121.53) UC1.BB36 v12(71.53,121.53) UC1.BB40 v12(72.82,121.53) UC1.BB44 v12(74.11,121.53) ; v12(63.16,124) UC1.BM14 UC1.BM16 UC1.BM18 UC1.BM20 ; v12(64.12,122.77) v12(64.77,122.77) ; v12(74.75,123.01) v12(75.4,123.01) ; UC1.L59 77.66,111.82 UC1.L57 77.51,111.68 UC1.K55 UC1.K53 ; v12(65.73,123.01) v12(66.38,123.01) v12(67.02,123.01) v12(67.67,123.01) v12(68.31,123.01) ; UC1.BB28 v4(67.67,121.53) v12(67.02,121.53) v12(66.38,121.53) v5(65.73,121.53) ; v12(77.33,123.01) v12(76.68,123.01) UC1.BH52 ; v12(63.8,111.92) UC1.L14
  BOTTOM w0.102: v12(78.8,110.72) v15(78.8,110.29) ; 68.63,111.68 UC1.K29 ; UC1.BP46 UC1.BP44 ; v12(78.01,110.56) 78,110.57 v12(77.43,110.57) ; v15(78.71,111.5) 78.71,111.57 UC1.L61 UC1.L59 ; 67.34,111.68 UC1.K25
  BOTTOM w0.127: v12(75.96,117.34) 76,117.3 UC1.AH54 ; v15(51.43,102.05) 51.56,102.05 51.86,101.75 U47.2 ; v15(112.34,107.08) 112.17,107.25 v16(112.17,108.31)
  BOTTOM w0.152: v12(79.23,113.43) v5(78.71,113.43) v12(78.22,113.43) v5(77.73,113.43) v12(77.23,113.43) v12(76.99,113.11) v5(76.74,112.79) ; v12(78.96,115.04) v4(78.47,115.04) v12(77.97,115.04) v5(77.48,115.04) v12(76.99,115.04) ; UC1.BL8 v12(61.9,124.09) ; v12(67.02,112.42) 66.89,112.42 66.83,112.47 66.44,112.47 UC1.N22 66.31,112.49 65.8,112.49 v12(65.73,112.42) 65.64,112.51 65.19,112.51 UC1.N18 65.05,112.46 64.49,112.46 UC1.N16 64.4,112.46 63.85,112.46 UC1.N14 v12(63.8,111.92) ; UC1.L14 v12(64.12,111.68)
  BOTTOM w0.178: v5(65.73,121.53) UC1.BD20 v12(65.73,122.03) v12(65.73,122.52) v12(65.73,123.01) ; v12(77.33,123.01) v12(77.33,122.52) v12(77.33,122.03)
  BOTTOM w0.203: v12(76.99,120.2) 76.99,120.12 v4(76.74,119.87) ; v12(76.99,120.2) 76.99,120.27 v12(76.74,120.52) 76.49,120.27 v5(76.49,120.2) 76.39,120.2 v12(76.04,120.55) v12(76.04,121.04) 76.11,121.04 v5(76.36,121.29) ; v12(76.99,120.2) v12(77.48,120.2) v12(77.97,120.2) v12(78.47,120.2) UC1.AU63 ; v7(100.86,133.09) 100.94,133.18 JCAM3.1 ; v12(63.48,122.77) v12(63.48,122.27) ; v12(140.06,115.36) 140.14,115.36 140.35,115.14 PU500.22 ; UC1.AP64 v12(79.88,119.23) ; v12(74.11,123.01) 74.35,123.26 v12(74.43,123.26) ; JIO4.58 v7(129.52,94.65) ; v5(76.36,121.29) 76.12,121.53 UC1.BB52 ; v5(76.36,121.29) 76.6,121.53 v12(76.68,121.53) ; v12(64.07,114.55) 64.57,114.55 v5(64.57,114.55) ; v12(64.07,114.55) v4(63.59,114.08) ; v12(64.07,114.55) 63.89,114.72 v4(63.59,114.72) 63.1,114.72 v12(63.1,114.72) v12(62.61,114.72) v12(62.11,114.72) 62.11,114.72 UC1.Y5 UC1.Y3 UC1.Y1 ; UC1.J3 UC1.J5 61.62,111.5 v12(62.11,111.5) UC1.J9 ; UC1.AE4 UC1.AE2 60.4,116.33 v12(60.38,116.35) ; v12(74.43,121.78) 74.68,121.53 UC1.BB48 ; v12(74.43,121.78) 74.18,121.53 v12(74.11,121.53) ; v12(74.43,121.78) v12(74.43,122.27) ; JCAM3.7 101.09,135.58 v7(101.09,135.58) ; v12(62.85,116.33) v12(62.36,116.33) ; v12(64.57,117.9) v4(64.07,117.9) v12(63.59,117.95) 63.59,117.94 v12(63.1,117.94) 62.61,117.94 ; UC1.AW21 65.98,120.79 UC1.AV20 65.49,120.8 v12(65.41,120.8) ; v5(79.23,116.65) 79.22,116.66 79.09,116.66 79.09,116.66 78.83,116.66 78.82,116.66 78.72,116.66 v12(78.71,116.65) 78.6,116.65 78.6,116.65 78.33,116.65 78.33,116.65 78.32,116.65 v4(78.22,116.65) 78.22,116.75 78,116.97 UC1.AG59 ; v12(62.36,122.77) UC1.BG6 UC1.BG4 UC1.BG2 ; v4(67.34,120.79) 67.59,121.04 v4(67.67,121.04) v4(67.67,121.53) ; v4(67.34,120.79) 67.1,120.55 v4(67.02,120.55) 66.95,120.55 v4(66.7,120.79) 66.95,121.04 v12(67.02,121.04) 67.1,121.04 v4(67.34,120.79) ; v12(68.63,121.78) 68.56,121.78 UC1.BB28 ; v12(68.63,121.78) 68.88,121.53 v12(68.95,121.53) ; v12(68.63,121.78) v12(68.63,122.27) v12(68.63,122.77) 68.56,122.77 v12(68.31,123.01) 68.56,123.26 v12(68.63,123.26) UC1.BL29 UC1.BN29 ; v12(76.74,116.65) v12(77.23,116.65) 77.73,116.65 UC1.AF58 77.73,116.73 UC1.AG59 ; JIO1.32 217.38,114.08 217.22,113.92 v15(217.22,113.68) JIO1.34 ; JIO1.40 v15(217.17,112.48) ; UC1.AG59 v12(77.97,116.97) ; UC1.R2 UC1.R4 v12(61.87,113.11) v12(62.36,113.11) v12(62.85,113.11) ; UC1.BA1 UC1.BA3 UC1.BA5 UC1.BA7 v12(62.61,121.16) v12(63.1,121.16) ; 62.61,117.94 UC1.AK9 62.61,117.94 ; 62.61,117.94 v12(62.11,117.94) 62.11,117.94 UC1.AK5 UC1.AK3 UC1.AK1 60.61,117.92 60.3,117.61 v12(59.88,117.61) ; UC1.BP60 78.32,124.81 v12(78.35,124.84) ; v12(85.89,124.29) U35.B4 U35.C4 v12(86.39,125.29) ; v15(120.94,94.66) 120.94,94.72 121.12,94.9 JIO4.100 ; U47.11 v12(55.46,102.07) ; JCAM3.4 101.39,134.38 101.36,134.41 100.85,134.41 v7(100.8,134.46) ; v15(217.05,109.81) 217.2,109.81 217.47,110.08 JIO1.52 ; UC1.BN29 UC1.BP28 v12(68.64,124.79) UC1.BP30 UC1.BN29 ; UC1.BL47 v12(74.43,123.26) ; v12(74.43,123.26) v12(74.75,123.01) ; v12(66.06,113.43) v12(66.55,113.43) v12(67.05,113.43) ; v5(76.49,118.26) UC1.AK54 ; v5(76.49,118.26) v4(76.74,118.58) ; v5(76.49,118.26) v12(75.96,118.46) ; UC1.BP44 v12(73.46,124.83) ; v12(64.45,121.04) 64.52,121.04 UC1.AW17 64.52,120.55 UC1.AV16 ; JIO1.45 v15(221.6,111.28) ; JIO1.23 v15(221.56,115.68) ; v12(64.57,119.02) UC1.AR15 64.05,119.55 v12(63.35,119.55) v12(62.85,119.55) v12(62.36,119.55) v12(61.87,119.55) UC1.AR4 UC1.AR2 ; U35.A2 v12(84.89,124.29) ; v12(65.73,123.01) UC1.BK20 UC1.BM20 ; JIO4.70 v7(127.12,94.63) ; UC1.N18 v4(65.06,112.87) v4(65.06,113.43) ; JIO1.42 v15(217.21,112.08) ; UC1.BP52 76.04,124.93 v12(76.15,125.04) ; v12(67.05,113.43) v4(67.05,113.99) v12(67.05,114.55) v4(67.05,115.1) ; v12(67.05,113.43) v4(67.05,112.87) 67.02,112.85 v12(67.02,112.42) 67.15,112.42 67.21,112.48 67.22,112.48 67.25,112.51 67.57,112.51 UC1.N26 ; v12(60.29,124.4) 60.31,124.4 60.43,124.52 UC1.BP1 ; UC1.BP36 70.95,124.58 71.46,124.58 UC1.BP38 UC1.BM38 v12(71.53,123.5) v12(71.53,123.01) v12(71.53,122.52) v12(71.53,122.03) v12(71.53,121.53) ; v12(76.97,125.02) 76.68,124.74 UC1.BP54 ; v15(58.27,102.43) 58.5,102.43 58.66,102.27 U47.19 ; U35.A4 v12(85.89,123.79) ; v12(77.73,121.16) 77.97,121.41 v12(77.97,121.48) ; UC1.BK56 v12(77.33,123.01) ; UC1.AM64 79.62,118.58 v12(79.62,118.59) ; JIO4.52 v7(130.72,94.67) ; JIO1.30 v15(217.24,114.48) ; JIO1.41 v15(221.52,112.08) ; JIO4.76 v7(125.92,94.68) ; JIO4.88 v7(123.52,95.87) ; JIO4.64 v7(128.32,94.62) ; v12(75.96,119.58) 76.31,119.23 v12(76.74,119.23) ; JIO1.44 v15(217.22,111.68) ; JIO1.29 v15(221.57,114.48) ; JIO4.94 v15(122.32,94.65) ; JIO1.35 v15(221.57,113.28) ; JIO1.38 v15(217.19,112.88) ; v15(208.47,97.58) 208.65,97.76 JNFC1.5 ; JIO1.36 v15(217.22,113.28) ; v12(73.98,112.87) 73.49,112.87 UC1.R44 v12(72.99,112.87) ; JIO1.49 v15(221.52,110.48) ; JIO4.82 v7(124.72,95.86)
  BOTTOM w0.229: v12(73.98,112.87) v5(74.48,112.87) v12(74.97,112.87)
  BOTTOM w0.254: v15(68.37,127.83) 68.45,127.75 CC94.2 ; v15(48.41,128.54) 48.4,128.53 48.4,128.2 RH67.2 ; JNGFF1.25 202.05,140.21 201.92,140.35 201.5,140.35 v13(201.38,140.47) ; v15(201.45,138.63) 201.64,138.63 201.72,138.71 JNGFF1.31 ; v12(66.11,124.91) 66.38,124.64 UC1.BP22 ; v12(90.52,98.26) 90.54,98.23 JXDP1.50 ; R468.2 59.49,95.14 59.55,95.2 v12(61.01,95.2) ; C271.2 70.68,128.74 v15(71.03,129.09) ; v12(67.82,136.77) 67.78,136.8 U33.E12 ; U33.A14 70.63,138.28 v12(70.79,138.45) ; UC1.BP62 78.78,124.94 v12(78.68,125.03) ; U33.E12 v12(67.28,137.28) U33.F13 ; U33.E12 U33.D12 ; v12(61.9,110.29) UC1.D8 62.74,110.29 v12(62.83,110.2) ; v15(72.47,127.75) 72.44,127.73 CC99.2 ; v12(52.83,115.84) CH13.2 ; v15(66.79,128.25) 67.09,128.56 C268.2 ; v15(67.33,127.68) 67.03,127.38 CC96.2 ; v15(25.04,105.83) 24.82,105.83 24.52,105.54 JNGFF2.75 ; v12(65.73,105.02) 65.73,104.83 CC119.2 ; U34.A3 193.82,138.1 v12(193.67,138.24) ; v12(69.78,132.78) U33.A2 ; v15(58.78,116.6) 58.71,116.66 CC110.2 ; v12(61.78,137.28) U33.U13 ; U35.H5 v12(86.89,127.79) ; U34.A2 v12(194.32,138.24) ; UH3.3 47.72,126.42 47.56,126.26 RH73.1 ; v4(64.57,116.78) UC1.AF15 63.72,116.78 UC1.AF13 ; CC95.2 70.17,127.38 v15(69.87,127.68) ; UC1.AB13 v4(64.07,115.66) UC1.AD13 ; CC109.2 57.66,117.26 57.61,117.21 57.61,117.19 v15(57.58,117.19) ; v15(25.02,106.24) 25.27,106.24 25.52,105.99 JNGFF2.71 ; JNGFF2.15 39.52,103.93 v15(39.76,103.7) ; v12(86.89,126.29) U35.E5 U35.E6 U35.E7 v12(88.39,125.79) ; v15(63.32,99.9) R447.2 ; v12(84.89,124.79) U35.C2 ; UC1.R50 v12(74.97,112.87) ; R359.2 v15(190.07,128.69) ; U34.N3 v15(193.82,131.03)
  BOTTOM w0.279: v12(72.99,119.58) v5(74.48,119.58) v12(74.97,119.58) v12(75.47,119.58) ; v12(72.99,118.46) v5(74.48,118.46) v12(74.97,118.46) UC1.AL50
  BOTTOM w0.305: C256.2 v15(81.09,132.34) ; v13(197.45,148) 197.13,147.68 JDEG1.10 ; v15(204.09,147.73) 204.09,147.32 203.98,147.21 JNGFF1.5 ; v15(68.94,129.09) 68.7,128.85 R365.2 ; JXDP1.8 77.94,96.46 v15(77.81,96.59) ; JXDP1.38 86.94,96.59 86.64,96.89 v15(86.64,98.21) ; v5(70.02,115.66) v12(70.02,115.11) v5(70.02,114.55) v12(70.02,113.99) v5(70.02,113.43) UC1.T33 v12(70.02,112.87) ; v15(79.69,96.76) 79.74,96.71 JXDP1.14 ; JEDP1.44 v15(101.13,97.06)
  BOTTOM w0.356: v12(68.04,115.66) v5(68.04,115.1) v10(68.04,114.55) v5(68.04,113.99) ; UC1.AA44 v12(72.99,115.11)
  BOTTOM w0.381: UH4.3 41.26,110.29 41.43,110.46 41.43,111.03 v15(41.12,111.33) ; v5(74.48,115.11) UC1.AA44 ; DA6.2 v15(11.79,141.47) ; v15(81.69,105.13) 81.69,104.82 82.04,104.46 RC83.1 ; PQ109.1 203.27,119.31 v15(203.36,119.22)
  BOTTOM w0.406: v13(201.57,149.84) 200.74,149 CLIP3.1 ; JEDP1.47 v15(100.13,96.04) ; v13(198.15,150.31) 198.13,150.29 JDEG1.12
  BOTTOM w0.508: JUFC.40 125.61,132.86 v15(125.37,132.63) ; PC612.2 194.08,113.02 194.51,112.59 PR611.2 ; PC714.2 129.23,117.54 PR718.2 ; C231.2 v15(196.67,142.17) ; v15(167.21,106.06) 168.35,106.06 169.02,105.39 PR1510.2 ; C305.2 173.68,104.64 v15(173.89,104.43) ; PQ513.3 138.05,106.54 PR543.2 ; R500.2 v15(206.41,110.42)
  vias: v1(12.39,140.67) v1(12.56,127.14) v1(13.58,137.17) v1(13.78,133.75) v1(14.98,139.79) v1(16.04,123.01) v1(16.49,128.43) v1(18.89,135.31) v1(20.65,137.71) v1(21.34,59.76) v1(21.34,58.18) v1(21.79,31.44) v1(21.79,28.87) v1(22.89,31.13) v1(23.65,34.9) v1(23.98,28.79) v1(24.33,30.98) v1(24.51,34.9) v1(24.63,107.27) v1(24.79,77.36) v1(25.17,77.59) v1(25.41,103.75) v1(25.48,34.88) v1(26.08,139.73) v1(26.34,34.88) v1(27.34,57.51) v1(27.33,34.88) v1(28.19,34.88) v1(29.06,136.13) v1(29.26,142.76) v1(29.18,34.88) v1(29.3,95.76) v1(29.97,34.88) v1(31.74,98.1) v1(33.01,130.39) v1(34.26,38.29) v1(34.69,37.66) v1(34.86,148.19) v1(35.52,39.35) v1(35.69,40.43) v1(35.69,39.92) v1(35.84,39.35) v1(36.19,41.17) v1(36.19,40.67) v1(36.19,39.16) v1(36.69,40.67) v1(36.69,40.17) v1(36.69,39.66) v1(36.69,39.16) v1(37.19,40.67) v1(37.19,40.17) v1(37.19,39.66) v1(37.19,39.16) v1(37.61,57.19) v1(37.69,40.67) v1(37.69,40.17) v1(37.69,39.66) v1(37.69,39.16) v1(38.19,40.17) v1(38.19,39.16) v1(38.35,150.41) v1(38.82,39.22) v1(39.27,57.17) v1(39.19,39.16) v1(40.84,57.14) v1(41.46,151.53) v1(115.28,126.66) v1(184.46,133.84) v1(184.63,144.52) v1(186.84,142.36) v1(189.26,145.1) v1(192.56,148.81) v1(197.71,149.16) v1(202.8,149.67) v1(206.02,148.66) v1(214.59,95.05) v1(218.41,94.73) v1(220.41,102.28) v2(3.65,52.18) v2(3.77,48.55) v2(15.98,39.13) v2(18.25,40.28) v2(18.29,41.21) v2(19.87,39.82) v2(20.47,153.67) v2(23.77,55.92) v2(24.51,119.52) v2(24.54,118.94) v2(24.64,120.03) v2(24.69,118.56) v2(24.94,118.89) v2(25.07,120.06) v2(25.15,118.53) v2(25.09,102.48) v2(25.12,55.64) v2(25.35,118.89) v2(25.48,120.06) v2(25.48,58.8) v2(25.55,118.53) v2(25.5,77.42) v2(25.67,71.97) v2(25.76,118.89) v2(25.78,76.34) v2(25.7,74.56) v2(25.7,73.98) v2(25.69,73.43) v2(25.88,120.06) v2(25.93,75.58) v2(25.98,118.51) v2(26.16,118.89) v2(26.24,54.05) v2(26.19,39.73) v2(26.29,120.03) v2(26.34,119.5) v2(26.31,108.75) v2(26.29,53.13) v2(26.29,52.49) v2(26.29,51.86) v2(26.29,51.22) v2(26.29,50.59) v2(26.52,33.25) v2(26.94,102.3) v2(27,87.73) v2(27.09,104.85) v2(27.28,106.38) v2(27.42,125.76) v2(27.47,57.99) v2(27.56,53.13) v2(27.56,52.49) v2(27.56,51.86) v2(27.56,51.22) v2(27.56,50.59) v2(27.74,41.92) v2(28.07,57.99) v2(28.35,28.95) v2(28.48,123.52) v2(28.79,68.7) v2(28.83,53.13) v2(28.83,52.49) v2(28.83,51.86) v2(28.83,51.22) v2(28.83,50.59) v2(28.99,127.22) v2(29.58,58.49) v2(29.59,36.08) v2(29.77,53.23) v2(30.06,46.31) v2(30.16,133.29) v2(30.17,42.31) v2(30.23,120.48) v2(30.35,125.69) v2(30.39,117.25) v2(30.71,104) v2(31.03,45.07) v2(31.24,65.52) v2(31.78,119.16) v2(31.78,103.62) v2(31.9,134.15) v2(31.97,116.04) v2(31.9,41.25) v2(32.16,51.75) v2(32.33,52.26) v2(32.49,127.23) v2(32.51,123.29) v2(32.77,53.41) v2(32.79,103.97) v2(32.95,135.57) v2(33,117.25) v2(33.48,62.41) v2(33.55,60.54) v2(33.76,82.49) v2(33.93,125.6) v2(34.24,106.03) v2(34.46,120.38) v2(34.7,38.56) v2(35.12,69) v2(35.19,38.97) v2(35.32,134.13) v2(35.37,127.25) v2(35.41,100.12) v2(35.68,36.67) v2(35.62,32.9) v2(36.13,123.44) v2(36.55,63.99) v2(36.65,105.18) v2(36.65,59.38) v2(36.83,136.2) v2(36.81,132.86) v2(36.9,117.22) v2(37.09,119.25) v2(37.26,134.15) v2(37.6,125.71) v2(37.62,41.13) v2(37.76,62.53) v2(37.76,61.52) v2(37.76,60.5) v2(37.81,138.08) v2(38.28,111.78) v2(38.46,127.23) v2(38.42,120.32) v2(38.63,135.2) v2(38.65,132.92) v2(38.65,62.53) v2(38.65,61.52) v2(38.83,123.36) v2(38.95,136.99) v2(39.39,116.97) v2(39.53,62.53) v2(39.53,61.52) v2(39.53,60.5) v2(39.62,39.33) v2(39.84,114.43) v2(39.86,112.51) v2(39.83,38.85) v2(40.35,138.16) v2(40.33,134.01) v2(40.46,136.2) v2(42.05,63.38) v2(42.07,51.28) v2(42.32,60.14) v2(42.42,57.07) v2(42.79,118.95) v2(42.91,23.79) v2(43.19,20.55) v2(45.08,112.16) v2(47.93,118.9) v2(51.61,94.6) v2(52.86,95.87) v2(52.91,94.2) v2(53.52,96.17) v2(53.78,143.7) v2(53.9,94.15) v2(54.37,132.92) v2(56.82,94.13) v2(56.84,93.59) v2(57.58,93.57) v2(57.8,137.5) v2(59.56,123.4) v2(60.12,96) v2(63.3,99.25) v2(64.63,100.52) v2(66.55,116.76) v2(67.05,118.44) v2(67.05,117.32) v2(67.05,114.23) v2(67.05,113.75) v2(67.82,104.87) v2(68.04,119.26) v2(68.04,118.14) v2(68.04,115.08) v2(68.04,114.23) v2(68.08,108.26) v2(69.03,119.25) v2(69.03,118.14) v2(69.03,117.01) v2(69.03,115.88) v2(69.03,114.78) v2(69.03,113.66) v2(69.51,105.21) v2(70.02,119.24) v2(70.02,118.77) v2(70.02,117.65) v2(70.02,116.83) v2(70.02,115.43) v2(70.02,114.31) v2(70.02,113.2) v2(71.01,119.26) v2(71.01,118.14) v2(71.01,116.86) v2(71.01,115.45) v2(71.01,114.32) v2(71.01,113.19) v2(72,119.26) v2(72,118.14) v2(72,116.9) v2(72,115.42) v2(72,114.3) v2(72,113.19) v2(72.03,105.87) v2(73.31,117.34) v2(73.31,116.22) v2(73.33,115.1) v2(73.42,119.58) v2(73.4,118.46) v2(73.65,113.99) v2(73.66,112.87) v2(74.33,106.34) v2(74.55,117.34) v2(74.6,119.58) v2(74.6,118.46) v2(74.64,116.22) v2(74.65,115.11) v2(74.64,113.99) v2(74.64,112.87) v2(74.98,105.02) v2(76.63,103.79) v2(77.59,113.43) v2(78.59,113.43) v2(79.97,113.47) v2(83.47,113.3) v2(93.91,124.58) v2(102.31,102.73) v2(109.31,99.94) v2(110.8,100.31) v2(111.84,100.33) v2(113.39,126.86) v2(122.1,101) v2(123.66,100.7) v2(124.58,103.94) v2(125.22,100.74) v2(126.74,100.72) v2(126.96,102.38) v2(127.5,104) v2(128.32,100.73) v2(129.57,101.08) v2(129.71,104.87) v2(130.23,107.87) v2(132.55,94.78) v2(133.13,120.65) v2(135.15,116.91) v2(136.12,118.07) v2(136.19,107.08) v2(136.88,116.14) v2(137.64,119.62) v2(137.74,107.05) v2(137.9,104.92) v2(139.52,115.31) v2(139.67,104.94) v2(139.75,119.57) v2(142.98,115.18) v2(143.89,115.66) v2(144.17,129.45) v2(145.26,120.59) v2(146,118.13) v2(147.24,119.93) v2(147.47,117.03) v2(148.84,118.71) v2(150.85,117.01) v2(151.69,111.85) v2(153.29,118.73) v2(154.03,127.55) v2(154.48,111.88) v2(154.76,128.34) v2(154.81,117.44) v2(154.97,119.9) v2(156.97,118.79) v2(158.04,111.93) v2(158.06,99.66) v2(158.06,98.97) v2(159,117.39) v2(159.64,114.06) v2(159.59,110.86) v2(159.64,108.78) v2(159.66,100.42) v2(160.27,118.73) v2(162.05,110.35) v2(162.13,100.4) v2(162.86,111.65) v2(171.22,96.44) v2(172.34,97.91) v2(174.42,122.39) v2(174.47,120) v2(175.31,121.33) v2(176.35,120) v2(176.4,122.44) v2(176.64,94.25) v2(177.52,121.35) v2(178.41,122.52) v2(178.56,119.95) v2(179.5,131.77) v2(179.5,121.3) v2(179.98,119.42) v2(180.24,122.52) v2(181.64,118.2) v2(181.76,122.11) v2(181.76,120.61) v2(181.76,119.47) v2(183.46,122.21) v2(183.54,120.82) v2(183.57,119.57) v2(183.49,118.33) v2(183.54,117.11) v2(184.18,131.08) v2(185.95,121.43) v2(186,118.66) v2(187.27,120.26) v2(187.35,116.93) v2(188.92,118.61) v2(190.47,116.93) v2(190.7,120.16) v2(191.74,118.56) v2(193.57,120.03) v2(193.67,116.83) v2(194.76,138.24) v2(194.74,118.53) v2(198.34,108.47) v2(203.3,137.21) v2(203.33,135.71) v2(203.77,129.55) v2(203.77,120.82) v2(205.21,125.26) v2(205.7,120.82) v2(206.15,94.05) v2(206.57,94.05) v2(206.82,126.91) v2(206.82,126.15) v2(206.82,125.39) v2(206.98,123.26) v2(206.98,118.15) v2(206.99,94.05) v2(212.72,121.45) v2(212.83,129.17) v2(212.8,124.35) v2(212.98,126.96) v2(214.4,136.57) v2(215.56,123.99) v3(15.84,48.43) v3(16.33,50.69) v3(16.4,52.57) v3(16.41,45.32) v3(16.6,48.87) v3(16.66,47.16) v3(16.66,46.27) v3(16.73,49.7) v3(18.95,49.7) v3(18.95,47.86) v3(18.95,46.14) v3(19.01,51.48) v3(19.02,50.64) v3(19.08,48.91) v3(19.2,47.03) v3(20.42,36.21) v3(29.21,110.84) v3(30,110.91) v3(30,109.31) v3(30.84,110.96) v3(30.81,109.31) v3(30.84,67.63) v3(30.94,68.19) v3(31.14,67.5) v3(31.34,68.19) v3(31.42,67.6) v3(31.62,68.16) v3(34.92,61.74) v3(35.41,62.52) v3(35.56,63.31) v3(38.89,108.19) v3(39.32,107.25) v3(39.42,108.19) v3(51.09,95.56) v3(52.27,95.47) v3(52.37,95.85) v3(54.46,95.21) v3(55.07,144.16) v3(55.07,142.66) v3(55.32,95.21) v3(56.29,95.29) v3(57.28,95.82) v3(57.73,95.93) v3(58.83,95.95) v3(171.77,98.78) v3(173.81,98.66) v3(220,115.52) v4(64.57,117.34) v4(67.05,118.46) v4(71.01,114.55) v4(71.01,113.43) v4(75.47,118.46) v5(64.57,115.66) v5(66.06,116.78) v5(66.06,116.22) v5(66.55,116.78) v5(68.04,119.02) v5(68.04,117.9) v5(70.02,119.02) v5(70.02,117.9) v5(70.02,116.78) v5(72,115.66) v5(72,114.55) v5(72,113.43) v5(74.48,113.99) v7(8.84,121.5) v7(15.35,50.13) v7(15.35,49.27) v7(15.38,48.4) v7(15.38,47.54) v7(15.38,46.65) v7(15.38,45.79) v7(15.44,52.16) v7(15.44,51.15) v7(18.7,33.64) v7(19.43,28.74) v7(19.96,35.4) v7(20.78,42.82) v7(21.39,28.87) v7(26.57,38.52) v7(27.08,70.72) v7(27.17,71.9) v7(28.09,70.72) v7(28.22,60.62) v7(28.54,55.41) v7(28.68,30.77) v7(28.73,71.86) v7(29.3,70.72) v7(29.3,60.05) v7(29.81,32.72) v7(30.1,59.63) v7(30.19,60.62) v7(30.57,55.6) v7(30.89,51.03) v7(30.95,34.27) v7(30.9,30.74) v7(31.34,32.81) v7(31.46,53.7) v7(31.39,52.3) v7(31.6,57.39) v7(32.16,60.37) v7(32.41,56.87) v7(32.61,109.03) v7(32.66,70.65) v7(32.66,59.79) v7(32.6,34.46) v7(32.74,75.58) v7(32.87,109.03) v7(32.84,73.16) v7(32.85,71.35) v7(32.87,35.84) v7(33.55,70.59) v7(33.67,59.82) v7(33.66,35.18) v7(34.32,35.85) v7(34.66,32.81) v7(35.14,59.67) v7(35.47,75.48) v7(35.87,34.27) v7(36.03,60.11) v7(36.16,62.97) v7(36.16,61.13) v7(36.79,60.62) v7(36.79,49.06) v7(36.8,32.37) v7(36.96,76.67) v7(38.02,71.89) v7(38,32.43) v7(38.25,35.07) v7(38.36,49.26) v7(38.47,65.02) v7(38.44,34.14) v7(38.7,48.81) v7(38.79,59.45) v7(38.89,48.24) v7(39.08,49.57) v7(39.15,32.22) v7(39.4,48.94) v7(39.4,33.76) v7(39.65,59.73) v7(39.65,47.73) v7(40.22,48.81) v7(40.35,60.94) v7(40.47,59.54) v7(40.47,48.17) v7(40.41,35.66) v7(40.54,74.99) v7(40.56,63.97) v7(40.52,63.28) v7(40.62,34.71) v7(54.15,133.89) v7(54.76,143.39) v7(57.1,129.68) v7(135.93,135.69) v7(178.45,92.45) v7(179.93,93.74) v7(190.79,93.73) v7(195.1,93.75) v7(198.04,93.74) v7(200.16,96.98) v7(200.23,93.74) v7(200.41,96.61) v7(202.86,137.2) v7(202.83,135.71) v7(203.64,95.06) v7(216.37,122.28) v7(216.32,120.34) v7(216.56,94.37) v7(216.66,143.15) v7(216.84,98.67) v7(217,124.17) v7(217.88,123.4) v7(218.75,135.98) v7(218.94,129.21) v7(218.9,126.25) v7(218.89,96.75) v7(219.05,132.4) v7(219.4,92.88) v7(219.73,99.2) v7(220.43,105.19) v7(221.2,102.61) v7(222.12,133.49) v8(53.42,129.56) v8(53.44,128.92) v8(54.18,129.53) v8(54.23,128.92) v8(64.57,117.6) v8(66.55,117.09) v8(67.05,118.78) v8(67.05,117.66) v8(68.04,118.77) v8(68.04,117.63) v8(68.04,115.41) v8(70.02,114.86) v8(70.02,113.75) v8(71.01,114.86) v8(71.01,113.75) v8(72,118.91) v8(72,117.8) v8(72,114.85) v8(72,113.75) v8(74.23,119.58) v8(74.22,118.46) v8(74.22,115.1) v8(74.22,113.99) v8(74.22,112.87) v8(75.21,118.46) v8(134.39,129.14) v8(136.87,129.14) v8(139.34,129.14) v9(3.09,116.04) v9(4.34,114.87) v9(4.78,140.15) v9(4.78,137.7) v9(4.78,128.8) v9(4.78,126.35) v9(4.83,120.5) v9(4.79,117.24) v9(5.51,143.69) v9(5.5,143.22) v9(5.5,142.89) v9(5.77,143.69) v9(6.48,116.01) v9(6.58,139.15) v9(6.71,135.77) v9(6.72,132.93) v9(6.83,139.15) v9(6.92,132.72) v9(6.93,122.14) v9(7.47,123.48) v9(7.84,13.29) v9(8.09,18.8) v9(9.58,163.96) v9(10.67,165.62) v9(10.76,162.23) v9(10.81,140.83) v9(11.09,141.09) v9(11.9,123.47) v9(12,163.95) v9(12.5,15.97) v9(13.03,15.97) v9(13.66,47.42) v9(13.64,15.94) v9(13.77,48.24) v9(13.87,48.86) v9(14.23,49.8) v9(14.27,46.5) v9(14.35,51.61) v9(14.37,51.16) v9(14.42,47.42) v9(14.51,50.51) v9(14.53,48.24) v9(14.63,48.86) v9(14.66,46.02) v9(14.93,47.42) v9(14.99,49.8) v9(15.04,48.24) v9(15.03,46.5) v9(15.11,51.61) v9(15.13,51.16) v9(15.14,48.86) v9(15.4,47.27) v9(15.42,46.02) v9(15.5,49.8) v9(15.54,46.5) v9(15.62,51.61) v9(15.64,51.16) v9(15.93,46.02) v9(17.75,37.04) v9(17.95,32.09) v9(18.21,42.76) v9(18.72,51.81) v9(18.69,19.42) v9(18.69,19.08) v9(18.69,18.76) v9(18.87,55.58) v9(18.81,26.24) v9(18.84,16.79) v9(19.06,131.84) v9(19.06,129.01) v9(19.08,126.99) v9(19.04,121.99) v9(19.06,120.83) v9(19.04,119.62) v9(19.06,118.29) v9(19.06,115.75) v9(19.08,114.47) v9(19.06,113.21) v9(19.06,111.91) v9(19.06,110.67) v9(19.08,109.15) v9(19.05,63.42) v9(19.07,46.92) v9(19.05,23.59) v9(19.08,19.12) v9(19.09,133.13) v9(19.09,130.59) v9(19.09,125.51) v9(19.11,124.44) v9(19.09,122.97) v9(19.11,117.02) v9(19.15,59.59) v9(19.14,19.54) v9(19.12,18.71) v9(19.25,21.9) v9(19.29,128.07) v9(19.49,21.27) v9(19.62,92.57) v9(19.62,89.18) v9(19.64,84.15) v9(19.62,37.81) v9(19.6,31.9) v9(19.6,16.79) v9(19.72,24.15) v9(19.81,23.59) v9(19.97,73) v9(19.96,19.22) v9(19.95,18.85) v9(20.01,69.01) v9(20.01,21.9) v9(19.98,19.58) v9(20.18,108.78) v9(20.11,16.79) v9(20.26,21.27) v9(20.35,132.29) v9(20.32,129.26) v9(20.32,23.59) v9(20.33,22.73) v9(20.35,19.42) v9(20.35,19.08) v9(20.35,18.74) v9(20.47,53.56) v9(20.44,51.59) v9(20.46,49.77) v9(20.41,48.14) v9(20.46,46.81) v9(20.47,40.35) v9(20.47,34.87) v9(20.47,31.08) v9(20.46,29.81) v9(20.42,28.48) v9(20.53,66.91) v9(20.51,60.74) v9(20.55,58.15) v9(20.53,55.81) v9(20.48,45.48) v9(20.53,43.85) v9(20.51,42.08) v9(20.48,38.55) v9(20.48,36.71) v9(20.48,32.97) v9(20.48,24.15) v9(20.52,21.9) v9(20.76,21.27) v9(20.76,20.37) v9(21.06,128.82) v9(20.99,24.15) v9(21.22,130.55) v9(21.26,18.77) v9(21.43,133.59) v9(21.49,28.13) v9(21.52,20.37) v9(21.72,15.89) v9(21.82,89.13) v9(21.87,38.04) v9(21.96,45.56) v9(21.97,43.36) v9(21.93,35.18) v9(22.02,58.02) v9(22.03,52) v9(22.03,51.41) v9(22.01,50.12) v9(22.01,49.53) v9(22.03,23.3) v9(22.03,20.37) v9(22.02,18.77) v9(22.28,111.39) v9(22.22,108.75) v9(22.38,130.51) v9(22.37,22.42) v9(22.43,67.53) v9(22.4,65.15) v9(22.4,15.92) v9(22.53,18.77) v9(22.61,55.23) v9(22.72,21.08) v9(22.82,45.56) v9(22.8,35.18) v9(22.8,24.11) v9(22.79,23.3) v9(22.85,19.89) v9(22.92,133.57) v9(22.91,110.58) v9(22.95,28.1) v9(22.91,15.92) v9(23.04,58.02) v9(23.11,129.95) v9(23.14,22.42) v9(23.23,65.45) v9(23.3,23.3) v9(23.49,25.93) v9(23.56,24.11) v9(23.48,21.08) v9(23.67,65.81) v9(23.65,40.05) v9(23.65,39.35) v9(23.65,38.65) v9(23.64,22.42) v9(23.62,19.89) v9(23.75,88.47) v9(23.74,86.34) v9(23.75,84.48) v9(23.73,82.73) v9(23.74,80.95) v9(23.77,79.15) v9(23.77,77.67) v9(23.77,75.47) v9(23.85,130.51) v9(23.79,77.12) v9(23.79,73.91) v9(23.82,72.75) v9(23.79,72.32) v9(23.8,71.67) v9(23.8,70.78) v9(23.8,69.55) v9(24.03,111.39) v9(24.03,58.02) v9(24.03,40.05) v9(24.03,39.35) v9(24.03,38.65) v9(24.07,24.11) v9(23.99,21.08) v9(24.12,19.89) v9(24.26,65.81) v9(24.31,133.58) v9(24.31,28.09) v9(24.41,67.5) v9(24.43,61.33) v9(24.54,68.91) v9(24.71,119.24) v9(24.79,119.7) v9(24.92,119.45) v9(25.04,119.7) v9(25.04,119.22) v9(24.98,70.4) v9(25.17,119.45) v9(25.11,108.75) v9(25.26,70.18) v9(25.3,119.7) v9(25.32,119.22) v9(25.3,39.35) v9(25.3,38.65) v9(25.45,119.45) v9(25.55,119.7) v9(25.58,119.22) v9(25.55,65.79) v9(25.56,28.07) v9(25.64,114.82) v9(25.62,39.73) v9(25.64,31.27) v9(25.7,119.45) v9(25.75,23.13) v9(25.81,119.7) v9(25.86,119.22) v9(25.79,84.65) v9(25.88,89.54) v9(25.91,53.13) v9(25.91,52.49) v9(25.91,51.86) v9(25.91,51.22) v9(25.91,50.59) v9(26.06,133.61) v9(26.06,119.7) v9(25.98,119.45) v9(25.98,70.46) v9(26.1,84.65) v9(26.14,65.79) v9(26.28,68.89) v9(26.29,67.5) v9(26.44,40.05) v9(26.44,39.35) v9(26.44,38.65) v9(26.56,70.4) v9(26.51,23.13) v9(26.67,53.13) v9(26.67,52.49) v9(26.67,51.86) v9(26.67,51.22) v9(26.67,50.59) v9(26.72,79.45) v9(26.75,24.19) v9(26.87,81.19) v9(26.87,80.2) v9(26.8,70.2) v9(26.82,40.05) v9(26.82,39.35) v9(26.82,38.65) v9(26.81,28.09) v9(26.9,82.18) v9(27.08,63.92) v9(27.08,63.41) v9(27.08,62.84) v9(27.02,23.13) v9(27.18,53.13) v9(27.18,52.49) v9(27.18,51.86) v9(27.18,51.22) v9(27.18,50.59) v9(27.26,127.91) v9(27.24,84.24) v9(27.36,112.61) v9(27.36,112.33) v9(27.36,112.05) v9(27.33,111.11) v9(27.33,110.86) v9(27.36,110.58) v9(27.3,79.45) v9(27.37,61.85) v9(27.31,48.24) v9(27.47,131.19) v9(27.51,24.19) v9(27.63,133.59) v9(27.63,126.6) v9(27.65,63.92) v9(27.62,63.4) v9(27.65,62.84) v9(27.76,67.64) v9(27.89,79.43) v9(27.89,59.48) v9(27.94,53.13) v9(27.94,52.49) v9(27.94,51.86) v9(27.94,51.22) v9(27.94,50.59) v9(27.95,28.07) v9(28.02,24.19) v9(28.17,114.28) v9(28.16,63.92) v9(28.16,63.41) v9(28.16,62.84) v9(28.23,124.49) v9(28.33,68.89) v9(28.45,53.13) v9(28.45,52.49) v9(28.45,51.86) v9(28.45,51.22) v9(28.45,50.59) v9(28.49,125.53) v9(28.54,86.14) v9(28.65,70.46) v9(28.71,108.75) v9(28.71,25.95) v9(28.97,89.54) v9(29.16,80.16) v9(29.21,53.13) v9(29.21,52.49) v9(29.21,51.86) v9(29.21,51.22) v9(29.21,50.59) v9(29.25,28.09) v9(29.29,79.35) v9(29.44,133.57) v9(29.48,88.22) v9(29.46,70.41) v9(29.44,30.04) v9(29.51,80.16) v9(29.6,66.25) v9(29.62,41.43) v9(29.88,67.68) v9(30.02,111.8) v9(30,110.58) v9(30.03,102.63) v9(30.05,68.85) v9(30.1,70.41) v9(30.31,90.91) v9(30.31,87.38) v9(30.31,48.24) v9(30.3,29.48) v9(30.63,84.15) v9(30.76,112.23) v9(30.76,111.98) v9(30.76,111.7) v9(30.71,70.32) v9(30.8,28.1) v9(30.97,106.15) v9(30.94,70.12) v9(30.91,58.64) v9(31.03,133.54) v9(31.1,108.75) v9(31.11,52.04) v9(31.24,132.25) v9(31.22,131.33) v9(31.32,33.06) v9(31.6,89.56) v9(31.58,68.85) v9(31.64,67.71) v9(31.72,62.74) v9(31.72,61.8) v9(31.83,35.32) v9(31.83,34.89) v9(31.93,83.51) v9(31.97,63.78) v9(31.97,37.13) v9(31.99,36.49) v9(31.99,36.24) v9(31.99,35.98) v9(32.08,34.89) v9(32.16,65.8) v9(32.15,42.48) v9(32.16,37.41) v9(32.13,35.35) v9(32.11,28.08) v9(32.25,86.34) v9(32.21,33.9) v9(32.21,33.04) v9(32.43,40.14) v9(32.39,38.67) v9(32.42,38.08) v9(32.5,133.6) v9(32.58,100.64) v9(32.59,143.62) v9(32.64,142.64) v9(32.61,141.13) v9(32.63,139.69) v9(32.61,138.59) v9(32.6,137.38) v9(32.61,136.05) v9(32.63,134.67) v9(32.67,103.39) v9(32.7,108.25) v9(32.7,106.66) v9(32.72,105.01) v9(32.97,68.82) v9(33.05,33.59) v9(33.1,44.97) v9(33.18,67.71) v9(33.22,44.72) v9(33.32,99.25) v9(33.3,90.91) v9(33.3,86.38) v9(33.45,122.67) v9(33.45,122.39) v9(33.42,111.61) v9(33.41,52.33) v9(33.44,50.45) v9(33.47,28.04) v9(33.53,53.57) v9(33.93,61.04) v9(34.05,89.54) v9(34.06,86.25) v9(34.12,52.26) v9(34.29,101.36) v9(34.33,68.77) v9(34.39,115.09) v9(34.48,143.69) v9(34.57,112.84) v9(34.54,112.49) v9(34.57,112.13) v9(34.57,111.8) v9(34.54,110.33) v9(34.57,104.03) v9(34.53,67.71) v9(34.69,42.67) v9(34.82,110.33) v9(34.92,71.81) v9(34.93,49.61) v9(35.08,104.03) v9(35.15,51.5) v9(35.23,114.16) v9(35.23,34.39) v9(35.31,108.47) v9(35.33,28.06) v9(35.38,107.51) v9(35.39,52.54) v9(35.48,31.69) v9(35.52,104.02) v9(35.51,99.23) v9(35.56,52.85) v9(35.53,52.29) v9(35.62,113.11) v9(35.73,142.83) v9(35.76,62.87) v9(35.89,143.03) v9(35.9,67.71) v9(35.89,47.84) v9(36.02,104) v9(36,89.56) v9(36.06,68.85) v9(36.06,36.04) v9(36.05,35.16) v9(36,26.26) v9(36.18,143.42) v9(36.09,90.91) v9(36.19,143.7) v9(36.26,108.47) v9(36.25,107.51) v9(36.32,131.7) v9(36.29,36.24) v9(36.28,35.39) v9(36.47,97.8) v9(36.39,58.26) v9(36.54,131.46) v9(36.7,52.03) v9(36.7,49.62) v9(36.73,47.08) v9(36.75,44.9) v9(36.96,52.03) v9(37.05,28.08) v9(37.17,67.71) v9(37.22,142.78) v9(37.21,52.05) v9(37.35,143.01) v9(37.36,45.46) v9(37.44,76.9) v9(37.52,104.27) v9(37.58,99.2) v9(37.58,76.19) v9(37.62,45.33) v9(37.76,143.69) v9(37.74,68.85) v9(37.83,89.56) v9(37.83,25.59) v9(37.93,137.47) v9(38.15,137.96) v9(38.11,62.53) v9(38.11,61.52) v9(38.11,60.5) v9(38.24,142.75) v9(38.28,67.71) v9(38.2,35.22) v9(38.32,45.32) v9(38.39,142.97) v9(38.53,49.64) v9(38.66,55.51) v9(38.66,54.9) v9(38.66,52.19) v9(38.6,45.1) v9(38.59,25.59) v9(38.71,54.3) v9(38.73,53.74) v9(38.73,53.18) v9(38.71,52.67) v9(38.85,143.69) v9(38.91,138.78) v9(38.94,138.19) v9(38.94,137.61) v9(38.98,72.98) v9(39,62.53) v9(39,61.52) v9(39,60.5) v9(39.15,68.85) v9(39.1,25.59) v9(39.25,63.57) v9(39.25,59.47) v9(39.27,55.51) v9(39.32,54.88) v9(39.37,54.32) v9(39.37,53.74) v9(39.32,53.23) v9(39.34,52.67) v9(39.34,52.19) v9(39.31,26.68) v9(39.47,137.61) v9(39.5,138.75) v9(39.48,138.22) v9(39.55,86.35) v9(39.65,46.21) v9(39.69,42.67) v9(39.84,99.2) v9(39.98,138.19) v9(39.89,62.53) v9(39.89,61.52) v9(39.89,60.5) v9(39.9,55.49) v9(39.98,54.85) v9(39.98,54.3) v9(39.98,53.71) v9(39.9,45.95) v9(40.06,53.23) v9(40.06,52.67) v9(40.07,34.7) v9(40.07,26.68) v9(40.11,138.78) v9(40.08,137.58) v9(40.11,121.83) v9(40.08,121.53) v9(40.08,72.23) v9(40.08,52.19) v9(40.19,28.11) v9(40.31,110.33) v9(40.31,110.07) v9(40.31,109.82) v9(40.38,44.89) v9(40.32,34.7) v9(40.44,121.83) v9(40.44,121.53) v9(40.47,89.58) v9(40.56,55.49) v9(40.58,26.68) v9(40.6,143.48) v9(40.61,54.85) v9(40.61,54.3) v9(40.61,53.74) v9(40.69,141.42) v9(40.72,68.85) v9(40.69,53.25) v9(40.72,52.69) v9(40.72,52.19) v9(40.77,27.03) v9(40.89,122.9) v9(40.89,102.66) v9(40.94,67.77) v9(40.96,21.54) v9(41.01,37.86) v9(40.99,34.68) v9(41.11,42.01) v9(41.25,122.88) v9(41.25,121.83) v9(41.27,121.55) v9(41.2,102.66) v9(41.27,74.53) v9(41.22,55.49) v9(41.27,54.93) v9(41.25,53.74) v9(41.27,53.25) v9(41.27,52.72) v9(41.27,41.16) v9(41.26,37.86) v9(41.25,34.68) v9(41.29,80.08) v9(41.33,54.3) v9(41.35,52.24) v9(41.36,22.61) v9(41.39,42.01) v9(41.41,24.05) v9(41.5,102.66) v9(41.5,82.06) v9(41.5,81.5) v9(41.51,37.86) v9(41.53,27.03) v9(41.66,121.83) v9(41.66,121.53) v9(41.63,57.71) v9(41.72,21.54) v9(41.81,102.66) v9(41.87,99.19) v9(41.86,22.61) v9(41.9,25.03) v9(41.92,24.05) v9(42.04,27.03) v9(42.09,123.06) v9(42.13,28.1) v9(42.21,103.64) v9(42.23,21.54) v9(42.34,123.06) v9(42.29,89.54) v9(42.38,67.77) v9(42.34,26.24) v9(42.36,22.63) v9(42.3,18.66) v9(42.47,103.68) v9(42.53,76.09) v9(42.57,68.89) v9(42.62,143.52) v9(42.66,25.03) v9(42.77,142.41) v9(42.71,85.61) v9(42.72,72.42) v9(42.74,27.01) v9(42.74,26.07) v9(42.97,18.23) v9(43.05,75.6) v9(43.01,75.19) v9(43,74.59) v9(42.99,74.02) v9(43,73.29) v9(42.99,21.81) v9(43.13,140.58) v9(43.09,138.05) v9(43.17,25.03) v9(43.38,140.58) v9(43.36,133.52) v9(43.33,132.1) v9(43.28,28.09) v9(43.46,115.23) v9(43.46,114.95) v9(43.42,23.27) v9(43.5,27.01) v9(43.5,26.07) v9(43.61,133.52) v9(43.66,132.1) v9(43.73,97.57) v9(43.73,82.46) v9(43.73,82.08) v9(43.74,81.24) v9(43.74,80.86) v9(43.74,77.43) v9(43.77,75.19) v9(43.77,74.59) v9(43.76,74.02) v9(43.76,73.29) v9(43.76,72.7) v9(43.71,72.23) v9(43.74,63.85) v9(43.74,62.07) v9(43.74,61.18) v9(43.74,59.4) v9(43.71,41.44) v9(43.71,41.19) v9(43.71,40.93) v9(43.71,40.17) v9(43.71,39.92) v9(43.71,39.66) v9(43.76,21.81) v9(43.74,18.23) v9(43.81,83.15) v9(43.79,78.88) v9(43.83,76.08) v9(43.81,75.6) v9(43.84,42.71) v9(43.84,42.46) v9(43.84,42.2) v9(43.87,39.04) v9(43.87,38.74) v9(43.87,38.42) v9(43.94,140.12) v9(43.94,139.39) v9(43.97,67.81) v9(44.07,135.75) v9(44.01,27.01) v9(44.01,26.07) v9(44.12,68.9) v9(44.18,23.27) v9(44.2,140.12) v9(44.27,74.59) v9(44.26,74.02) v9(44.27,73.29) v9(44.27,72.7) v9(44.22,72.23) v9(44.26,21.81) v9(44.24,18.23) v9(44.35,135.55) v9(44.32,75.6) v9(44.28,75.19) v9(44.44,143.51) v9(44.47,28.11) v9(44.69,23.27) v9(45.07,80.3) v9(45.06,79.07) v9(45.07,77.76) v9(45.06,76.56) v9(45.07,75.22) v9(45.07,72.68) v9(45.06,71.49) v9(45.04,49.59) v9(45.07,47.43) v9(45.06,44.34) v9(45.03,32.15) v9(45.17,126.69) v9(45.1,99.16) v9(45.11,87.57) v9(45.1,84.33) v9(45.1,82.93) v9(45.08,81.64) v9(45.08,73.99) v9(45.1,68.31) v9(45.14,67.34) v9(45.14,65.89) v9(45.15,55.78) v9(45.13,54.74) v9(45.1,53.37) v9(45.1,52.04) v9(45.11,50.8) v9(45.08,48.57) v9(45.1,46.48) v9(45.1,45.53) v9(45.13,43.01) v9(45.08,41.71) v9(45.13,40.47) v9(45.11,39.06) v9(45.13,37.93) v9(45.14,36.54) v9(45.13,35.39) v9(45.08,30.59) v9(45.1,29.11) v9(45.19,64.76) v9(45.2,63.45) v9(45.22,60.26) v9(45.22,59.1) v9(45.22,57.98) v9(45.18,57.09) v9(45.34,135.73) v9(45.34,103.77) v9(45.49,122.67) v9(45.6,103.77) v9(45.69,135.73) v9(45.75,129.48) v9(46.34,143.52) v9(46.51,139.39) v9(46.55,126.53) v9(46.63,121.2) v9(46.63,120.31) v9(46.63,119.42) v9(46.68,140.02) v9(46.84,129.07) v9(47,99.15) v9(47.47,140.48) v9(47.73,140.48) v9(47.87,103.42) v9(48.01,126.56) v9(48.08,114.62) v9(48.21,137.47) v9(48.21,137.14) v9(48.58,137.47) v9(48.58,137.14) v9(48.64,143.51) v9(48.64,129.96) v9(48.71,150.01) v9(48.79,134.27) v9(48.87,104.18) v9(48.87,103.42) v9(48.87,102.66) v9(48.95,137.47) v9(48.93,137.12) v9(49.05,138.31) v9(49.17,140.08) v9(49.12,129.92) v9(49.15,99.18) v9(49.25,114.04) v9(49.29,126.9) v9(49.43,143.42) v9(49.4,100.58) v9(49.57,130.99) v9(49.81,136.95) v9(49.81,131.41) v9(50.08,130.61) v9(50.37,143.98) v9(50.37,143.73) v9(50.37,143.47) v9(50.62,143.98) v9(50.62,143.73) v9(50.62,143.47) v9(50.96,137.27) v9(51.66,107.07) v9(51.66,106.82) v9(51.67,99.16) v9(51.76,141.07) v9(51.97,139.61) v9(51.9,104.41) v9(51.93,103.57) v9(51.93,102.99) v9(52.02,114.34) v9(52.1,143.65) v9(52.17,142.23) v9(52.1,138.6) v9(52.32,99.18) v9(52.73,102.3) v9(52.84,129.94) v9(53.09,112.72) v9(53.21,124.5) v9(53.3,114.14) v9(53.38,130.45) v9(53.49,139.61) v9(53.49,137.45) v9(53.57,123.75) v9(53.52,113.74) v9(53.49,99.18) v9(53.89,114.05) v9(53.89,113.68) v9(54.04,131.16) v9(54.11,130.48) v9(54.76,137.58) v9(54.74,116.45) v9(54.8,143.64) v9(54.89,139.61) v9(54.89,138.47) v9(54.95,99.16) v9(55,120.08) v9(55.26,141.07) v9(55.26,135.97) v9(55.36,117.01) v9(55.36,116.37) v9(55.52,125.97) v9(55.96,123.21) v9(56.27,142.36) v9(56.21,123.21) v9(56.3,128.44) v9(56.54,130.93) v9(56.53,99.18) v9(56.65,143.68) v9(56.68,121.44) v9(56.69,129.92) v9(56.87,130.93) v9(57.16,119.09) v9(57.2,139.33) v9(57.23,138.58) v9(57.2,137.35) v9(57.23,136.03) v9(57.28,123.21) v9(57.3,109.31) v9(57.3,108.04) v9(57.42,119.09) v9(57.53,104.1) v9(57.53,103.72) v9(57.66,123.21) v9(57.67,119.09) v9(57.71,112.99) v9(57.71,112.74) v9(57.78,112.49) v9(57.78,104.1) v9(57.78,103.72) v9(57.91,123.21) v9(57.92,119.09) v9(58.21,147.51) v9(58.46,143.64) v9(58.46,130.57) v9(58.47,106.01) v9(58.46,99.21) v9(58.48,142.13) v9(58.48,140.72) v9(58.5,139.23) v9(58.52,138.03) v9(58.56,136.73) v9(58.57,135.14) v9(58.56,132.01) v9(58.56,126.71) v9(58.53,124.28) v9(58.52,113.54) v9(58.52,112.31) v9(58.52,110.96) v9(58.51,109.37) v9(58.51,107.74) v9(58.5,104.49) v9(58.52,100.98) v9(58.58,117.17) v9(58.71,147.51) v9(59.21,147.51) v9(60.21,150.01) v9(62.06,117.13) v9(62.15,117.49) v9(62.14,113.91) v9(62.14,112.79) v9(62.26,116.88) v9(62.2,113.4) v9(64.71,131.69) v9(64.99,131.69) v9(65.27,131.67) v9(67.13,115.81) v9(67.16,104.84) v9(67.13,104.18) v9(67.13,103.93) v9(67.13,101.11) v9(67.13,100.85) v9(67.16,99.2) v9(67.25,124.93) v9(67.25,122.71) v9(67.26,113.2) v9(67.26,107.93) v9(67.28,111.85) v9(67.3,110.43) v9(67.32,106.44) v9(67.32,105.77) v9(67.41,104.84) v9(67.5,124.93) v9(67.5,122.71) v9(67.51,113.2) v9(67.54,111.85) v9(67.55,110.43) v9(67.51,107.93) v9(67.58,106.44) v9(67.58,105.77) v9(67.64,115.81) v9(67.64,104.18) v9(67.64,103.93) v9(67.64,101.11) v9(67.64,100.85) v9(67.94,126.35) v9(67.94,126.1) v9(68.17,99.2) v9(68.58,122.86) v9(68.58,121.76) v9(68.58,111.2) v9(69.16,122.86) v9(69.14,121.67) v9(69.12,118.83) v9(69.12,117.65) v9(69.11,116.68) v9(69.11,116.42) v9(69.12,112.87) v9(69.2,115.6) v9(69.19,114.47) v9(69.19,113.37) v9(69.19,99.2) v9(69.5,120.55) v9(69.75,122.85) v9(69.75,121.71) v9(69.75,120.55) v9(69.69,119.16) v9(69.77,111.2) v9(70,123.76) v9(70,115.81) v9(70,114.7) v9(70.03,112.77) v9(70.26,119.65) v9(70.21,99.2) v9(70.28,123.76) v9(70.33,122.88) v9(70.33,121.68) v9(70.35,115.79) v9(70.46,119.42) v9(70.43,118.3) v9(70.38,114.67) v9(70.39,113.53) v9(70.48,126.35) v9(70.48,126.1) v9(70.51,119.73) v9(70.64,129.48) v9(70.89,122.88) v9(70.89,121.68) v9(70.92,111.79) v9(71.07,116.49) v9(71.22,99.2) v9(71.48,122.85) v9(71.48,111.79) v9(71.53,121.71) v9(71.64,129.48) v9(71.65,119.92) v9(72.03,122.88) v9(72.03,111.79) v9(72.11,124.98) v9(72.11,124.73) v9(72.11,124.48) v9(72.08,121.73) v9(72.19,118.81) v9(72.19,117.68) v9(72.19,116.58) v9(72.2,115.93) v9(72.22,114.79) v9(72.22,113.66) v9(72.24,101.72) v9(72.24,99.2) v9(72.32,118.06) v9(72.32,114.41) v9(72.33,113.09) v9(72.64,129.48) v9(72.67,121.73) v9(72.67,110.92) v9(72.77,119.94) v9(73.02,126.35) v9(73.02,126.1) v9(73.25,121.73) v9(73.28,110.9) v9(73.28,101.03) v9(73.25,99.2) v9(73.33,119.94) v9(73.44,118.8) v9(73.44,117.64) v9(73.48,117.04) v9(73.44,116.53) v9(73.47,115.41) v9(73.47,114.29) v9(73.47,113.66) v9(73.47,113.17) v9(73.47,112.59) v9(73.5,119.25) v9(73.5,118.14) v9(73.5,115.95) v9(73.51,114.81) v9(73.64,129.48) v9(73.81,121.72) v9(73.84,110.87) v9(74.27,117.52) v9(74.27,99.2) v9(74.34,116.37) v9(74.33,115.01) v9(74.33,113.87) v9(74.36,112.7) v9(74.4,121.72) v9(74.45,119.94) v9(74.41,118.73) v9(74.42,110.87) v9(74.98,121.72) v9(75.01,110.9) v9(75.22,126.33) v9(75.22,126.08) v9(75.25,117.48) v9(75.37,116.42) v9(75.31,115.08) v9(75.29,99.2) v9(75.43,118.73) v9(75.41,113.95) v9(75.98,116.27) v9(76.06,119.95) v9(76.12,121.72) v9(76.15,110.9) v9(76.3,99.2) v9(76.43,117.5) v9(76.43,116.31) v9(76.43,115.12) v9(76.43,113.92) v9(76.48,112.74) v9(76.73,121.74) v9(76.71,110.87) v9(76.91,118.71) v9(77.18,126.3) v9(77.18,126.05) v9(77.27,110.87) v9(77.32,99.2) v9(77.42,131.74) v9(77.52,113.1) v9(77.7,131.74) v9(77.77,113.1) v9(77.81,121.25) v9(77.98,131.71) v9(78.03,113.1) v9(78.31,126.46) v9(78.31,125.95) v9(78.32,102.79) v9(78.33,99.2) v9(78.54,113.1) v9(78.82,126.46) v9(78.82,125.95) v9(78.79,113.1) v9(79.04,113.1) v9(79.35,99.2) v9(79.55,113.1) v9(79.76,115.6) v9(79.81,113.1) v9(80.06,113.1) v9(80.37,99.2) v9(80.45,126.32) v9(80.45,126.06) v9(80.57,113.1) v9(80.57,108.8) v9(80.82,113.1) v9(81.17,131.03) v9(81.11,129.06) v9(81.11,127.32) v9(81.37,129.06) v9(81.37,127.32) v9(81.42,131.03) v9(81.38,113.17) v9(81.46,108.8) v9(81.38,99.2) v9(82.12,131.43) v9(82.12,131.18) v9(82.24,113.17) v9(82.32,108.8) v9(82.4,99.2) v9(82.55,128.32) v9(82.63,131.43) v9(82.63,131.18) v9(83.13,131.43) v9(83.13,131.18) v9(83.11,113.15) v9(83.26,126.66) v9(83.21,108.8) v9(83.41,99.2) v9(83.64,131.43) v9(83.64,131.18) v9(84.15,131.43) v9(84.15,131.18) v9(84.1,108.75) v9(84.35,108.75) v9(84.43,99.2) v9(84.66,131.43) v9(84.66,131.18) v9(84.61,108.75) v9(85.17,131.43) v9(85.17,131.18) v9(85.37,108.75) v9(85.45,99.2) v9(85.67,131.43) v9(85.67,131.18) v9(85.62,108.75) v9(85.75,128.06) v9(85.88,108.75) v9(86,123.03) v9(86.18,131.43) v9(86.18,131.18) v9(86.23,123.18) v9(86.42,129.4) v9(86.64,108.75) v9(86.64,102.67) v9(86.69,131.43) v9(86.69,131.18) v9(86.89,108.75) v9(86.89,102.67) v9(86.97,99.2) v9(87.15,108.75) v9(87.17,102.66) v9(87.2,131.43) v9(87.2,131.18) v9(87.71,131.43) v9(87.71,131.18) v9(87.96,102.68) v9(87.99,99.2) v9(88.21,131.43) v9(88.21,131.18) v9(88.24,102.67) v9(88.3,129.06) v9(88.51,128.86) v9(88.52,102.66) v9(88.72,131.43) v9(89,99.2) v9(89.18,123.56) v9(89.18,102.66) v9(89.23,131.43) v9(89.33,123.33) v9(89.48,102.66) v9(89.74,131.43) v9(89.76,102.66) v9(89.88,130.58) v9(89.99,101.5) v9(90.02,99.2) v9(90.25,131.43) v9(90.25,131.18) v9(90.38,130.25) v9(90.4,102.58) v9(90.64,130.58) v9(90.75,131.43) v9(90.75,131.18) v9(90.86,123.32) v9(91.03,99.2) v9(91.15,130.58) v9(91.15,130.25) v9(91.26,131.43) v9(91.26,131.18) v9(91.65,130.25) v9(91.77,131.43) v9(91.77,131.18) v9(91.85,102.83) v9(92.02,102.53) v9(92.05,99.2) v9(92.18,125.72) v9(92.28,131.43) v9(92.28,131.18) v9(92.2,102.83) v9(92.51,130.55) v9(92.79,131.43) v9(92.79,131.18) v9(92.79,130.25) v9(92.89,102.68) v9(93.07,99.2) v9(93.15,125.74) v9(93.27,130.55) v9(93.19,102.68) v9(93.29,131.43) v9(93.29,131.18) v9(93.55,130.25) v9(93.5,102.68) v9(93.78,130.55) v9(93.8,131.43) v9(93.8,131.18) v9(94.06,130.25) v9(94.08,99.2) v9(94.18,102.66) v9(94.31,131.43) v9(94.31,131.18) v9(94.46,125.36) v9(94.49,102.66) v9(94.72,125.36) v9(94.82,131.43) v9(94.82,131.18) v9(94.79,102.66) v9(94.97,125.36) v9(95.33,131.43) v9(95.33,131.18) v9(95.35,129.71) v9(95.61,129.71) v9(95.71,125.36) v9(95.83,131.43) v9(95.83,131.18) v9(95.83,116.98) v9(95.83,116.02) v9(95.96,125.36) v9(96.11,116.98) v9(96.16,116.02) v9(96.11,99.2) v9(96.21,125.36) v9(96.34,131.43) v9(96.34,131.18) v9(96.39,116.98) v9(96.44,116.02) v9(96.85,131.43) v9(96.85,131.18) v9(96.93,125.36) v9(97.05,117.01) v9(97.05,116.02) v9(97.18,125.36) v9(97.13,99.2) v9(97.23,130.55) v9(97.36,131.43) v9(97.36,131.18) v9(97.33,117.01) v9(97.36,116.02) v9(97.47,130.03) v9(97.43,125.36) v9(97.64,117.01) v9(97.66,116.02) v9(97.87,131.43) v9(97.87,131.18) v9(97.99,130.55) v9(98.15,99.2) v9(98.23,130.03) v9(98.27,117.01) v9(98.37,131.43) v9(98.37,131.18) v9(98.5,130.55) v9(98.53,117.01) v9(98.74,130.03) v9(98.81,117.01) v9(98.88,131.43) v9(98.88,131.18) v9(99.16,99.2) v9(99.32,130.17) v9(99.39,131.43) v9(99.39,131.18) v9(99.4,130.45) v9(99.43,126.73) v9(99.9,131.43) v9(99.9,131.18) v9(100,126.73) v9(100.16,130.45) v9(100.09,130.17) v9(100.18,99.2) v9(100.41,131.43) v9(100.41,131.18) v9(100.41,128.49) v9(100.67,130.45) v9(100.59,130.17) v9(100.91,131.43) v9(100.91,131.18) v9(101.09,130.24) v9(101.19,99.2) v9(101.31,126.75) v9(101.42,131.18) v9(101.85,130.24) v9(102.21,99.2) v9(102.4,131.26) v9(102.4,131) v9(102.39,101.13) v9(102.51,100.88) v9(102.76,115.32) v9(102.81,103.38) v9(103.23,99.2) v9(103.63,131.24) v9(103.63,130.99) v9(104.01,121.1) v9(104.01,120.83) v9(104.01,103.49) v9(104.19,100.66) v9(104.24,99.2) v9(104.34,103.49) v9(104.77,125.85) v9(104.77,100.66) v9(105.08,131.26) v9(105.08,131) v9(105.13,103.49) v9(105.23,128.95) v9(105.26,99.2) v9(105.46,114.39) v9(105.46,114.11) v9(105.46,103.49) v9(105.56,125.57) v9(105.73,129.07) v9(105.74,127.8) v9(105.74,127.55) v9(106.07,127.8) v9(106.07,127.55) v9(106.27,99.2) v9(106.31,121.7) v9(106.31,121.42) v9(106.32,120.81) v9(106.34,120.53) v9(106.49,129.99) v9(106.91,131.26) v9(106.91,131) v9(107.04,110.87) v9(107,107.17) v9(107.21,125.08) v9(107.36,111.29) v9(107.34,110.87) v9(107.34,110.54) v9(107.29,99.2) v9(107.46,125.08) v9(107.47,107.17) v9(107.66,110.87) v9(107.66,110.54) v9(107.98,110.87) v9(107.91,107.17) v9(108.01,111.29) v9(107.99,110.53) v9(108.24,129.99) v9(108.28,110.87) v9(108.28,110.54) v9(108.22,106.07) v9(108.31,99.2) v9(108.66,111.29) v9(108.6,110.87) v9(108.6,110.54) v9(108.84,131.24) v9(108.84,130.99) v9(109.32,99.2) v9(109.44,129.99) v9(109.72,116.11) v9(109.7,115.22) v9(109.88,126.88) v9(110.34,99.2) v9(110.63,131.26) v9(110.63,131) v9(110.85,117.62) v9(110.85,114.06) v9(110.87,105.41) v9(110.85,104.92) v9(110.85,104.41) v9(110.85,103.9) v9(110.85,103.39) v9(110.85,102.89) v9(110.85,102.38) v9(110.85,101.87) v9(110.85,101.36) v9(110.86,100.8) v9(110.97,129.99) v9(110.96,128.5) v9(110.96,127.33) v9(110.96,126.06) v9(110.96,124.79) v9(110.96,123.52) v9(110.96,122.25) v9(110.96,120.98) v9(110.96,119.71) v9(110.96,118.44) v9(110.96,117.17) v9(110.96,115.9) v9(110.96,112.12) v9(110.93,110.73) v9(110.93,109.41) v9(110.92,107.98) v9(110.92,106.62) v9(111.18,107.98) v9(111.18,106.62) v9(111.12,105.41) v9(111.1,104.92) v9(111.1,104.41) v9(111.1,103.9) v9(111.1,103.39) v9(111.1,102.89) v9(111.1,102.38) v9(111.1,101.87) v9(111.1,101.36) v9(111.11,100.8) v9(111.23,129.99) v9(111.21,128.5) v9(111.21,127.33) v9(111.21,126.06) v9(111.21,124.79) v9(111.21,123.52) v9(111.21,122.25) v9(111.21,120.98) v9(111.21,119.71) v9(111.21,118.44) v9(111.21,117.17) v9(111.21,115.9) v9(111.21,112.12) v9(111.19,110.73) v9(111.19,109.41) v9(111.35,117.62) v9(111.35,114.06) v9(111.35,99.2) v9(112.14,117.44) v9(112.14,117.19) v9(112.33,121.25) v9(112.36,118.95) v9(112.36,109.78) v9(112.37,108.24) v9(112.36,106.71) v9(112.33,105.29) v9(112.37,103.79) v9(112.42,132.2) v9(112.42,130.2) v9(112.43,128.63) v9(112.43,126.75) v9(112.42,124.98) v9(112.38,123.61) v9(112.39,117.44) v9(112.39,117.19) v9(112.41,113.72) v9(112.38,111.66) v9(112.41,102.63) v9(112.38,101.35) v9(112.38,99.32) v9(112.65,117.44) v9(112.65,117.19) v9(113.09,133.5) v9(113.69,104.14) v9(113.8,99.18) v9(113.92,132.11) v9(113.94,104.02) v9(114.72,99.33) v9(114.85,132.13) v9(114.85,130.33) v9(114.85,104.59) v9(114.97,104.27) v9(115.1,104.59) v9(115.23,104.27) v9(115.33,133.49) v9(115.48,99.33) v9(116.24,99.33) v9(116.28,110.07) v9(116.46,113.63) v9(116.47,109.29) v9(116.48,132.31) v9(116.48,130.53) v9(116.51,122.52) v9(116.94,133.49) v9(117.07,130.84) v9(117,99.33) v9(117.4,115.31) v9(117.65,130.84) v9(117.77,99.33) v9(118.24,131.12) v9(118.27,119.85) v9(118.22,117.95) v9(118.21,115.28) v9(118.3,132.32) v9(118.53,133.47) v9(118.53,99.33) v9(118.95,131.41) v9(118.94,112.03) v9(119.18,105.6) v9(119.24,113.32) v9(119.24,111.32) v9(119.24,110.2) v9(119.24,109.08) v9(119.19,107.84) v9(119.19,106.82) v9(119.49,99.35) v9(119.62,128.69) v9(119.61,128.3) v9(119.62,127.55) v9(119.63,127.13) v9(119.75,130.83) v9(120.26,99.35) v9(120.37,104.98) v9(121.02,99.35) v9(121.16,133.29) v9(121.41,133.29) v9(121.4,131.36) v9(121.39,130.76) v9(121.67,133.29) v9(121.73,132.32) v9(121.87,99.37) v9(122.66,99.42) v9(123.42,99.42) v9(123.57,132.2) v9(123.53,128.78) v9(123.53,128.39) v9(123.53,127.52) v9(123.55,127.09) v9(123.72,111.11) v9(123.8,108.32) v9(124.18,99.42) v9(124.32,128.56) v9(124.31,126.49) v9(124.31,125.72) v9(124.61,129.48) v9(124.94,99.42) v9(125.22,109.71) v9(125.53,123.21) v9(125.7,99.42) v9(126.26,118.18) v9(126.36,123.8) v9(126.47,99.41) v9(126.67,108.27) v9(126.77,111.17) v9(127.23,99.42) v9(127.65,125.44) v9(127.96,123.79) v9(127.99,99.42) v9(128.16,129.38) v9(128.16,128.58) v9(128.24,132.3) v9(128.22,123.79) v9(128.49,132.08) v9(128.59,121.83) v9(128.77,109.96) v9(128.85,121.83) v9(128.98,118.18) v9(129.13,131.82) v9(129.17,99.42) v9(129.36,126.98) v9(130.07,123.94) v9(130.16,126.58) v9(130.66,123.93) v9(130.64,110.15) v9(130.64,99.37) v9(130.96,112.99) v9(131.34,124.86) v9(131.55,124.63) v9(131.67,128.37) v9(132.18,99.37) v9(133.01,130.24) v9(133.35,126.13) v9(133.35,125.24) v9(133.34,99.44) v9(133.53,125.9) v9(133.5,124.98) v9(134.21,126.08) v9(134.19,125.21) v9(134.42,125.87) v9(134.39,125.03) v9(134.63,99.44) v9(135.2,127.9) v9(135.55,131.89) v9(135.7,130.98) v9(135.7,130.39) v9(135.81,126.65) v9(135.97,99.43) v9(136.33,136.95) v9(136.33,135.43) v9(137.1,136.95) v9(137.1,135.43) v9(137.38,99.41) v9(137.72,132.16) v9(137.86,136.95) v9(137.86,135.43) v9(137.92,130) v9(137.9,127.88) v9(138.01,124.95) v9(138.3,132.31) v9(138.62,136.95) v9(138.62,135.43) v9(138.73,129.67) v9(138.68,99.33) v9(138.9,132.32) v9(139.38,136.95) v9(139.38,135.43) v9(139.96,129.24) v9(140.14,136.95) v9(140.14,135.43) v9(140.12,99.35) v9(140.91,136.95) v9(140.91,135.43) v9(140.96,130.94) v9(141.58,113.73) v9(141.67,136.95) v9(141.67,135.43) v9(141.64,99.4) v9(141.9,132.35) v9(142.14,129.83) v9(142.16,128.59) v9(142.18,128.25) v9(142.16,127.93) v9(142.11,121.76) v9(142.29,111.47) v9(142.43,136.95) v9(142.43,135.43) v9(142.52,126.71) v9(142.52,126.15) v9(142.52,125.54) v9(143,126.69) v9(143.05,126.15) v9(143.1,125.54) v9(143.19,136.95) v9(143.19,135.43) v9(143.76,126.1) v9(143.76,125.54) v9(143.79,126.69) v9(143.95,136.95) v9(143.95,135.43) v9(144.42,99.39) v9(144.72,136.95) v9(144.72,135.43) v9(144.7,132.32) v9(144.88,132.1) v9(145.48,136.95) v9(145.48,135.43) v9(146.24,136.95) v9(146.24,135.43) v9(146.23,132.26) v9(146.38,99.32) v9(146.42,119.25) v9(147,136.95) v9(147,135.43) v9(147.13,130.99) v9(147.33,131.26) v9(147.76,136.95) v9(147.76,135.43) v9(148.13,99.36) v9(148.53,136.95) v9(148.53,135.43) v9(148.55,121.17) v9(148.97,133.82) v9(149.15,131.66) v9(149.29,136.95) v9(149.29,135.43) v9(149.45,124.86) v9(150.05,136.95) v9(150.05,135.43) v9(149.99,126.7) v9(150.18,99.46) v9(150.29,107.48) v9(150.43,104.17) v9(150.49,133.82) v9(150.62,128.54) v9(150.66,124.63) v9(150.66,124.31) v9(150.74,125.76) v9(150.72,101.97) v9(150.74,100.68) v9(150.81,136.95) v9(150.81,135.43) v9(150.84,131.3) v9(150.9,110.58) v9(151.18,105.27) v9(151.57,136.95) v9(151.57,135.43) v9(151.76,110.58) v9(152.02,133.82) v9(152.13,107.48) v9(152.2,99.46) v9(152.34,136.95) v9(152.34,135.43) v9(153.1,136.95) v9(153.1,135.43) v9(153.14,129.01) v9(153.14,128.63) v9(153.11,125.05) v9(153.11,124.79) v9(153.11,116.25) v9(153.11,115.99) v9(153.14,113.1) v9(153.14,112.84) v9(153.14,107.64) v9(153.14,107.38) v9(153.11,103.24) v9(153.11,102.99) v9(153.36,125.05) v9(153.36,124.79) v9(153.36,116.25) v9(153.36,115.99) v9(153.36,103.24) v9(153.36,102.99) v9(153.39,129.01) v9(153.39,128.63) v9(153.39,113.1) v9(153.39,112.84) v9(153.39,107.64) v9(153.39,107.38) v9(153.39,102.26) v9(153.39,100.33) v9(153.54,133.82) v9(153.64,129.01) v9(153.64,128.63) v9(153.66,125.05) v9(153.66,124.79) v9(153.62,116.25) v9(153.62,115.99) v9(153.64,113.1) v9(153.64,112.84) v9(153.64,107.64) v9(153.64,107.38) v9(153.62,103.24) v9(153.62,102.99) v9(153.86,136.95) v9(153.86,135.43) v9(154.8,136.44) v9(155.56,136.44) v9(156.32,136.44) v9(156.71,91.44) v9(157.09,136.44) v9(157.47,91.44) v9(157.85,136.44) v9(157.98,91.44) v9(158.61,136.44) v9(159.21,91.56) v9(159.37,136.44) v9(159.97,91.56) v9(160.13,136.44) v9(160.48,91.56) v9(160.9,136.44) v9(161.21,91.27) v9(161.66,136.44) v9(161.97,91.27) v9(162.42,136.44) v9(162.48,91.27) v9(163.03,91.48) v9(163.18,136.44) v9(163.79,91.48) v9(163.94,136.44) v9(164.3,91.48) v9(164.53,135.43) v9(164.53,133.9) v9(164.67,132.48) v9(164.71,136.44) v9(165.28,91.31) v9(165.29,135.43) v9(165.29,133.9) v9(165.47,136.44) v9(165.43,132.48) v9(166.05,135.43) v9(166.05,133.9) v9(165.99,92.75) v9(166.04,91.31) v9(166.23,136.44) v9(166.19,132.48) v9(166.55,91.31) v9(166.75,92.75) v9(166.95,132.48) v9(167.03,135.28) v9(167.26,92.75) v9(167.29,94.34) v9(167.72,132.48) v9(168.05,94.34) v9(168.56,94.34) v9(168.6,91.31) v9(168.8,130.04) v9(168.8,126.96) v9(168.8,126.71) v9(168.81,123.25) v9(168.81,122.87) v9(168.81,120.07) v9(168.81,119.69) v9(168.8,114.41) v9(168.8,113.9) v9(168.81,111.45) v9(168.81,110.94) v9(168.81,105.67) v9(168.81,105.42) v9(168.8,100.26) v9(168.8,99.75) v9(169.05,130.04) v9(169.05,126.96) v9(169.05,126.71) v9(169.06,123.25) v9(169.06,122.87) v9(169.06,120.07) v9(169.06,119.69) v9(169.05,114.41) v9(169.05,113.9) v9(169.06,111.45) v9(169.06,110.94) v9(169.06,105.67) v9(169.06,105.42) v9(169.05,100.26) v9(169.05,99.75) v9(169.1,96.66) v9(169.3,130.04) v9(169.31,126.96) v9(169.31,126.71) v9(169.32,123.25) v9(169.32,122.87) v9(169.31,120.07) v9(169.31,119.69) v9(169.31,114.41) v9(169.31,113.9) v9(169.31,111.45) v9(169.31,110.94) v9(169.31,105.67) v9(169.31,105.42) v9(169.31,100.26) v9(169.31,99.75) v9(169.36,91.31) v9(169.38,92.19) v9(169.87,91.31) v9(169.89,130.06) v9(170.14,130.06) v9(170.1,94.21) v9(170.15,92.19) v9(170.23,93.44) v9(170.4,130.06) v9(170.41,110.35) v9(170.44,110.02) v9(170.46,109.16) v9(170.46,108.85) v9(170.47,96.65) v9(170.53,103.96) v9(170.53,103.07) v9(170.51,102.13) v9(170.65,92.19) v9(170.74,110.38) v9(170.74,110.02) v9(170.77,109.18) v9(170.79,108.88) v9(170.86,94.21) v9(170.99,93.44) v9(171.37,94.21) v9(171.5,93.44) v9(171.9,96.65) v9(172.01,94.65) v9(172.03,91.31) v9(172.35,100.22) v9(172.77,94.65) v9(172.8,91.31) v9(172.94,92.44) v9(173.28,94.65) v9(173.23,94.13) v9(173.29,96.65) v9(173.3,91.31) v9(173.7,92.44) v9(173.82,114.9) v9(173.84,114.6) v9(173.94,104.61) v9(173.94,103.37) v9(173.99,94.13) v9(174.15,114.93) v9(174.15,114.62) v9(174.21,92.44) v9(174.44,96.65) v9(174.5,94.13) v9(174.59,103.98) v9(174.73,130.16) v9(175.18,104.57) v9(175.23,103.37) v9(175.34,91.27) v9(175.73,96.66) v9(175.82,94.04) v9(175.82,92.12) v9(175.99,100.22) v9(176.14,104.73) v9(176.14,104.23) v9(176.1,91.27) v9(176.58,92.12) v9(176.59,130.14) v9(176.61,91.27) v9(176.99,117.44) v9(177.06,99.61) v9(176.98,96.65) v9(177.09,94.04) v9(177.09,92.12) v9(177.93,91.23) v9(178.2,114.78) v9(178.24,95.01) v9(178.2,93.96) v9(178.29,118.35) v9(178.47,96.66) v9(178.49,110.56) v9(178.7,92.1) v9(178.69,91.23) v9(178.8,132.83) v9(178.95,94.75) v9(178.96,93.96) v9(179.23,105.67) v9(179.27,103.96) v9(179.2,91.23) v9(179.3,130.17) v9(179.44,133.86) v9(179.41,112.77) v9(179.47,93.96) v9(179.46,92.1) v9(179.52,96.65) v9(179.6,100.12) v9(179.72,132.69) v9(179.71,94.75) v9(179.97,92.1) v9(180.15,93.93) v9(180.28,137.37) v9(180.26,135.73) v9(180.22,94.75) v9(180.39,109.4) v9(180.75,134.01) v9(180.75,133.25) v9(180.75,132.48) v9(180.9,96.69) v9(180.91,93.93) v9(181.12,118.85) v9(181.13,107.53) v9(181.21,136.59) v9(181.21,135.82) v9(181.47,138.2) v9(181.41,112.9) v9(181.42,93.93) v9(181.55,94.91) v9(181.91,110.08) v9(182.06,96.65) v9(182.31,94.91) v9(182.54,140.86) v9(182.52,134.01) v9(182.52,133.25) v9(182.52,132.48) v9(182.65,143.55) v9(182.61,142.29) v9(182.82,94.91) v9(182.98,139.6) v9(183.26,136.86) v9(183.26,135.33) v9(183.44,96.69) v9(183.65,133.99) v9(183.65,133.23) v9(183.65,132.46) v9(183.59,103.52) v9(183.81,144.85) v9(183.81,143.32) v9(183.96,112.64) v9(183.95,108.42) v9(184.21,141.59) v9(184.4,139.78) v9(184.4,138.25) v9(184.43,137.14) v9(184.46,109.81) v9(184.58,135.75) v9(184.6,96.65) v9(184.82,143.48) v9(184.82,142.72) v9(184.89,105.42) v9(185.07,134.12) v9(185.07,133.36) v9(185.07,132.6) v9(185.01,116.67) v9(185.25,115.47) v9(185.87,125.25) v9(185.97,141.61) v9(185.9,136.13) v9(185.91,132.14) v9(185.91,131.76) v9(185.95,94.98) v9(186.07,96.67) v9(186.14,130.31) v9(186.28,136.13) v9(186.29,132.14) v9(186.29,131.76) v9(186.72,140.88) v9(186.71,94.98) v9(186.86,144.67) v9(186.88,122.99) v9(186.94,139.56) v9(187.01,110.06) v9(187.14,96.65) v9(187.22,94.98) v9(187.45,143.6) v9(187.39,113.22) v9(187.72,141.75) v9(187.72,140.23) v9(187.91,145.71) v9(188.14,144.36) v9(188.09,127.88) v9(188.44,141.04) v9(188.56,115.59) v9(188.65,142.12) v9(188.59,96.67) v9(188.66,93.91) v9(189.06,137.15) v9(189.22,130.66) v9(189.36,143.4) v9(189.35,142.17) v9(189.35,133.91) v9(189.42,93.91) v9(189.61,122.72) v9(189.68,96.65) v9(189.88,135.22) v9(189.93,93.91) v9(190.14,142.53) v9(190.32,146.07) v9(190.34,133.33) v9(190.55,143.75) v9(190.48,93.99) v9(190.93,96.67) v9(191.13,144.74) v9(191.2,142.69) v9(191.25,93.99) v9(191.4,115.63) v9(191.75,93.99) v9(191.82,147.36) v9(191.82,146.07) v9(192,143.88) v9(192.15,142.86) v9(192.13,96.66) v9(192.52,123.49) v9(192.7,93.99) v9(192.82,137.78) v9(192.94,98.97) v9(193.17,115.5) v9(193.2,135.24) v9(193.38,146.28) v9(193.28,134.25) v9(193.32,114.06) v9(193.31,96.66) v9(193.4,118.63) v9(193.4,117.48) v9(193.46,93.99) v9(193.62,148.07) v9(193.87,141.23) v9(193.87,139.71) v9(193.86,133.33) v9(193.87,132.66) v9(193.83,101.67) v9(193.83,98.04) v9(193.97,93.99) v9(194.26,146.93) v9(194.4,143.85) v9(194.4,142.32) v9(194.44,96.66) v9(194.49,149.14) v9(194.67,145.94) v9(194.58,104.91) v9(194.72,101.67) v9(194.72,98.03) v9(194.96,96.93) v9(195.02,116.41) v9(195.08,122.01) v9(195.27,147.87) v9(195.24,126.55) v9(195.22,124.07) v9(195.3,141.39) v9(195.45,145) v9(195.46,143.12) v9(195.59,137.25) v9(195.63,96.92) v9(195.86,139.66) v9(195.96,140.68) v9(195.96,116.41) v9(195.88,113.96) v9(195.91,111.98) v9(195.89,94.01) v9(196.17,148.78) v9(196.14,146.24) v9(196.27,142.46) v9(196.29,144.12) v9(196.31,96.93) v9(196.52,100.5) v9(196.52,99.61) v9(196.67,147.39) v9(196.65,94.01) v9(196.72,96.33) v9(196.82,111.98) v9(196.85,97.39) v9(196.98,114.45) v9(197.07,145.33) v9(197.09,141.81) v9(197.09,140.29) v9(197.1,94.97) v9(197.16,94.01) v9(197.64,146.37) v9(197.61,97.39) v9(197.69,96.32) v9(197.87,104.59) v9(197.86,94.97) v9(198.04,142.5) v9(198.09,126.53) v9(198.12,97.39) v9(198.21,124.07) v9(198.23,122.02) v9(198.26,119.4) v9(198.18,94.15) v9(198.34,138.99) v9(198.37,94.97) v9(198.7,96.32) v9(198.79,137.58) v9(198.81,100.75) v9(198.81,99.86) v9(198.95,94.15) v9(198.98,147.67) v9(199.11,145.33) v9(199.23,97.23) v9(199.32,99.65) v9(199.42,149.07) v9(199.42,94.99) v9(199.45,94.15) v9(199.73,96.32) v9(199.92,146.6) v9(200.08,99.65) v9(199.99,97.23) v9(200.1,144.49) v9(200.18,94.99) v9(200.45,94.04) v9(200.48,126.56) v9(200.5,97.23) v9(200.66,147.79) v9(200.63,124.13) v9(200.67,121.97) v9(200.59,99.65) v9(200.69,134.99) v9(200.7,131.02) v9(200.69,96.32) v9(200.69,94.99) v9(200.86,145.49) v9(200.81,119.46) v9(201.09,116.79) v9(201.16,114.09) v9(201.21,94.04) v9(201.38,97.36) v9(201.45,94.99) v9(201.55,148.99) v9(201.72,94.04) v9(202.14,97.36) v9(202.21,94.99) v9(202.49,147.49) v9(202.53,145.76) v9(202.65,97.36) v9(202.67,94.08) v9(202.73,96.27) v9(202.72,94.99) v9(202.88,102.31) v9(203.01,121.88) v9(203.21,119.14) v9(203.24,116.69) v9(203.44,113.96) v9(203.43,94.08) v9(203.59,97.47) v9(203.71,148.81) v9(203.77,102.3) v9(203.72,96.27) v9(203.77,95.05) v9(203.91,146.28) v9(203.96,144.82) v9(203.94,94.08) v9(204.08,122.98) v9(204.1,126.96) v9(204.1,126.41) v9(204.1,125.26) v9(204.35,97.47) v9(204.47,147.61) v9(204.53,95.05) v9(204.8,119.4) v9(204.8,116.59) v9(204.86,97.47) v9(204.84,96.26) v9(205.04,95.05) v9(205.73,145.3) v9(206.17,146.6) v9(206.37,96.23) v9(206.82,126.58) v9(206.82,125.82) v9(206.82,125.05) v9(206.98,147.34) v9(207.23,98.69) v9(207.23,97.91) v9(207.42,144.85) v9(207.52,96.23) v9(207.64,146.32) v9(207.82,125.82) v9(208.27,94.83) v9(208.6,120.32) v9(208.76,147.12) v9(208.75,96.22) v9(208.94,99.08) v9(208.94,98.82) v9(209.05,96.54) v9(209.04,94.83) v9(209.28,145.28) v9(209.58,130.8) v9(209.54,94.83) v9(209.65,148.17) v9(209.61,120.32) v9(209.69,143.89) v9(209.69,143.26) v9(209.97,141) v9(209.93,99.1) v9(209.93,98.85) v9(210.21,146.52) v9(210.24,126.18) v9(210.24,125.36) v9(210.24,96.55) v9(210.38,94.82) v9(210.62,116.4) v9(210.6,115.05) v9(211.05,145.05) v9(211.14,94.82) v9(211.23,148) v9(211.29,115.74) v9(211.65,94.82) v9(211.73,98.26) v9(211.91,146.29) v9(212.05,116.42) v9(212.04,115.03) v9(212.18,111.18) v9(212.24,94.91) v9(212.32,120.34) v9(212.37,98.5) v9(212.42,101.39) v9(212.46,96.2) v9(212.64,148.66) v9(212.85,147.36) v9(212.83,145.25) v9(213,94.91) v9(213.22,96.2) v9(213.58,144.67) v9(213.51,94.91) v9(213.61,144.01) v9(213.61,143.75) v9(213.73,110.2) v9(213.73,96.2) v9(213.87,146.24) v9(213.79,143.07) v9(213.79,142.81) v9(213.79,142.53) v9(213.97,132.81) v9(213.94,128.64) v9(213.94,128.39) v9(213.98,129.86) v9(213.98,129.28) v9(214.16,148.66) v9(214.12,140.38) v9(214.12,140.1) v9(214.12,139.79) v9(214.12,139.49) v9(214.12,139.18) v9(214.15,134.38) v9(214.1,131.55) v9(214.1,127.78) v9(214.1,127.5) v9(214.1,127.22) v9(214.13,120.34) v9(214.15,99.08) v9(214.2,147.47) v9(214.29,98.83) v9(214.5,126.46) v9(214.5,126.18) v9(214.5,125.85) v9(214.5,125.54) v9(214.5,125.24) v9(214.58,144.04) v9(214.58,142.51) v9(214.59,130.36) v9(214.77,135.56) v9(214.71,96.15) v9(214.87,110.95) v9(214.97,128.74) v9(214.91,106.89) v9(214.9,104.2) v9(215.04,146.29) v9(214.99,119.48) v9(215.04,99.08) v9(215.04,98.82) v9(215.09,132.91) v9(215.16,126.94) v9(215.44,131.38) v9(215.47,96.15) v9(215.55,94.62) v9(215.75,145.07) v9(215.75,143.55) v9(215.86,110.95) v9(215.8,106.89) v9(215.8,100.93) v9(215.95,134.51) v9(215.98,96.15) v9(216.03,104.24) v9(216,99.08) v9(216,98.82) v9(216.13,142.64) v9(216.1,135.84) v9(216.1,129.98) v9(216.1,128.45) v9(216.1,126.17) v9(216.33,132.81) v9(216.31,94.62) v9(216.35,92.04) v9(216.53,144.45) v9(216.69,100.93) v9(216.74,98.95) v9(216.86,126.94) v9(216.87,96.11) v9(217,98.56) v9(217.07,94.62) v9(216.99,93.17) v9(217.12,125.19) v9(217.14,104.22) v9(217.11,92.04) v9(217.27,136.87) v9(217.27,133.64) v9(217.26,125.43) v9(217.2,106.89) v9(217.35,131) v9(217.46,143.43) v9(217.42,135.17) v9(217.4,125.19) v9(217.5,98.95) v9(217.58,94.62) v9(217.6,125.9) v9(217.63,96.11) v9(217.76,98.56) v9(217.75,93.17) v9(217.86,128.89) v9(217.88,92.04) v9(218.04,138.35) v9(218.11,132.82) v9(218.11,127.47) v9(218.26,98.95) v9(218.27,98.56) v9(218.39,96.11) v9(218.38,92.04) v9(218.52,93.17) v9(218.64,135.83) v9(218.68,122.16) v9(218.66,119.82) v9(218.66,119.31) v9(218.66,119.06) v9(218.67,117.06) v9(218.67,111.46) v9(218.65,102.51) v9(218.65,102.26) v9(218.65,101.75) v9(218.77,131.59) v9(218.69,114.1) v9(218.68,108.91) v9(218.69,105.82) v9(218.94,125.31) v9(218.92,119.82) v9(218.92,119.31) v9(218.92,119.06) v9(218.92,117.06) v9(218.95,114.1) v9(218.92,111.46) v9(218.94,108.91) v9(218.94,105.82) v9(218.91,102.51) v9(218.91,102.26) v9(218.91,101.75) v9(218.96,100.53) v9(218.9,96.11) v9(219.02,93.17) v9(219.1,130.39) v9(219.17,119.82) v9(219.17,119.31) v9(219.17,119.06) v9(219.18,117.06) v9(219.18,111.46) v9(219.16,102.51) v9(219.16,102.26) v9(219.16,101.75) v9(219.2,114.1) v9(219.19,108.91) v9(219.2,105.82) v9(219.33,127.19) v9(219.44,100.4) v9(219.44,98.62) v9(219.48,128.87) v9(219.54,94.15) v9(219.5,92.08) v9(219.58,133.11) v9(219.59,123.69) v9(219.59,121.4) v9(219.59,119.88) v9(219.72,134.6) v9(219.69,96.58) v9(219.9,136.08) v9(220.17,130.67) v9(220.17,120.59) v9(220.12,101.14) v9(220.16,99.73) v9(220.26,92.08) v9(220.35,125.97) v9(220.35,122.93) v9(220.3,94.15) v9(220.45,96.58) v9(220.67,129.56) v9(220.7,115.74) v9(220.78,112.82) v9(220.73,104.82) v9(220.83,110.58) v9(220.85,107.48) v9(220.95,115.74) v9(220.98,104.82) v9(220.88,101.14) v9(220.92,99.73) v9(221.01,133.47) v9(221.03,112.82) v9(221.06,94.15) v9(221.03,92.08) v9(221.08,131.46) v9(221.08,127.02) v9(221.11,120.64) v9(221.08,110.58) v9(221.11,107.48) v9(221.21,115.74) v9(221.23,104.82) v9(221.21,96.58) v9(221.34,125.72) v9(221.28,112.82) v9(221.34,110.58) v9(221.36,107.48) v9(221.44,124.75) v9(221.39,119.32) v9(221.39,101.14) v9(221.43,99.73) v9(221.57,94.15) v9(221.53,92.08) v9(221.62,121.4) v9(221.72,134.79) v9(221.74,130.44) v9(221.69,128.06) v9(221.72,96.58) v9(222.15,126.48) v9(222.2,131.43) v9(222.25,129.15) v9(222.28,123.94) v9(222.3,133.72) v10(189.82,135.24) v10(193.32,134.24) v11(20.94,120.53) v11(31.78,40.2) v11(32.84,38.27) v11(33.35,43.84) v11(34.87,46.73) v11(35.36,43.61) v12(16.92,144.72) v12(50.77,97.42) v12(51.47,103.56) v12(52.19,103.57) v12(54.61,103.97) v12(54.69,127.32) v12(55.83,123.05) v12(56.08,123.05) v12(56.29,122.13) v12(56.64,110.48) v12(57.28,108.68) v12(60.61,123.61) v12(60.61,110.34) v12(61.13,112.14) v12(61.44,97.13) v12(61.52,109.43) v12(61.78,139.28) v12(61.78,135.78) v12(61.78,134.28) v12(61.78,133.28) v12(62.28,139.78) v12(62.28,134.78) v12(62.78,135.28) v12(62.78,134.78) v12(63.28,138.28) v12(63.28,136.78) v12(63.28,135.28) v12(63.28,133.28) v12(63.28,131.78) v12(63.78,139.78) v12(63.78,137.78) v12(63.78,134.28) v12(64.28,139.78) v12(64.28,136.78) v12(64.28,135.28) v12(64.28,134.28) v12(64.28,133.78) v12(64.28,133.28) v12(64.28,131.78) v12(64.36,106.68) v12(64.78,138.28) v12(64.78,137.28) v12(64.78,133.78) v12(65.06,115.66) v12(65.28,133.78) v12(65.4,128.77) v12(65.56,115.66) v12(65.61,106.68) v12(65.78,139.78) v12(65.78,133.78) v12(66.28,138.78) v12(66.28,138.28) v12(66.28,137.28) v12(66.28,133.78) v12(66.55,117.34) v12(66.78,139.28) v12(66.78,138.78) v12(66.78,133.78) v12(66.78,131.78) v12(67.05,119.02) v12(67.05,117.9) v12(67.28,139.78) v12(67.28,133.78) v12(67.28,131.78) v12(67.78,136.28) v12(67.78,135.78) v12(67.78,135.28) v12(67.78,134.78) v12(67.78,134.28) v12(67.78,133.78) v12(68.04,119.58) v12(68.04,118.46) v12(68.04,117.34) v12(68.28,139.78) v12(68.28,138.28) v12(68.28,133.28) v12(68.28,132.78) v12(68.28,132.28) v12(68.28,131.78) v12(68.78,133.28) v12(68.78,132.28) v12(68.78,131.78) v12(69.03,119.58) v12(69.03,118.46) v12(69.03,117.34) v12(69.03,116.22) v12(69.03,115.1) v12(69.03,113.99) v12(69.03,112.87) v12(69.28,133.28) v12(69.28,132.78) v12(69.28,131.78) v12(69.78,137.28) v12(69.78,135.28) v12(69.78,133.78) v12(69.78,133.28) v12(70.02,119.58) v12(70.02,118.46) v12(70.02,117.34) v12(70.89,110.44) v12(71.01,119.58) v12(71.01,118.46) v12(71.01,117.34) v12(71.01,115.11) v12(71.01,113.99) v12(71.01,112.87) v12(71.53,110.44) v12(72,119.58) v12(72,118.46) v12(72,117.34) v12(72,115.1) v12(72,113.99) v12(72,112.87) v12(72.82,110.44) v12(72.97,105.2) v12(72.99,117.34) v12(72.99,116.22) v12(72.99,113.99) v12(73.46,110.44) v12(73.98,119.58) v12(73.98,118.46) v12(73.98,115.1) v12(73.98,113.99) v12(74.11,110.44) v12(75.4,110.44) v12(75.96,116.22) v12(75.96,115.11) v12(75.96,113.99) v12(76.04,110.44) v12(76.68,110.44) v12(77.97,123.01) v12(78.08,122.61) v12(78.8,123.23) v12(78.96,122.77) v12(78.96,122.13) v12(84.89,130.29) v12(84.89,129.29) v12(84.89,126.79) v12(84.89,126.29) v12(84.89,125.29) v12(85.39,125.29) v12(85.89,125.29) v12(86.39,131.79) v12(86.39,130.29) v12(86.39,129.29) v12(86.64,98.63) v12(86.89,129.29) v12(86.89,128.79) v12(86.89,128.29) v12(86.89,126.79) v12(86.89,123.79) v12(87.11,101.39) v12(87.39,131.79) v12(87.39,129.79) v12(87.39,129.29) v12(87.89,131.29) v12(87.89,130.79) v12(88.39,130.79) v12(88.39,130.29) v12(88.39,129.29) v12(88.39,123.79) v12(88.89,131.79) v12(88.89,125.79) v12(89.39,125.79) v12(89.89,130.29) v12(89.89,129.29) v12(89.89,125.79) v12(90.39,131.79) v12(90.39,128.79) v12(90.39,127.29) v12(90.39,126.29) v12(90.39,125.79) v12(90.39,125.29) v12(90.39,123.79) v12(90.89,129.79) v12(90.89,126.29) v12(91.39,130.29) v12(91.39,128.79) v12(91.39,127.29) v12(91.39,125.29) v12(91.39,123.79) v12(91.89,131.79) v12(91.89,131.29) v12(91.89,127.29) v12(91.89,126.79) v12(92.39,130.79) v12(92.39,126.79) v12(92.89,130.79) v12(92.89,129.79) v12(92.89,129.29) v12(92.89,127.79) v12(92.89,126.29) v12(92.89,125.29) v12(101,139.03) v12(101,130.93) v12(101.3,139.03) v12(101.3,130.93) v12(101.61,139.03) v12(101.61,130.93) v12(110.46,121.2) v12(110.44,120.21) v12(110.44,118.18) v12(110.49,119.19) v12(110.72,121.2) v12(110.69,120.21) v12(110.74,119.19) v12(110.69,118.18) v12(110.97,121.2) v12(110.95,120.21) v12(110.95,118.18) v12(111,119.19) v12(111.33,121.2) v12(111.33,120.2) v12(111.33,119.2) v12(111.33,118.2) v12(112.83,119.7) v12(112.83,119.2) v12(114.83,121.2) v12(114.83,120.2) v12(193.32,135.24) v12(193.32,133.74) v12(194.32,134.74) v13(0.43,52.9) v13(0.44,50.46) v13(0.43,47.82) v13(0.46,45.27) v13(0.43,42.74) v13(0.5,55.51) v13(0.51,21.45) v13(0.51,18.91) v13(0.51,16.37) v13(0.51,13.83) v13(0.51,11.29) v13(1.45,8.97) v13(1.78,124.56) v13(1.77,115.89) v13(1.8,118.43) v13(2.23,113.12) v13(2.77,22.1) v13(2.84,25.02) v13(3.37,123.33) v13(3.3,119.27) v13(3.4,8.74) v13(3.62,56.72) v13(4.06,143.79) v13(4.03,142.39) v13(4.03,113.1) v13(4.13,121.25) v13(4.33,136.09) v13(5.08,134) v13(5.06,131.38) v13(5.25,157.26) v13(6.03,113.08) v13(6.16,56.72) v13(6.69,159.3) v13(7.54,161.5) v13(7.82,165.72) v13(7.81,163.53) v13(8.7,56.72) v13(9.56,166.47) v13(10.46,49.49) v13(11.15,129.53) v13(11.12,56.7) v13(11.25,132.1) v13(11.23,130.83) v13(11.23,128.56) v13(11.24,7.39) v13(11.77,144.57) v13(11.77,143.93) v13(11.81,52.29) v13(11.84,51.26) v13(11.96,166.46) v13(11.93,4.33) v13(12.02,5.79) v13(12.27,49.42) v13(12.39,132.04) v13(12.47,130.88) v13(12.55,129.53) v13(12.6,128.56) v13(13.25,164.44) v13(13.28,162.07) v13(13.53,159.51) v13(13.51,132.04) v13(13.56,130.85) v13(13.61,129.56) v13(13.66,128.59) v13(13.78,56.72) v13(13.84,7.44) v13(14.18,157.17) v13(14.42,128.56) v13(14.5,132.02) v13(14.5,130.85) v13(14.49,129.53) v13(14.97,7.84) v13(15,10.56) v13(15,5.48) v13(15.23,155.65) v13(15.85,114.54) v13(16.41,57.18) v13(16.45,12.18) v13(16.76,109.24) v13(16.76,106.7) v13(16.76,104.16) v13(16.76,101.62) v13(16.76,99) v13(16.76,96.54) v13(16.78,93.98) v13(16.76,91.46) v13(16.76,88.92) v13(16.76,86.38) v13(16.76,83.84) v13(16.76,81.3) v13(16.76,78.76) v13(16.76,76.22) v13(16.76,73.68) v13(16.76,71.14) v13(16.76,68.6) v13(16.78,66.14) v13(16.76,64.02) v13(16.76,62.44) v13(16.78,61.06) v13(16.76,58.94) v13(17.11,113.83) v13(17.25,154.71) v13(17.2,13.35) v13(17.78,111.89) v13(17.84,15.28) v13(18.35,146.51) v13(18.78,12.19) v13(19.15,154.64) v13(19.51,13.43) v13(19.64,14.89) v13(20.17,136.07) v13(21.04,154.67) v13(21.02,12.18) v13(21.92,148.69) v13(22.2,13.25) v13(23.35,148.65) v13(23.58,154.67) v13(23.63,146.83) v13(23.67,12.19) v13(24.02,137.65) v13(24.46,150.45) v13(24.69,148.07) v13(25.26,152.27) v13(25.29,146.33) v13(25.46,144.85) v13(25.75,150.47) v13(26.12,154.67) v13(26.1,12.18) v13(26.67,76.52) v13(26.67,75.33) v13(26.7,74.36) v13(26.7,73.55) v13(26.86,145.88) v13(27,140.95) v13(27.15,149.09) v13(27.38,147.3) v13(27.7,151.08) v13(28.07,75.33) v13(28.12,74.36) v13(28.14,73.52) v13(28.66,154.67) v13(29.48,152.18) v13(29.46,75.3) v13(29.44,74.36) v13(29.41,73.5) v13(29.77,143.36) v13(31.12,150.86) v13(31.2,154.67) v13(31.27,152.06) v13(31.79,145.82) v13(32.96,12.18) v13(33.11,149.23) v13(33.26,16.34) v13(33.21,13.5) v13(33.74,154.67) v13(34.47,82.77) v13(34.47,81.85) v13(34.49,80.86) v13(34.61,15.99) v13(34.74,12.18) v13(35.07,14.79) v13(35.56,82.77) v13(35.53,81.85) v13(35.59,80.86) v13(36.15,151.37) v13(36.28,154.67) v13(36.56,17.18) v13(36.68,80.84) v13(36.78,82.74) v13(36.7,81.85) v13(37.1,12.19) v13(37.77,80.81) v13(37.87,81.93) v13(37.79,18.19) v13(37.92,82.74) v13(38.11,24.02) v13(38.6,17.3) v13(38.82,154.67) v13(38.85,21.49) v13(39.29,23.68) v13(39.45,22.55) v13(39.55,20.82) v13(39.76,17.22) v13(39.82,12.18) v13(40.27,21.69) v13(40.24,13.8) v13(40.39,24.02) v13(41.36,154.67) v13(41.79,15.32) v13(42.34,12.19) v13(42.76,13.63) v13(43.04,16.67) v13(43.9,154.67) v13(44.9,12.18) v13(45.12,88.99) v13(45.75,83.84) v13(45.75,81.3) v13(45.75,78.76) v13(45.75,76.22) v13(45.75,73.68) v13(45.75,71.14) v13(45.75,68.6) v13(45.75,65.66) v13(45.75,63.52) v13(45.75,60.86) v13(45.75,58.44) v13(45.71,55.93) v13(45.75,53.36) v13(45.75,50.82) v13(45.75,48.28) v13(45.75,45.74) v13(45.75,43.2) v13(45.75,40.66) v13(45.75,38.12) v13(45.75,35.58) v13(45.75,33.04) v13(45.75,30.5) v13(45.75,27.96) v13(45.75,25.42) v13(45.75,22.88) v13(45.75,20.34) v13(45.75,17.8) v13(45.75,15.26) v13(45.73,13.44) v13(46,88.38) v13(46.44,154.67) v13(47.66,88.99) v13(48.98,154.67) v13(50.2,88.99) v13(51.52,154.67) v13(52.74,88.99) v13(54.06,154.67) v13(55.28,88.99) v13(56.6,154.67) v13(57.82,88.99) v13(59.14,154.67) v13(60.36,88.99) v13(61.68,154.67) v13(62.9,88.99) v13(64.22,154.67) v13(65.44,88.99) v13(67.98,88.99) v13(70.52,88.99) v13(72,146.61) v13(73.06,88.99) v13(74.9,139.35) v13(75.6,88.99) v13(76.29,139.11) v13(77.7,139.11) v13(78.14,88.99) v13(79.5,139.11) v13(80.67,139.11) v13(80.68,88.99) v13(81.74,139.11) v13(83.08,139.11) v13(83.22,88.99) v13(84.43,139.11) v13(85.69,139.23) v13(85.76,88.99) v13(87.02,139.46) v13(87.16,89) v13(88.35,139.61) v13(89.41,139.61) v13(90.64,139.61) v13(91.86,139.62) v13(93.31,139.61) v13(94.49,139.61) v13(95.78,139.61) v13(96.94,139.62) v13(96.91,91.57) v13(98.2,139.61) v13(98.68,90.28) v13(99.48,139.62) v13(100.74,139.61) v13(101.22,90.28) v13(101.92,139.61) v13(103.76,90.28) v13(104.72,139.59) v13(105.94,139.55) v13(106.3,90.28) v13(106.58,138.61) v13(108.3,138.17) v13(109.56,138.15) v13(110.84,138.17) v13(112.17,138.15) v13(113.38,138.17) v13(114.71,138.15) v13(115.92,138.17) v13(117.18,138.15) v13(118.28,90.28) v13(118.46,138.17) v13(119.72,138.15) v13(120.82,90.28) v13(121,138.17) v13(122.26,138.15) v13(123.36,90.28) v13(123.54,138.17) v13(124.55,138.15) v13(125.39,137.96) v13(125.56,137.01) v13(125.83,135.99) v13(125.9,90.28) v13(126.39,135.11) v13(127.22,134.44) v13(128.44,90.28) v13(128.49,133.96) v13(129.9,133.92) v13(130.98,90.28) v13(131.22,134.22) v13(132.17,134.91) v13(132.99,136.06) v13(133.38,137.07) v13(133.52,90.28) v13(134.01,137.9) v13(135.51,138.14) v13(136.06,90.28) v13(136.8,138.15) v13(138.4,138.17) v13(138.6,90.28) v13(139.66,138.15) v13(140.94,138.17) v13(141.14,90.28) v13(142.2,138.15) v13(143.48,138.17) v13(143.68,90.28) v13(144.81,138.15) v13(146.02,138.17) v13(146.22,90.28) v13(147.28,138.15) v13(148.56,138.17) v13(148.76,90.28) v13(149.82,138.15) v13(151.1,138.17) v13(151.3,90.28) v13(152.36,138.15) v13(153.64,138.17) v13(153.84,90.28) v13(154.97,138.15) v13(156.18,138.17) v13(156.38,90.28) v13(157.44,138.15) v13(158.72,138.17) v13(158.92,90.28) v13(159.98,138.15) v13(161.26,138.17) v13(161.46,90.28) v13(162.59,138.15) v13(163.8,138.17) v13(164,90.28) v13(164.87,138.15) v13(165.96,138.17) v13(166.54,90.28) v13(167.09,138.15) v13(168.12,138.17) v13(169.08,90.28) v13(169.38,138.15) v13(170.46,138.17) v13(171.62,90.28) v13(174.16,90.28) v13(176.7,90.28) v13(179.24,90.28) v13(180.06,138.13) v13(182.57,141.68) v13(182.65,144.22) v13(182.76,147.19) v13(182.73,145.38) v13(189.67,92.97) v13(190.78,152.63) v13(191.33,92.99) v13(192.43,151.3) v13(193.09,92.98) v13(193.19,150.28) v13(193.32,152.63) v13(194.97,151.3) v13(195.63,92.98) v13(195.86,152.63) v13(195.99,150.28) v13(197,151.3) v13(198.17,92.98) v13(198.4,152.63) v13(200.71,92.98) v13(202.91,152.61) v13(203.1,151.04) v13(203.25,92.98) v13(204.98,152.64) v13(205.05,137.85) v13(205.64,151.04) v13(205.68,137.88) v13(205.79,92.98) v13(206.83,152.67) v13(207.67,151.04) v13(208.33,92.98) v13(209.22,94.33) v13(209.37,152.67) v13(209.7,151.04) v13(210.21,149.52) v13(210.87,92.98) v13(211.73,151.04) v13(211.91,152.67) v13(212.24,149.52) v13(212.83,94.17) v13(213.41,92.98) v13(213.77,151.04) v13(214.45,152.67) v13(215.04,149.52) v13(215.09,148.05) v13(215.15,91.35) v13(215.8,151.04) v13(215.95,92.98) v13(216.05,146.47) v13(216.62,90.28) v13(216.99,152.67) v13(217.07,149.52) v13(217.07,148) v13(217.53,145.13) v13(217.83,151.04) v13(218.08,146.47) v13(219.01,90.3) v13(219.1,149.52) v13(219.1,148) v13(219.1,144.8) v13(219.1,139.61) v13(219.23,142.05) v13(219.53,152.67) v13(219.86,146.55) v13(220.88,148.07) v13(220.88,144.03) v13(220.88,138.34) v13(220.88,136.06) v13(221.01,151.02) v13(221.01,140.78) v13(221.03,92.98) v13(221.49,101.64) v13(221.49,99.13) v13(221.7,90.28) v13(222.49,152.39) v13(222.65,150.48) v13(222.65,147.94) v13(222.65,145.4) v13(222.65,142.86) v13(222.65,140.32) v13(222.65,137.78) v13(222.65,135.24) v13(222.65,132.7) v13(222.65,130.16) v13(222.65,127.62) v13(222.65,125.08) v13(222.65,122.54) v13(222.65,120) v13(222.65,117.46) v13(222.65,114.92) v13(222.65,112.38) v13(222.65,109.84) v13(222.65,107.3) v13(222.65,104.76) v13(222.65,102.22) v13(222.65,99.68) v13(222.63,98.3) v13(222.63,96.64) v13(222.65,93.97) v13(222.62,91.98) v15(7.26,121.12) v15(7.44,120.11) v15(13.39,135.17) v15(13.64,142.74) v15(14.05,135.77) v15(14,123.1) v15(14.43,124.78) v15(14.4,121.4) v15(14.88,121.38) v15(15.06,144.08) v15(15.06,143.25) v15(15.06,142.48) v15(15.04,140.78) v15(15.04,140.15) v15(15.06,139.41) v15(15.06,138.7) v15(15.06,137.89) v15(15.04,124.17) v15(15.06,120.18) v15(15.24,22.57) v15(15.32,25.28) v15(15.57,53.27) v15(15.57,43.18) v15(15.62,135.12) v15(15.75,137.51) v15(15.95,120.16) v15(15.98,22.57) v15(16.03,25.75) v15(16.03,16.6) v15(16.01,15.68) v15(16.18,44.24) v15(16.1,14.99) v15(16.26,135.12) v15(16.26,25.57) v15(16.36,142.1) v15(16.48,44.24) v15(16.66,137.51) v15(16.64,123.99) v15(16.61,43.91) v15(16.71,22.57) v15(16.79,44.24) v15(17.02,43.88) v15(16.99,25.75) v15(17.12,120.18) v15(17.09,44.24) v15(17.27,52.8) v15(17.22,25.57) v15(17.42,22.57) v15(17.55,137.53) v15(17.6,52.8) v15(17.75,105.58) v15(17.75,105.15) v15(17.81,105.96) v15(17.88,137.02) v15(17.91,136.11) v15(17.93,135.22) v15(17.91,134.36) v15(17.91,133.34) v15(17.93,132.45) v15(17.93,131.46) v15(17.96,130.57) v15(17.93,129.45) v15(17.93,128.36) v15(17.96,127.35) v15(17.93,125.44) v15(17.93,124.4) v15(17.91,122.47) v15(17.96,120.46) v15(17.93,44.21) v15(17.93,43.93) v15(17.91,25.72) v15(17.98,126.33) v15(18.13,153.8) v15(18.13,153.3) v15(18.13,152.81) v15(18.15,152.36) v15(18.15,151.87) v15(18.16,25.57) v15(18.16,22.57) v15(18.34,28.79) v15(18.47,29.07) v15(18.44,22.57) v15(18.59,28.8) v15(18.74,29.07) v15(18.85,28.82) v15(18.97,21.17) v15(18.93,20.42) v15(18.94,20.02) v15(19.08,22.52) v15(19.24,95.37) v15(19.3,130.44) v15(19.34,84.57) v15(19.38,22.52) v15(19.46,32.32) v15(19.46,32.04) v15(19.46,31.79) v15(19.61,129.2) v15(19.62,116.45) v15(19.66,58.69) v15(19.74,83.8) v15(19.84,116.94) v15(19.95,84.57) v15(20.01,117.43) v15(19.99,58.69) v15(20.14,129.24) v15(20.27,22.55) v15(20.29,58.69) v15(20.47,55.44) v15(20.55,22.55) v15(20.6,129.23) v15(20.74,57.59) v15(20.73,55.44) v15(20.98,105.2) v15(21.01,105.91) v15(21,105.58) v15(21,91.13) v15(21.11,27.8) v15(21.22,129.39) v15(21.18,128.37) v15(21.2,22.46) v15(21.36,79.29) v15(21.36,78.34) v15(21.38,78.85) v15(21.41,27.83) v15(21.46,22.55) v15(21.74,128.4) v15(23.07,14.79) v15(23.09,16.56) v15(23.09,15.67) v15(23.43,104.25) v15(23.43,104) v15(23.43,103.75) v15(23.55,130.83) v15(23.49,128.34) v15(23.49,127.42) v15(23.49,126.63) v15(23.52,123.97) v15(23.52,122.93) v15(23.55,121.66) v15(23.52,114.47) v15(23.49,110.63) v15(23.5,109.99) v15(23.52,107.46) v15(24.16,72.66) v15(24.21,74.89) v15(24.21,73.01) v15(24.31,71.08) v15(24.54,107.41) v15(24.71,119.24) v15(24.71,109.43) v15(24.84,119.47) v15(24.97,119.24) v15(24.92,17.08) v15(25.07,127.83) v15(25.07,127.55) v15(24.99,119.7) v15(25.03,104.77) v15(25.12,119.47) v15(25.27,119.7) v15(25.25,119.24) v15(25.4,119.47) v15(25.53,119.7) v15(25.51,109.62) v15(25.65,119.47) v15(25.78,119.7) v15(25.79,109.62) v15(25.91,119.47) v15(26.03,119.7) v15(26.1,127.31) v15(26.09,86.55) v15(26.3,127.5) v15(26.31,37.19) v15(26.4,115.24) v15(26.44,43.86) v15(26.57,121.08) v15(26.57,84.83) v15(26.57,83.02) v15(26.5,41.51) v15(26.5,36.17) v15(26.64,118.7) v15(26.76,46.14) v15(26.7,39.09) v15(26.82,42.9) v15(26.92,121.1) v15(26.95,44.62) v15(27.02,118.7) v15(27.19,127.39) v15(27.27,60.8) v15(27.25,58.61) v15(27.28,35.58) v15(27.32,56.73) v15(27.33,31.77) v15(27.44,127.39) v15(27.41,118.7) v15(27.46,59.79) v15(27.55,131.04) v15(27.7,127.39) v15(27.77,121.04) v15(27.79,123.12) v15(27.95,127.39) v15(27.92,116.65) v15(28.03,49.13) v15(28.03,35.54) v15(28.1,115.46) v15(28.14,113.32) v15(28.21,127.39) v15(28.31,115.27) v15(28.3,86.58) v15(28.46,127.39) v15(28.53,110.7) v15(28.81,124.16) v15(28.82,123.87) v15(29.03,104.77) v15(28.99,49.93) v15(28.98,47.98) v15(29.11,84.83) v15(29.16,36.03) v15(29.45,112.14) v15(29.46,33.9) v15(29.62,122.19) v15(29.62,121.41) v15(29.67,81.4) v15(29.7,112.14) v15(29.82,56.73) v15(29.87,49.13) v15(29.99,55.08) v15(30.17,129.76) v15(30.11,53.21) v15(30.56,131.08) v15(30.53,104.74) v15(30.91,86.58) v15(31.08,50.03) v15(31.52,35.28) v15(31.7,131.13) v15(32.03,104.77) v15(32.03,47.86) v15(32.13,79.57) v15(32.21,81.4) v15(32.28,53.32) v15(32.38,83.51) v15(32.41,54.59) v15(32.47,35.16) v15(32.52,58.87) v15(32.71,131.1) v15(33.36,47.86) v15(33.53,104.18) v15(33.81,131.08) v15(33.91,78.2) v15(34.11,74.26) v15(34.47,83.73) v15(34.8,131.08) v15(34.89,48.68) v15(35.03,104.77) v15(35.27,47.86) v15(35.38,107.48) v15(35.98,48.35) v15(35.99,131.08) v15(36.3,114.57) v15(36.3,114.29) v15(36.3,114.01) v15(36.47,83.76) v15(36.45,78.2) v15(36.58,107.46) v15(36.52,104.77) v15(37.46,13.12) v15(37.51,15.44) v15(37.57,14.08) v15(37.72,107.43) v15(37.93,108.97) v15(38.03,104.77) v15(38.73,107.33) v15(38.76,66.89) v15(39.71,35.28) v15(40.03,121.83) v15(40.16,122.09) v15(40.23,66.64) v15(40.34,121.9) v15(40.54,121.71) v15(40.74,121.34) v15(40.79,122.98) v15(40.79,122.72) v15(41.03,104.77) v15(41.17,122.98) v15(41.17,122.72) v15(41.08,121.34) v15(41.3,122.09) v15(41.3,121.71) v15(41.43,121.34) v15(41.68,122.09) v15(41.68,121.71) v15(41.78,121.34) v15(41.97,111.74) v15(42.09,122.97) v15(42.09,122.72) v15(42.14,121.35) v15(42.25,122.06) v15(42.25,121.69) v15(42.52,105.4) v15(43.02,123.21) v15(43.03,105.37) v15(43.28,123.21) v15(43.69,103.19) v15(43.99,103.19) v15(44.13,104.61) v15(44.13,104.3) v15(44.13,104) v15(44.3,103.19) v15(44.43,15.48) v15(44.42,14.3) v15(44.54,13.22) v15(44.78,122.44) v15(44.86,124.55) v15(44.86,123.28) v15(44.86,120.11) v15(44.83,108.47) v15(44.88,119.17) v15(45.07,113.55) v15(45.06,112.54) v15(45.9,131.33) v15(45.93,130.13) v15(45.9,127.7) v15(45.9,122.62) v15(45.9,121.35) v15(45.97,117.03) v15(45.9,116.27) v15(45.9,114.85) v15(45.9,113.73) v15(45.9,112.46) v15(45.9,111.19) v15(45.9,109.92) v15(45.9,108.65) v15(45.9,107.38) v15(45.9,104.84) v15(46.08,130.8) v15(46.05,120.44) v15(46.17,118.38) v15(46.15,103.22) v15(46.1,99.43) v15(46.18,96.71) v15(46.2,95.34) v15(46.35,120.44) v15(46.32,117.11) v15(46.41,130.24) v15(46.41,127.7) v15(46.41,122.62) v15(46.41,121.35) v15(46.43,118.38) v15(46.41,116.27) v15(46.43,114.87) v15(46.41,113.73) v15(46.41,112.46) v15(46.41,111.19) v15(46.41,109.92) v15(46.41,108.93) v15(46.41,107.38) v15(46.66,131.31) v15(46.66,130.8) v15(46.94,138.14) v15(47.2,142.64) v15(47.22,141.14) v15(47.22,139.64) v15(48.01,106.87) v15(48.01,106.59) v15(48.16,96.05) v15(48.51,98.01) v15(48.54,96.05) v15(48.61,131.3) v15(48.6,99.91) v15(48.6,99.18) v15(48.69,126.38) v15(48.73,101.29) v15(48.77,98.01) v15(50.03,131.24) v15(50.06,130.8) v15(51.33,131.31) v15(51.33,130.8) v15(51.97,126.79) v15(52.1,126.47) v15(52.21,99.84) v15(52.21,98.82) v15(52.21,97.81) v15(52.53,93.94) v15(52.64,131.3) v15(52.63,130.81) v15(53.01,153.48) v15(52.98,132.78) v15(53.23,99.84) v15(53.23,98.82) v15(53.23,97.81) v15(53.29,130.8) v15(53.39,133.08) v15(53.41,122.88) v15(53.49,153.46) v15(53.64,131.33) v15(53.85,115.71) v15(54,153.46) v15(54,109.95) v15(54,109.44) v15(54,108.93) v15(54.24,99.84) v15(54.24,98.82) v15(54.24,97.81) v15(54.2,93.94) v15(54.51,153.36) v15(54.58,110.71) v15(54.76,152.39) v15(54.76,150.89) v15(54.76,149.39) v15(54.74,147.89) v15(54.78,140.89) v15(54.76,139.39) v15(54.81,107.28) v15(54.81,106.77) v15(55.08,131.31) v15(55.07,130.81) v15(55.17,153.41) v15(55.26,107.8) v15(55.26,99.84) v15(55.26,98.82) v15(55.26,97.81) v15(55.42,94.15) v15(56.27,99.84) v15(56.27,98.82) v15(56.27,97.81) v15(56.34,128.04) v15(56.41,130.8) v15(56.87,140.86) v15(56.87,139.59) v15(56.87,137.23) v15(56.9,143.32) v15(56.9,142.05) v15(56.9,138.29) v15(56.92,133.24) v15(56.92,128.04) v15(56.95,126.79) v15(56.92,122.13) v15(57,135.96) v15(57.02,134.71) v15(57.02,112.81) v15(57.1,128.82) v15(57.28,134.53) v15(57.23,133.24) v15(57.38,140.86) v15(57.38,139.59) v15(57.38,138.32) v15(57.38,137.23) v15(57.38,135.96) v15(57.29,99.84) v15(57.29,98.82) v15(57.29,97.81) v15(57.4,143.32) v15(57.4,142.05) v15(57.45,128.11) v15(57.48,118.02) v15(57.56,122.07) v15(57.68,150.03) v15(57.81,112.5) v15(57.96,118.77) v15(58,115.48) v15(58,114.87) v15(58,114.26) v15(58.07,112.5) v15(58.32,144.72) v15(58.32,144.24) v15(58.31,99.84) v15(58.31,98.82) v15(58.31,97.81) v15(58.45,103.85) v15(58.48,141.77) v15(58.48,140.01) v15(58.5,138.23) v15(58.5,136.44) v15(58.55,118.77) v15(58.55,112.51) v15(59.18,103.48) v15(59.54,144.72) v15(59.54,144.21) v15(60.43,143.12) v15(60.81,144.72) v15(60.81,144.21) v15(60.93,129.56) v15(60.93,129.28) v15(61.16,129.4) v15(61.55,105.85) v15(61.49,105.43) v15(62.08,144.72) v15(62.08,144.21) v15(62.18,143.14) v15(62.76,101.26) v15(62.76,101.01) v15(63.35,144.72) v15(63.35,144.21) v15(63.98,143.14) v15(64.06,95.27) v15(64.29,95.14) v15(64.39,101.64) v15(64.39,101.39) v15(64.43,98.4) v15(64.62,144.72) v15(64.62,144.21) v15(64.92,95.58) v15(65.2,99.2) v15(65.2,98.4) v15(65.56,101.64) v15(65.56,101.39) v15(65.89,144.72) v15(65.89,144.21) v15(65.96,98.4) v15(66.04,143.02) v15(66.37,95.14) v15(66.4,101.67) v15(66.4,101.41) v15(66.62,95.14) v15(66.98,107.46) v15(67.07,106.86) v15(67.16,144.72) v15(67.16,144.21) v15(67.28,99.31) v15(68.33,99.99) v15(68.43,144.72) v15(68.43,144.21) v15(68.42,102.91) v15(68.42,102.66) v15(68.45,100.95) v15(68.91,143.09) v15(68.91,95.53) v15(69.7,144.72) v15(69.7,144.21) v15(70.74,96.15) v15(70.8,143.12) v15(70.97,144.72) v15(70.97,144.21) v15(71.58,106.19) v15(71.83,99.99) v15(72.24,144.72) v15(72.24,144.21) v15(72.26,105.5) v15(72.26,104.92) v15(72.26,104.64) v15(72.26,103.11) v15(72.26,102.83) v15(72.29,103.98) v15(72.29,103.7) v15(72.36,95.51) v15(72.44,105.7) v15(73.18,141.9) v15(73.18,136.95) v15(73.2,144.03) v15(73.2,140.81) v15(73.41,133.11) v15(73.55,134.81) v15(73.51,130.42) v15(73.62,95.52) v15(73.71,144.03) v15(73.69,142.09) v15(73.69,140.28) v15(74.28,139.7) v15(74.27,96.26) v15(74.98,105.35) v15(75.15,138.86) v15(75.19,98.52) v15(75.83,135.14) v15(75.94,128.31) v15(75.94,128.04) v15(75.94,127.74) v15(76.15,95.71) v15(76.2,104.41) v15(76.2,104.16) v15(76.48,136.72) v15(76.48,136.21) v15(77.24,105.2) v15(77.24,104.94) v15(77.64,99.12) v15(77.75,136.72) v15(77.75,136.21) v15(77.8,130.09) v15(77.8,129.81) v15(78.05,129.94) v15(78.26,138.72) v15(78.56,138.72) v15(78.87,138.72) v15(79.02,136.72) v15(79.02,136.21) v15(79.17,138.72) v15(79.23,121.16) v15(79.44,99.12) v15(80.29,136.72) v15(80.29,136.21) v15(81.26,112.67) v15(81.24,99.12) v15(81.43,119.96) v15(81.56,136.72) v15(81.56,136.21) v15(81.54,112.67) v15(81.54,95.87) v15(81.79,134.08) v15(82.15,112.59) v15(82.3,130.32) v15(82.35,128.68) v15(82.38,116.76) v15(82.3,111.57) v15(82.47,130.52) v15(82.41,112.59) v15(82.55,111.57) v15(82.58,108.12) v15(82.64,128.67) v15(82.64,116.76) v15(82.69,112.6) v15(82.83,136.72) v15(82.83,136.21) v15(82.82,135.07) v15(82.98,121.88) v15(83.04,99.12) v15(83.08,121.62) v15(83.16,111.57) v15(83.25,121.86) v15(83.38,121.59) v15(83.3,116.76) v15(83.34,95.8) v15(83.41,111.57) v15(83.56,116.76) v15(83.77,108.12) v15(83.82,116.76) v15(84.1,136.72) v15(84.1,136.21) v15(84.46,111.69) v15(84.63,135.09) v15(84.77,111.69) v15(84.84,99.12) v15(84.96,108.12) v15(85.13,95.65) v15(85.24,112.65) v15(85.37,136.72) v15(85.37,136.21) v15(85.29,107.3) v15(85.29,107.05) v15(85.66,111.69) v15(85.96,111.69) v15(86.64,136.72) v15(86.64,136.21) v15(87.91,136.72) v15(87.91,136.21) v15(88.06,120.59) v15(88.7,120.84) v15(88.86,102.92) v15(88.86,102.33) v15(89.18,136.72) v15(89.18,136.21) v15(89.21,106.2) v15(90.24,99.12) v15(90.45,136.72) v15(90.45,136.21) v15(90.45,120.21) v15(90.53,135.14) v15(91.45,135.13) v15(91.72,136.72) v15(91.72,136.21) v15(92.05,108.2) v15(92.3,120.99) v15(92.46,119.19) v15(92.56,121) v15(92.56,113.42) v15(92.58,114.39) v15(92.71,119.19) v15(92.86,113.42) v15(92.89,114.39) v15(92.99,136.72) v15(92.99,136.21) v15(93.17,113.42) v15(93.27,135.13) v15(93.19,114.39) v15(93.2,106.33) v15(93.24,99.12) v15(93.32,119.19) v15(93.62,119.19) v15(93.77,113.42) v15(93.8,114.39) v15(93.84,99.12) v15(94.08,113.42) v15(94.1,114.39) v15(94.26,136.72) v15(94.26,136.21) v15(94.41,114.39) v15(94.38,113.42) v15(94.49,98.52) v15(95.53,136.72) v15(95.53,136.21) v15(95.66,133.17) v15(95.68,131.38) v15(96.75,135.8) v15(96.75,134.53) v15(96.75,132.91) v15(96.75,131.64) v15(96.75,128.89) v15(96.77,109.03) v15(96.77,107.76) v15(96.77,106.49) v15(96.77,105.22) v15(96.75,103.16) v15(96.75,102) v15(96.75,101.01) v15(96.75,99.53) v15(96.75,97.73) v15(96.75,96.79) v15(96.81,125.73) v15(96.87,124.43) v15(96.8,116.37) v15(96.9,123.16) v15(96.89,121.89) v15(97.12,125.72) v15(97.17,124.42) v15(97.15,123.15) v15(97.15,121.88) v15(97.26,135.8) v15(97.26,134.53) v15(97.26,132.91) v15(97.26,131.64) v15(97.26,130.16) v15(97.26,128.89) v15(97.23,116.75) v15(97.26,103.16) v15(97.26,102) v15(97.26,101.01) v15(97.26,99.53) v15(97.26,97.73) v15(97.26,96.79) v15(97.28,127.14) v15(97.28,109.03) v15(97.28,107.76) v15(97.28,106.49) v15(97.28,105.22) v15(98.29,127.55) v15(98.29,118.54) v15(99.77,111.15) v15(99.77,110.81) v15(99.77,110.48) v15(99.77,110.15) v15(99.77,109.79) v15(100.13,111.15) v15(100.13,110.81) v15(100.13,110.48) v15(100.13,110.15) v15(100.14,109.81) v15(100.47,111.15) v15(100.47,110.81) v15(100.47,110.48) v15(100.47,110.15) v15(100.49,109.81) v15(100.84,111.17) v15(100.84,110.82) v15(100.84,110.49) v15(100.84,110.16) v15(100.86,109.82) v15(101.21,111.15) v15(101.21,110.81) v15(101.21,110.48) v15(101.21,110.15) v15(101.23,109.81) v15(101.59,111.14) v15(101.59,110.8) v15(101.59,110.47) v15(101.59,110.15) v15(101.6,109.81) v15(103.31,139.03) v15(104.56,105.58) v15(104.81,105.58) v15(105.07,105.58) v15(105.32,105.55) v15(105.33,97.72) v15(105.63,94.84) v15(105.93,97.72) v15(106.23,94.84) v15(106.39,105.59) v15(106.53,97.72) v15(106.64,105.59) v15(106.83,94.84) v15(106.9,105.59) v15(107.15,105.56) v15(107.51,125.15) v15(107.51,123.05) v15(107.56,115.24) v15(107.77,125.16) v15(107.77,123.04) v15(107.76,122.27) v15(107.76,121.9) v15(107.76,121.53) v15(107.73,120.45) v15(107.73,120.08) v15(107.73,119.75) v15(107.73,118.8) v15(107.73,118.47) v15(107.73,118.15) v15(107.73,117.03) v15(107.73,116.7) v15(107.73,116.37) v15(108.04,125.15) v15(108.04,123.03) v15(108.03,105.63) v15(108.28,105.63) v15(108.53,105.63) v15(108.79,105.6) v15(109.23,94.84) v15(109.83,94.84) v15(110.24,115.24) v15(111.03,94.84) v15(111.94,112.79) v15(112.23,94.84) v15(112.51,134.3) v15(112.65,114.72) v15(112.83,115.48) v15(112.91,125.09) v15(112.93,111.24) v15(112.93,110.99) v15(112.93,110.73) v15(113.02,123.36) v15(112.99,106.46) v15(113.43,94.84) v15(113.81,115.63) v15(114.07,125.2) v15(114.56,134.3) v15(114.72,94.87) v15(114.83,125.07) v15(114.83,117.7) v15(115.16,134.3) v15(115.46,130.55) v15(115.89,125.11) v15(115.93,109.62) v15(116.61,111.78) v15(116.61,111.5) v15(116.61,111.24) v15(116.61,110.99) v15(116.61,110.73) v15(117.32,109.77) v15(117.56,134.3) v15(117.6,115.79) v15(117.75,122.41) v15(117.8,107.91) v15(117.8,107.64) v15(118.36,105.43) v15(118.51,125.97) v15(118.62,105.4) v15(118.76,134.3) v15(118.71,123.29) v15(118.72,118.03) v15(119.15,116.22) v15(119.48,117.97) v15(119.96,134.3) v15(120.26,130.55) v15(120.34,118.79) v15(120.34,118.53) v15(120.56,134.3) v15(120.86,130.55) v15(120.85,108.14) v15(120.85,107.84) v15(120.8,105.86) v15(120.8,105.43) v15(120.9,107.05) v15(120.9,106.8) v15(121.16,134.3) v15(121.08,121.22) v15(121.08,120.97) v15(121.28,121.45) v15(121.68,118.34) v15(121.67,118.03) v15(121.67,117.11) v15(121.69,119.07) v15(121.69,118.79) v15(121.93,97.76) v15(122.33,97.81) v15(122.73,97.8) v15(123.13,97.79) v15(123.53,97.77) v15(123.63,118.36) v15(123.93,97.73) v15(124.17,118.36) v15(124.23,111.04) v15(124.28,114.72) v15(124.33,97.75) v15(124.56,114.72) v15(124.49,110.84) v15(124.73,97.79) v15(124.95,119.26) v15(124.95,119) v15(124.95,118.74) v15(124.95,118.48) v15(124.95,118.22) v15(124.95,117.96) v15(124.95,117.69) v15(124.95,117.4) v15(125.17,107.2) v15(125.13,97.79) v15(125.35,117.92) v15(125.36,117.56) v15(125.39,118.33) v15(125.54,118.1) v15(125.55,117.75) v15(125.53,117.35) v15(125.53,97.81) v15(125.65,109.44) v15(125.6,107.2) v15(125.93,97.79) v15(126.24,115.2) v15(126.21,114.92) v15(126.34,97.79) v15(126.73,97.81) v15(127.11,97.79) v15(127.21,116.36) v15(127.23,116.09) v15(127.48,116.37) v15(127.48,116.09) v15(127.53,97.81) v15(127.93,97.79) v15(128.33,97.79) v15(128.73,97.81) v15(129.08,105.56) v15(129.17,117.5) v15(129.13,97.81) v15(129.21,119.28) v15(129.19,116.53) v15(129.35,105.57) v15(129.53,97.8) v15(129.93,97.79) v15(130.33,97.8) v15(130.42,108.22) v15(130.53,120.8) v15(130.57,119.12) v15(130.57,117.31) v15(130.56,115.92) v15(130.57,114.68) v15(130.57,113.57) v15(130.56,112.64) v15(130.54,111.76) v15(130.53,110.59) v15(130.56,109.35) v15(130.57,107.14) v15(130.73,97.81) v15(131.6,126.91) v15(131.6,124.81) v15(131.62,119.32) v15(131.67,117.3) v15(131.67,116.19) v15(131.67,114.92) v15(131.67,113.65) v15(131.67,112.38) v15(131.67,111.11) v15(131.6,108.7) v15(131.6,107.61) v15(131.6,106.34) v15(131.67,104.36) v15(132.07,114.94) v15(132.03,108.7) v15(132.03,107.61) v15(132.03,106.34) v15(132.05,104.76) v15(132.13,126.91) v15(132.11,124.81) v15(132.13,118.43) v15(132.11,117.3) v15(132.11,116.19) v15(132.11,113.65) v15(132.11,112.38) v15(132.11,111.11) v15(133.35,110.94) v15(133.7,134.3) v15(134.21,110.94) v15(134.59,104.21) v15(134.59,103.95) v15(134.9,134.3) v15(135.09,123.63) v15(135.09,123.22) v15(135.37,123.43) v15(135.43,104.21) v15(135.43,103.95) v15(135.68,123.63) v15(135.68,123.22) v15(136.1,134.3) v15(136.35,104.21) v15(136.35,103.95) v15(136.79,118.95) v15(136.79,118.55) v15(136.85,111.88) v15(136.91,123.62) v15(136.91,123.22) v15(137.07,118.75) v15(137.08,123.42) v15(137.26,123.64) v15(137.26,123.23) v15(137.3,134.3) v15(137.37,118.95) v15(137.37,118.55) v15(137.36,104.18) v15(137.36,103.93) v15(138.35,106.83) v15(138.5,134.3) v15(138.53,118.96) v15(138.58,118.53) v15(138.63,104.18) v15(138.63,103.93) v15(138.73,123.62) v15(138.73,123.22) v15(138.79,118.76) v15(139.01,123.42) v15(139.04,118.96) v15(139.04,118.56) v15(139.32,123.62) v15(139.32,123.22) v15(139.7,134.3) v15(139.9,104.18) v15(139.9,103.93) v15(140.06,117.77) v15(140.06,117.46) v15(140.11,119.09) v15(140.11,118.81) v15(140.11,118.53) v15(140.36,118.94) v15(140.36,118.63) v15(140.31,117.62) v15(140.49,123.51) v15(140.49,123.11) v15(140.77,123.31) v15(141.07,123.51) v15(141.07,123.11) v15(141.17,128.17) v15(141.17,127.88) v15(141.58,123.48) v15(141.57,123) v15(141.73,123.24) v15(141.86,123.48) v15(141.86,122.99) v15(141.83,118.88) v15(141.83,118.6) v15(142.02,123.26) v15(142.08,107.09) v15(142.1,134.3) v15(142.15,123.51) v15(142.15,123) v15(142.28,123.26) v15(142.27,122.72) v15(142.4,123.51) v15(142.4,123) v15(142.42,104.33) v15(142.42,103.83) v15(142.53,123.26) v15(142.6,128.44) v15(142.6,127.93) v15(142.66,123.51) v15(142.65,122.62) v15(142.7,134.3) v15(142.79,123.26) v15(142.91,123.51) v15(142.91,123) v15(143.04,123.26) v15(143.17,123.51) v15(143.29,123.26) v15(143.29,122.67) v15(143.42,123.51) v15(143.55,123.26) v15(143.6,130.55) v15(143.67,123.51) v15(143.67,123) v15(143.69,104.33) v15(143.69,103.83) v15(143.8,123.26) v15(143.9,134.3) v15(143.93,123.51) v15(143.95,122.7) v15(144.08,123.27) v15(144.2,130.55) v15(144.5,134.3) v15(144.8,130.55) v15(144.96,128.44) v15(144.96,127.93) v15(144.96,104.33) v15(144.96,103.83) v15(144.98,118.73) v15(145.1,134.3) v15(145.95,134.3) v15(145.9,105.88) v15(146.28,115) v15(146.28,114.7) v15(146.23,104.33) v15(146.23,103.83) v15(146.3,115.28) v15(147.27,128.41) v15(147.27,127.9) v15(148.06,106.34) v15(147.99,105.58) v15(148.11,133.44) v15(148.17,96.33) v15(148.18,95.93) v15(148.18,95.49) v15(148.84,128.44) v15(148.84,127.93) v15(148.91,126.24) v15(148.91,125.83) v15(149.09,126.04) v15(149.43,128.44) v15(149.43,127.93) v15(149.39,126.24) v15(149.39,125.83) v15(149.61,130.94) v15(150.29,128.44) v15(150.29,127.93) v15(150.29,104.33) v15(150.29,103.83) v15(150.66,126.14) v15(150.66,125.73) v15(150.75,114.79) v15(150.75,114.38) v15(150.94,125.94) v15(150.88,101.49) v15(150.88,101.16) v15(150.88,100.83) v15(151.03,114.58) v15(151.24,126.14) v15(151.24,125.73) v15(151.21,101.49) v15(151.19,101.16) v15(151.19,100.86) v15(151.33,114.79) v15(151.33,114.38) v15(151.36,106.87) v15(151.56,104.33) v15(151.56,103.83) v15(152.04,128.41) v15(152.04,127.9) v15(152.15,126.23) v15(152.15,125.97) v15(152.15,125.72) v15(152.13,101.49) v15(152.13,101.16) v15(152.13,100.9) v15(152.4,126.1) v15(152.4,125.85) v15(152.43,114.8) v15(152.43,114.39) v15(152.46,101.49) v15(152.44,101.16) v15(152.52,100.92) v15(152.7,114.59) v15(152.86,128.44) v15(152.86,127.93) v15(153.01,114.8) v15(153.01,114.39) v15(153.27,101.47) v15(153.27,101.14) v15(153.27,100.81) v15(153.58,101.14) v15(153.58,100.84) v15(153.6,101.47) v15(153.85,104.33) v15(153.85,103.83) v15(153.98,126.23) v15(153.98,125.95) v15(153.98,125.69) v15(154.11,133.44) v15(154.21,126.1) v15(154.23,125.82) v15(154.28,114.78) v15(154.28,114.38) v15(154.56,114.58) v15(154.48,104.33) v15(154.48,103.83) v15(154.87,114.78) v15(154.87,114.38) v15(154.99,112.89) v15(155.85,121.06) v15(155.85,120.78) v15(156.08,120.25) v15(156.08,119.84) v15(156.11,107.17) v15(156.2,121.06) v15(156.2,120.78) v15(156.36,120.04) v15(156.29,104.33) v15(156.29,103.83) v15(156.67,120.25) v15(156.67,119.84) v15(157.12,104.33) v15(157.1,103.89) v15(157.86,120.22) v15(157.86,119.89) v15(157.86,104.33) v15(157.86,103.83) v15(158.01,127.93) v15(158.14,120.09) v15(158.45,120.22) v15(158.45,119.89) v15(158.52,106.8) v15(158.52,105.5) v15(158.78,106.8) v15(158.78,105.5) v15(158.83,104.31) v15(158.83,103.8) v15(159.49,128.44) v15(159.49,127.93) v15(159.65,120.27) v15(159.65,119.86) v15(159.93,120.06) v15(160.05,128.44) v15(160.05,127.93) v15(160.24,120.27) v15(160.24,119.86) v15(162.79,127.93) v15(162.94,117.54) v15(162.94,117.26) v15(162.99,119.05) v15(162.99,118.46) v15(162.99,114.82) v15(162.99,114.24) v15(163.19,118.77) v15(163.19,114.54) v15(163.39,119.05) v15(163.39,118.46) v15(163.4,114.82) v15(163.4,114.24) v15(164.19,128.44) v15(164.74,128.44) v15(165.14,95.47) v15(165.3,110.66) v15(166.26,116.43) v15(166.75,104.31) v15(166.93,113.12) v15(167.11,128.41) v15(167.08,102.07) v15(167.16,100.62) v15(167.23,108.17) v15(167.41,102.38) v15(167.49,127.98) v15(167.56,100.98) v15(167.83,113.13) v15(167.82,112.21) v15(167.91,118.14) v15(168.93,95.43) v15(169.54,133.35) v15(170.19,112.66) v15(170.23,101.08) v15(170.23,100.57) v15(171.35,126.53) v15(171.35,126.25) v15(171.37,125.26) v15(171.36,123.94) v15(171.36,123.63) v15(171.37,122.67) v15(171.37,122.34) v15(171.31,115.02) v15(171.31,114.76) v15(171.3,108.22) v15(171.4,124.96) v15(171.5,101.08) v15(171.5,100.57) v15(171.63,126.53) v15(171.63,126.25) v15(171.65,125.26) v15(171.68,124.96) v15(171.63,123.94) v15(171.63,123.63) v15(171.65,122.67) v15(171.65,122.34) v15(171.59,115.02) v15(171.59,114.76) v15(171.81,118.73) v15(171.81,118.46) v15(171.83,117.57) v15(172.11,117.57) v15(172.26,113.11) v15(172.24,112.02) v15(172.36,104.16) v15(172.33,102.75) v15(172.33,102.42) v15(172.58,110.8) v15(172.75,128.41) v15(172.75,127.9) v15(172.69,116.55) v15(172.77,101.08) v15(172.77,100.57) v15(172.97,116.55) v15(173.06,112.88) v15(173.16,111.89) v15(173.37,111.03) v15(173.34,109.67) v15(173.51,128.41) v15(173.51,127.9) v15(173.77,110.11) v15(174,113.35) v15(174,113.02) v15(174.28,113.35) v15(174.28,113.02) v15(174.19,108.94) v15(174.5,111.8) v15(174.52,110.12) v15(174.56,108.51) v15(174.6,128.41) v15(174.6,127.9) v15(174.62,102.47) v15(174.7,101.08) v15(174.7,100.57) v15(174.95,110.95) v15(174.92,109.48) v15(175.11,116.09) v15(175.23,115.84) v15(175.36,116.09) v15(175.41,108.7) v15(175.45,107.97) v15(175.51,115.84) v15(175.53,98.33) v15(175.62,116.09) v15(175.87,116.09) v15(175.79,115.84) v15(175.84,101.08) v15(175.84,100.57) v15(175.88,110.95) v15(175.93,109.48) v15(176.05,115.84) v15(176.06,107.33) v15(176.12,116.09) v15(176.38,116.09) v15(176.33,115.84) v15(176.45,130.44) v15(176.45,112.41) v15(176.63,116.09) v15(176.58,115.84) v15(176.73,112.41) v15(176.76,111.03) v15(176.78,128.41) v15(176.78,127.9) v15(176.86,115.84) v15(176.79,102.22) v15(176.89,116.09) v15(177.04,130.09) v15(177.04,108.33) v15(177.14,116.09) v15(177.11,115.81) v15(177.11,101.08) v15(177.11,100.57) v15(177.34,115.94) v15(177.34,112.41) v15(177.44,110.11) v15(177.51,111.67) v15(177.62,112.41) v15(177.89,102.97) v15(178.05,128.41) v15(178.05,127.9) v15(178.38,101.08) v15(178.38,100.57) v15(178.63,95.43) v15(178.7,109.71) v15(178.82,116.12) v15(178.82,115.79) v15(178.89,106.23) v15(179.65,101.08) v15(179.65,100.57) v15(179.76,128.41) v15(179.76,127.9) v15(179.92,121.88) v15(180.23,121.88) v15(180.3,102.2) v15(180.95,128.41) v15(180.95,127.9) v15(180.95,103.23) v15(180.9,100.62) v15(181.46,126.86) v15(181.46,124.55) v15(181.46,123.92) v15(181.46,122.65) v15(181.46,121.38) v15(181.46,120.11) v15(181.46,118.84) v15(181.46,117.57) v15(181.46,116.3) v15(181.46,115.03) v15(181.46,113.76) v15(181.46,112.49) v15(181.46,111.22) v15(181.46,109.87) v15(181.46,108.6) v15(181.43,101.72) v15(181.41,100.62) v15(181.48,126.1) v15(181.51,107.2) v15(181.51,103.16) v15(181.91,128.41) v15(181.91,127.9) v15(181.97,126.86) v15(181.97,124.55) v15(181.97,123.92) v15(181.97,122.65) v15(181.97,121.38) v15(181.97,120.11) v15(181.97,118.84) v15(181.97,117.57) v15(181.97,116.3) v15(181.97,115.03) v15(181.97,113.76) v15(181.97,112.49) v15(181.97,111.22) v15(181.97,109.87) v15(181.97,108.6) v15(181.94,107.61) v15(181.94,103.55) v15(181.94,101.72) v15(181.99,126.1) v15(183.26,144.52) v15(183.26,143.73) v15(183.26,138.18) v15(183.26,125.59) v15(183.26,124.32) v15(183.26,122.9) v15(183.26,121.63) v15(183.26,120.36) v15(183.26,119.09) v15(183.26,117.82) v15(183.26,116.55) v15(183.26,115.28) v15(183.26,114.01) v15(183.26,112.74) v15(183.26,111.47) v15(183.26,110.71) v15(183.26,109.95) v15(183.26,109.01) v15(183.26,108.24) v15(183.26,106.97) v15(183.24,104.79) v15(183.29,102.4) v15(183.44,133.95) v15(183.44,132.68) v15(183.44,131.41) v15(183.44,130.14) v15(183.39,128.77) v15(183.44,127.6) v15(183.49,140.26) v15(183.67,102.78) v15(183.77,140.55) v15(183.72,134.91) v15(183.77,125.59) v15(183.77,124.32) v15(183.77,122.9) v15(183.77,121.63) v15(183.77,120.36) v15(183.77,119.09) v15(183.77,117.82) v15(183.77,116.55) v15(183.77,115.28) v15(183.77,114.01) v15(183.77,112.74) v15(183.77,111.47) v15(183.77,110.71) v15(183.77,109.95) v15(183.77,109.01) v15(183.77,108.24) v15(183.77,106.97) v15(183.74,104.79) v15(184,144.52) v15(184.77,136.83) v15(184.89,99.42) v15(184.89,95.57) v15(185.32,132.46) v15(185.5,112.97) v15(186.16,142.45) v15(186.28,136.13) v15(186.77,102.53) v15(186.77,102.02) v15(186.93,107.95) v15(186.96,106.98) v15(186.99,144) v15(187.08,109.07) v15(187.09,110.74) v15(187.11,109.86) v15(187.24,107.95) v15(187.29,106.98) v15(187.46,109.87) v15(187.48,109.07) v15(187.57,107.93) v15(187.6,110.76) v15(187.62,106.98) v15(187.73,140.96) v15(187.85,109.07) v15(187.9,109.88) v15(188.06,110.76) v15(188.04,102.53) v15(188.04,102.02) v15(188.26,144) v15(188.76,112.49) v15(188.76,112.23) v15(188.76,111.98) v15(188.76,111.72) v15(188.76,111.47) v15(188.76,111.22) v15(188.76,110.96) v15(188.85,140.43) v15(188.83,96.91) v15(189.53,144) v15(189.76,99.44) v15(190.04,102.53) v15(190.04,102.02) v15(190.56,96.5) v15(190.8,144) v15(190.86,130.22) v15(190.81,112.62) v15(191.36,102.48) v15(191.36,102.02) v15(191.43,99.88) v15(191.93,99.87) v15(192.55,112.22) v15(192.54,111.96) v15(192.76,102.53) v15(192.76,102.02) v15(193.28,125.35) v15(193.29,139.85) v15(193.32,124.02) v15(193.29,93.94) v15(193.45,144) v15(193.47,129.26) v15(193.46,113.11) v15(193.53,125.35) v15(193.58,110.37) v15(193.6,124.02) v15(193.6,105.25) v15(193.6,104.38) v15(193.64,97.39) v15(193.97,123.99) v15(194.06,129.26) v15(194.04,125.36) v15(194,102.53) v15(194,102.02) v15(194.08,122.8) v15(194.13,121.53) v15(194.1,96.38) v15(194.28,119.73) v15(194.28,119.45) v15(194.41,139.31) v15(194.39,122.77) v15(194.41,121.53) v15(194.64,129.26) v15(194.72,144) v15(195.2,129.24) v15(195.73,102.53) v15(195.73,102.02) v15(195.78,129.24) v15(195.99,144) v15(196.37,115.27) v15(196.44,102.56) v15(196.44,102.05) v15(196.57,97.45) v15(196.97,96.41) v15(196.92,93.9) v15(196.99,132.63) v15(197.26,144) v15(197.26,139.31) v15(197.22,134.98) v15(197.38,128.12) v15(197.48,102.56) v15(197.48,102.05) v15(197.98,133.8) v15(198.01,113.43) v15(198.53,109.74) v15(198.93,99.89) v15(199.14,102.53) v15(199.14,102.02) v15(199.19,144.54) v15(199.44,144.54) v15(199.99,142.38) v15(200,141.54) v15(200,141.16) v15(200,140.78) v15(200,140.4) v15(200,139.16) v15(200,138.78) v15(200,138.39) v15(200,138.01) v15(200,137.63) v15(200,137.25) v15(200,136.87) v15(200,136.49) v15(200,136.11) v15(200,135.73) v15(200,135.35) v15(200,134.97) v15(200,133.47) v15(200,132.2) v15(200,131.51) v15(200,130.65) v15(200,128.92) v15(200,126.46) v15(200.02,102.53) v15(200.02,102.02) v15(200.25,142.92) v15(200.38,139.16) v15(200.38,138.78) v15(200.38,138.39) v15(200.38,138.01) v15(200.38,137.63) v15(200.38,137.25) v15(200.38,136.87) v15(200.38,136.49) v15(200.38,136.11) v15(200.38,135.73) v15(200.38,135.35) v15(200.38,134.97) v15(200.38,133.47) v15(200.38,132.2) v15(200.38,131.51) v15(200.38,130.65) v15(200.38,128.92) v15(200.38,126.46) v15(200.43,99.86) v15(200.51,142.92) v15(200.53,124.02) v15(200.53,123.26) v15(200.53,122.49) v15(200.53,121.86) v15(200.5,118.01) v15(200.94,99.86) v15(200.99,102.53) v15(200.99,102.02) v15(202.23,109.97) v15(202.23,109.69) v15(202.23,109.39) v15(202.56,121.35) v15(202.56,120.84) v15(202.62,102.56) v15(202.88,94.25) v15(202.96,147.71) v15(202.97,134.21) v15(202.96,130.71) v15(202.96,130.21) v15(203.36,121.31) v15(203.36,120.8) v15(203.45,125.94) v15(203.73,128.61) v15(203.71,102.53) v15(203.71,102.02) v15(204.14,121.31) v15(204.14,120.8) v15(204.4,97.44) v15(204.4,97.06) v15(204.4,96.68) v15(204.9,102.56) v15(204.9,102.05) v15(205.38,123.61) v15(205.49,125.94) v15(205.66,102.56) v15(205.66,102.05) v15(205.84,105.97) v15(206.43,102.56) v15(206.43,102.05) v15(206.5,121.35) v15(206.5,120.84) v15(207.29,121.36) v15(207.29,120.86) v15(207.37,118.37) v15(207.62,115.34) v15(207.99,117.33) v15(208.47,126) v15(208.39,97.22) v15(208.39,96.89) v15(208.39,96.52) v15(208.39,96.18) v15(208.39,95.85) v15(208.48,121.38) v15(208.48,120.87) v15(208.88,115.8) v15(209.04,121.38) v15(209.04,120.87) v15(209.68,121.35) v15(209.68,120.84) v15(209.74,115.8) v15(210.36,122.32) v15(210.36,121.81) v15(210.53,99.67) v15(210.53,93.84) v15(211.12,122.32) v15(211.12,121.81) v15(211.43,99.67) v15(211.43,93.84) v15(211.89,122.32) v15(211.89,121.81) v15(212.14,121.07) v15(212.14,120.31) v15(212.14,119.55) v15(212.14,118.79) v15(212.14,118.02) v15(212.14,117.26) v15(212.14,116.6) v15(212.17,113.12) v15(212.17,112.87) v15(212.17,104.33) v15(212.53,114.26) v15(212.65,122.32) v15(212.65,121.81) v15(212.65,121.07) v15(212.65,120.31) v15(212.65,119.55) v15(212.65,113.17) v15(212.65,112.92) v15(218.42,120.97) v15(218.5,107.72) v15(220.26,120.92) v15(220.25,107.72) v15(222,104.19) v15(222.03,97.71) v16(12.74,7.76) v16(13.04,51.93) v16(13.44,50.1) v16(13.93,48.02) v16(14.76,121.94) v16(15.3,136.02) v16(16.84,29.72) v16(19.84,77.24) v16(21.37,102.49) v16(157.19,124.17) v16(174.37,110.9) v16(174.32,107.39) v16(176.73,110.23) v16(187.87,123.84) v16(201.98,117.86) v19(7.75,127.65) v19(25.46,76.69) v19(25.65,77.05) v19(25.69,74.97) v19(25.86,54.98) v19(32.31,37.12) v19(32.36,36.39) v19(122.58,114.89) v19(123.11,114.87) v19(124.85,112.89) v19(126.87,114.21) v19(127.18,112.93) v20(34.34,39.61) v20(35.53,40.66) v20(35.53,40.17) v20(35.53,39.66) v21(22.81,44.97) v21(22.83,41.14) v21(24.64,45.07) v21(24.61,40.15) v21(25.02,54.93) v21(25.17,40.15) v21(25.68,40.15) v21(25.76,45.05) v21(26.36,40.43) v21(27.08,40.12) v21(27.13,45.05) v21(27.71,40.43) v21(30.14,44.07) v21(30.94,43.71) v21(34.39,40.43) v21(53.68,132.93) v21(54.15,134.56) v21(54.13,133.78) v21(54.61,134.23) v21(55.83,132.55) v21(97.05,128.16) v21(97.35,127.83) v21(114.22,126.43) v21(122.39,101.45) v22(47.46,153.66) v22(47.42,152.73) v22(47.42,151.6) v22(47.42,150.64) v22(47.5,149.89) v22(47.7,149.19) v22(48.48,151.84) v22(49.22,150.88) v22(49.3,149.12) v22(49.57,150.02) v22(50.66,151.12) v22(50.69,149.13) v22(50.83,151.86) v22(51.02,153.53) v22(51.01,150.51) v22(52.07,151.78) v22(52.16,153.56) v22(52.21,152.72) v22(52.71,149.13) v22(53.51,152.72) v22(54.09,149.07) v22(55.44,149.21) v22(55.72,153.55) v22(56.44,149.02) v22(56.7,153.54) v22(57.24,148.4) v22(57.85,137.98) v22(57.89,136.75) v22(57.98,138.76) v22(58.15,147.4) v22(58.09,136.29) v22(58.42,139.54) v22(58.39,135.32) v22(58.46,134.45) v22(58.45,133.95) v22(58.58,137.67) v22(58.8,146.71) v22(58.93,136.86) v22(59,140.08) v22(59.02,134.99) v22(59.06,134.3) v22(59.05,133.52) v22(59.17,145.9) v22(59.17,143.78) v22(59.13,141.83) v22(59.16,138.54) v22(59.22,153.56) v22(59.28,149.2) v22(59.18,145.16) v22(59.19,140.91) v22(59.29,142.97) v22(59.4,136.63) v22(59.58,134.76) v22(59.54,134.06) v22(59.61,139.29) v22(59.81,151.56) v22(59.98,135.27) v22(60.2,138.9) v22(60.39,147.16) v22(60.4,137.02) v22(60.49,141.55) v22(60.85,145.99) v22(60.89,139.46) v22(61.01,137.81) v22(61.58,150.2) v22(61.66,141.94) v22(61.77,140.8) v22(61.83,153.44) v22(61.93,152.12) v22(61.89,149.31) v22(61.95,147.99) v22(62.2,146.33) v22(63.02,141.77) v22(63.35,148.73) v22(63.39,151.1) v22(63.5,146.72) v22(63.73,142.36) v22(63.85,153.4) v22(64.17,145.45) v22(64.96,147.26) v22(64.92,142.78) v22(65.69,146.09) v22(66.98,142.75) v22(67.44,145.68) v22(69.36,145.47) v22(70.05,142.75) v22(70.87,145.78) v22(71.08,142.86) v22(72.62,141.9) v22(73.18,144.8) v22(76.06,138.46) v22(76.08,136.29) v22(76.22,134.45) v22(76.32,135.01) v22(76.32,132.13) v22(76.46,137.69) v22(76.5,130.21) v22(76.76,135.69) v22(76.88,135.12) v22(76.89,134.38) v22(77.06,136.89) v22(77.06,131.1) v22(77.12,136.18) v22(77.18,132.34) v22(77.3,138.42) v22(77.58,137.54) v22(77.95,130.91) v22(78.37,137.06) v22(78.42,138.3) v22(78.74,132.32) v22(78.76,131.53) v22(79.01,137.69) v22(79.71,138.29) v22(80,132.46) v22(81.16,133.37) v22(82.38,134.64) v22(83.42,135.78) v22(84.65,136.17) v22(85.84,136.18) v22(87.26,136.17) v22(88.61,136.17) v22(90.09,135.71) v22(90.98,134.39) v22(91.4,134.74) v22(91.68,133.92) v22(98.56,136.18) v22(98.49,135.66) v22(98.49,134.59) v22(98.55,133.59) v22(98.95,130.8) v22(98.94,129.71) v22(99.07,133.5) v22(99.08,131.67) v22(98.99,128.46) v22(99.19,136.24) v22(99.29,135.26) v22(99.33,134.38) v22(99.51,132.16) v22(99.5,128.09) v22(99.7,132.55) v22(99.85,135.56) v22(99.91,134.17) v22(99.91,130.79) v22(100.05,135.17) v22(100.06,129.1) v22(100.11,133.34) v22(100.2,136.27) v22(100.2,131.37) v22(100.3,130.19) v22(100.34,128.09) v22(100.41,132.16) v22(100.61,135.99) v22(111.71,101.4) v22(136.23,99.7) v22(199.36,109.5)
