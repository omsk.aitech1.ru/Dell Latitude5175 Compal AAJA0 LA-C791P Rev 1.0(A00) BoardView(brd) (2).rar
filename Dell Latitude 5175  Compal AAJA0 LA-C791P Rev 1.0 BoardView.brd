# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
Y1  20MHZ_12PF_7V20000015  [Y_X3G024000DC1H_4P]  137.85 126.21 180 top
Y2  32.768KHZ_12.5PF_9H03200031  [Y_9H03200031_2P]  194.3 140.88 0 bottom
YH1  32.768KHZ_12.5PF_9H03200042  [Y_9H03220008_2P]  55.1 129.05 180 bottom
YH2  24MHZ_12PF_7V24000020  [Y_X3G024000DC1H_4P]  53.56 107.27 90 bottom

## Library data of the parts
C1 C5 C10-C12 C19 C23 C28 C39 C40 C46 C55 C57 C59 C61 C63 C67 C71 C72 C74 C76 C78 C82 C83 C86 C89 C94 C97 C98 C100 C104 C106-C114 C116 C120 C122 C124 C126 C128 C136 C137 C145 C146 C158 C159 C161-C163 C166 C168 C170 C171 C173-C175 C178 C179 C182 C183 C186 C189-C191 C200-C207 C212 C213 C223-C233 C235-C249 C251-C254 C256-C261 C268-C271 C276 C282-C285 C295 C297 C300-C302 C305-C307 C318 C319 C323 C325 C326 C337 C338 C341 C342 C348-C352 C363-C366 C369 CA9 CA15 CA16 CA20 CA21 CA32 CA35 CA40 CA51-CA55 CA61 CA62 CA64 CA65 CC37 CC93 CC108 CH5 CH9-CH11 CH14 CH15 CH24 CT1 CT4 CV9 CV10 CV24 CV33 CX19-CX26 CZ1-CZ5 MC1 MC2 PC100 PC101 PC105-PC112 PC114-PC120 PC123-PC127 PC150 PC151 PC200 PC403 PC407-PC409 PC411-PC418 PC501 PC502 PC523 PC524 PC528 PC533-PC537 PC539 PC541 PC542 PC544 PC601-PC603 PC610 PC612 PC613 PC615 PC618 PC624 PC630 PC635 PC702-PC705 PC714-PC720 PC800 PC805-PC809 PC812 PC813 PC816 PC823 PC901-PC903 PC910 PC912 PC913 PC915 PC918-PC921 PC1000 PC1002 PC1005 PC1101-PC1105 PC1108 PC1111-PC1124 PC1127-PC1134 PC1138-PC1145 PC1149 PC1150 PC1255-PC1265 PC1408-PC1410 PC1412 PC1413 PC1415 PC1500 PC1501 = C_0402
C2 C3 C6-C9 C14-C18 C20-C22 C24-C27 C31-C38 C41-C45 C47-C49 C51-C54 C56 C58 C60 C62 C64-C66 C68-C70 C73 C75 C77 C80 C81 C84 C87 C88 C90-C93 C99 C101 C103 C105 C115 C117-C119 C121 C123 C127 C129-C135 C138-C144 C147-C157 C167 C169 C176 C177 C180 C181 C184 C185 C187 C188 C192-C198 C208 C209 C214 C219 C221 C234 C255 C262-C266 C298 C299 C304 C308-C317 C320-C322 C324 C327-C336 C339 C340 C345-C347 C353-C362 CA1-CA8 CA10-CA14 CA17-CA19 CA22 CA24-CA26 CA28-CA31 CA33 CA34 CA39 CA42-CA50 CA56-CA60 CA67-CA70 CC1-CC3 CC5-CC36 CC38-CC74 CC76-CC78 CC80-CC83 CC85-CC87 CC90 CC91 CC94-CC107 CC109-CC113 CC115-CC120 CC122-CC124 CH1-CH4 CH6-CH8 CH12 CH13 CH16-CH23 CU1 CU2 CV1-CV8 CV11 CV14-CV23 CV25-CV32 CV34-CV45 CX1-CX17 PC1200-PC1254 PC1266-PC1270 = C_0201
C4 C29 C30 C50 C85 C125 C160 C164 C165 C172 C199 C215-C218 C220 C222 C250 C267 C294 C296 C367 C368 CA23 CA27 CA36-CA38 CA41 CA63 CA66 CC4 CC75 CC79 CC84 CC88 CC89 CC92 CC114 CC121 CT2 CT3 CT5 CX18 PC113 PC121 PC122 PC400-PC402 PC404-PC406 PC515-PC517 PC525-PC527 PC529 PC531 PC538 PC540 PC604-PC609 PC611 PC614 PC616 PC617 PC620-PC623 PC700 PC710-PC713 PC802-PC804 PC810 PC811 PC814 PC817-PC822 PC904-PC909 PC911 PC914 PC916 PC917 PC924 PC1001 PC1003 PC1004 PC1110 PC1125 PC1126 PC1271-PC1304 PC1411 PC1414 = C_0603
C13 C102 = C_NEC
C343 C344 PC410 PC500 PC503-PC514 PC518-PC522 PC530 PC532 PC1106 PC1107 PC1109 PC1135-PC1137 PC1146-PC1148 = C_0805
CLIP1 CLIP5 = EMIST_SV-11A1M_1P
CLIP2-CLIP4 = EMIST_SUL-12A2M_1P
CLRP1 R324 RH46 RH47 = SHORTPADS: User Part Number: PART#
CLRP2 R1-R3 R7 R9 R18 R21 R22 R25-R28 R31 R34 R38 R40-R42 R49 R51 R52 R60-R64 R66 R67 R71 R74-R77 R84 R85 R94 R95 R99 R101 R102 R104 R105 R111 R114 R118 R119 R124 R125 R144 R145 R150 R155-R159 R162 R167-R169 R172 R173 R179 R184 R186 R209 R210 R233-R235 R238 R239 R244 R246 R251 R267 R271-R273 R282 R309-R316 R318-R323 R325 R327-R336 R338 R339 R341-R347 R352-R354 R357 R359-R363 R365 R367 R369 R387 R389 R392 R395 R410 R416 R419 R433-R435 R439 R440 R443 R444 R446-R449 R451 R452 R455-R458 R460 R461 R466 R468 R469 R482 R483 R488-R493 RA1-RA3 RA9 RA15 RA17 RA30 RA31 RA36-RA40 RA49 RA51 RA52 RA55 RA57 RA59 RA64 RA65 RC9 RC10 RC13 RC14 RC20-RC23 RC34-RC36 RC38 RC42 RC43 RC49 RC52-RC60 RC62 RC63 RC65 RC66 RC71 RC73-RC76 RC82 RC83 RC85-RC90 RC92 RC96 RC100 RC101 RC105 RC106 RC109-RC113 RC115 RC116 RC121 RC122 RC124-RC128 RH1-RH6 RH8-RH13 RH15 RH17 RH20 RH23-RH25 RH27 RH29-RH36 RH38 RH39 RH41-RH44 RH48-RH52 RH55-RH59 RH61-RH67 RH69 RH70 RH72 RH73 RH75 RH76 RH80-RH83 RH85-RH103 RH105-RH110 RH112-RH120 RH122-RH124 RH126-RH132 RV1-RV4 RV6 RV8-RV15 RV17 RV20-RV22 RV29-RV31 = R_0201
CV12 CV13 R12 R14 R19 R20 R87 R190 R191 R194 R201 R236 R237 R250 R304-R307 R450 R454 R462 R467 R478-R481 RA10 RA12 RA14 RA16 RA32-RA35 RA45 RA50 RH14 RH22 RH121 RH125 RH133 RV5 RV7 RV16 = R0201_0OHM
D1 PD102-PD105 PD500-PD506 = SDMK0340L-7-F_SOD323-2
D2 D8 DA2 DA5 DA6 DA10 DA11 = ESD207-B1-02EL_TSLP-2-19-2
D3 = RB751S40T1G_SOD523-2
D4 D6 D12 D16 D37 = BAT54CW-7-F_SOT323-3
D5 D7 D35 DA4 DA7 = PJSOT24CW_SOT323-3
D9 D10 RTCD1 = BAT54HT1G_SOD323-2
D11 D13-D15 D17-D34 D39-D42 = ESD108-B1-CSP0201_WLL-2-1-2
D38 = ESD101-B1-02ELS_TSSLP-2-4-2
DA8 DA9 DI1 DI2 PD100 PD101 = TVNST52302AB0_SOT523-3
FD1-FD4 = FIDUCIAL_C40M80
H1 H2 H4-H7 H23 = H_4P6
H3 = H_2P3
H8 H9 = H_1P2
H10 = H_1P5X2P1
H11 H25 H35 = H_2P8
H13-H18 H20-H22 H27-H34 = H_1P4X0P4N
H19 = H_1P3X0P4N
H24 = H_1P8X1P5
H26 = H_1P5
JAPS2 = ACES_50506-01841-P01_18P-NPM
JCAM3 = ACES_50463-0104A-001_10P
JDEG1 JLPDE1 = ACES_50521-01041-P01_10P
JDMIC1 = E-T_6918K-Y04N-00L_4P-T
JEDP1 = HRS_FH35C-45S-0P3SHW-50_45P-T
JHDMI1 = SINGA_2HE2016-100211F_19P-T
JHP1 = SINGA_2SJ3095-079111F_6P-T
JIO1 = HRS_DF40C-60DS-0P4V-51_60P-T
JIO4 = HRS_DF40C-100DS-0P4V-51_100P-T
JNFC1 = LCN_BAM04-20093-0500_20P
JNGFF1 = BELLW_80149-2021_67P
JNGFF2 = LCN_DAN05-67216-S503_75P-T-S
JNGFF3 = LCN_DAN05-67216-S500_75P-T-S
JPWR2 = E-T_3806K-F03N-33L_3P
JRTC1 = ACES_50278-00201-001_2P
JSPI1 = ACES_50696-0200M-P01_20P-NPM
JSPKL = ACES_50208-00201-P03_2P
JT100 = ACES_50278-01001-001_10P
JTS1 = ACES_50506-01241-P01_12P
JUFC JWFC = ACES_50515-03941-P02_39P
JUSB1 = TAIWI_USB034-107CRL-TWD_10P-T
JUSBC1 = JAE_DX07S024XJ1_24P-T
JUSH1 = E-T_6705K-Y26N-00L_26P
JXDP1 = E-T_6601K-Y61N-04L_61P
L1 L2 = MURAT_BLM15PX330SN1D_2P
L3 L16 = MURAT_BLM15AX100SN1D_2P
L4 L7-L9 L17-L23 LX1-LX4 ML3 ML6 ML13 = MURAT_DLW21HN900HQ2L_4P
L5 = KC_FBMA-L11-160808-800LMT_2P
L6 = TOKO_1269AS-H-1R0M-P2_2P
L10 = MURAT_LQG15HN1N0S02D_2P
L11 L24 = MURAT_BLM18EG221SN1D_2P
L12-L14 = INPAQ_HCM1012GH900BP_4P
L15 = MURAT_LQM2MPN2R2NG0L_2P
L25 L26 = MURAT_BLM15HD182SN1D_2P
LA1-LA9 LA11 LA12 R15 R36 R55 R57-R59 R89 R93 R98 R108-R110 R115-R117 R123 R142 R149 R160 R161 R165 R174 R182 R183 R187 R192 R217 R421 R425 R432 R438 R497 RA56 RC17-RC19 RC24 RC26 RC29 RC40 RC44 RC48 RC50 RC51 RC91 RC99 RC102 RC108 = R0603_0OHM
LA10 = MURAT_BLM21PG600SN1D_2P
LA13 LA14 = MURAT_BLM15PX181SN1D_2P
LED1 = LED_HT-191UD5_2P
LT1 PL101-PL103 PL500 PL600 PL602 PL605 PL700 PL803 PL805 PL806 PL900 = TAI-T_HCB2012KF-121T50_2P
MD1 = TVWDF1004AD0_DFN9
MD2 = AZ1065-06QPRDG_MSOP8
MIC1 MIC2 = WM7211IMS-RV_LGA5-8
ML1 ML2 ML4 ML5 ML11 ML12 = MURAT_DLW21SN670HQ2L_4P
PC1151 = C_D3
PD400 = DFLS160-7_POWERDI123-2
PD401 = 1N4148WS-7-F_SOD323-2
PD1500 = BAT54CW_SOT323-3
PH1100-PH1102 PR106 PR108 PR116-PR118 PR121 PR122 PR125-PR129 PR131 PR132 PR134 PR135 PR137 PR138 PR151-PR158 PR300-PR303 PR400 PR403-PR409 PR505 PR506 PR509 PR515 PR516 PR518-PR520 PR523-PR529 PR532 PR534 PR536-PR539 PR541-PR550 PR557 PR558 PR605 PR607 PR610-PR612 PR618 PR701 PR704 PR706 PR707 PR709 PR710 PR712 PR718 PR800 PR802-PR804 PR806 PR807 PR809 PR813 PR817-PR820 PR822-PR831 PR905-PR910 PR913 PR915 PR916 PR921 PR922 PR1001 PR1004 PR1005 PR1100 PR1102 PR1105 PR1106 PR1108 PR1111-PR1114 PR1116-PR1124 PR1126 PR1127 PR1129-PR1132 PR1141-PR1152 PR1413 PR1414 PR1416-PR1425 PR1500-PR1504 PR1510 R5 R6 R8 R10 R11 R13 R17 R24 R29 R30 R32 R33 R37 R39 R46 R50 R54 R65 R68 R69 R72 R73 R88 R97 R103 R120 R126 R132-R139 R141 R146-R148 R151-R154 R166 R170 R175 R177 R178 R180 R185 R188 R189 R195-R200 R202-R208 R212-R214 R218-R230 R232 R240 R241 R243 R245 R247-R249 R252 R253 R256 R258-R263 R268 R274-R277 R279 R283 R285 R286 R295-R298 R300 R303 R308 R317 R337 R340 R348 R356 R407-R409 R411 R423 R436 R437 R453 R459 R463 R471-R473 R484-R487 R496 R498-R502 R513 R514 RA4 RA20 RA21 RA23 RA28 RA29 RA42-RA44 RA46 RA53 RA54 RA58 RC11 RC12 RC25 RC27 RC28 RC30-RC32 RC39 RC41 RC45-RC47 RC61 RC64 RC69 RC70 RC72 RC77 RC79 RC81 RC84 RC93-RC95 RC97 RC98 RC103 RC104 RC107 RC114 RC117-RC120 RC123 RH7 RH19 RH40 RH45 RH53 RH54 RH60 RH78 RH104 RTCR1 RV18 RV19 RV23-RV28 RX1-RX3 RZ1-RZ3 = R_0402
PJP602 PJP603 PJP1100 = JUMP_43X118
PJP700 PJP800 PJP801 PJP900 PJP901 PJP1000 = JUMP_43X79
PL501 PL601 PL603 PL901 = MAG_MMD-06AEI1R5M-M1L_2P
PL701 = CYNTE_PCME051E-1R0MS_2P
PL802 PL804 PL904 PL1001 = CYNTE_PCMB041B-1R0MS_2P
PL903 PL1000 = TAI-T_HCB1608KF-121T3_L0603_2P
PL1102 = TOKO_FDSD0412-H-R47M-P3_2P
PL1103 PL1104 = MAG_MMD-05AE-R15MEM1L_2P
PL1105 = TOKO_1239AS-H-4R7M-P2_2P
PQ104 PQ503 = AON7405_DFN8-5
PQ105 PQ112 PQ151 PQ202 PQ300 PQ504-PQ506 PQ511-PQ513 PQ800 PQ1500 = DMN65D8LW-7_SOT323-3
PQ106 PQ109 PQ150 PQ1501 PQ1502 Q4 Q5 = DMN66D0LDW-7_SOT363-6
PQ107 PQ108 Q22 = DMP3099L-7_SOT23-3
PQ400 = P5103EMG_SOT23-3
PQ500 PQ502 PQ509 PQ510 = AON7407_DFN8-5
PQ501 PQ1100 = AON7934_DFN3X3A8-10
PR109 PR130 PR133 PR402 PR501-PR503 PR508 PR510 PR512 PR513 PR517 PR521 PR522 PR531 PR533 PR535 PR540 PR606 PR608 PR705 PR708 PR722 PR801 PR808 PR810-PR812 PR821 PR911 PR914 PR917 PR918 PR920 PR1000 PR1006 PR1107 PR1115 R4 R16 R23 R35 R43-R45 R53 R56 R70 R78-R83 R86 R96 R107 R121 R140 R143 R163 R164 R171 R176 R181 R193 R231 R242 R254 R255 R257 R264-R266 R269 R270 R278 R280 R281 R284 R301 R302 R326 R349 R355 R358 R364 R366 R374-R383 R388 R391 R394 R398 R400 R403 R404 R412 R441 R442 R445 R464 R465 R470 R474-R477 R494 R495 RA11 RA13 RA18 RA19 RA22 RA24-RA27 RA47 RA48 RA61-RA63 RC1-RC8 RC16 RC33 RC37 RC67 RC68 RC78 RC80 RH16 RH18 RH21 RH26 RH68 RH71 RH74 RH77 RH79 RH111 = R0402_0OHM
PR136 PR604 PR609 PR703 PR805 PR904 PR912 PR1109 PR1137 PR1138 RA60 = R_0805
PR401 PR507 PR530 PR603 PR617 PR711 PR816 PR903 PR1003 PR1103 PR1134 PR1135 PR1153-PR1155 PR1556-PR1558 R350 R351 R406 R417 R511 R512 R515 = R_0603
PR500 PR511 = R_1206_4P-D
PR504 PR514 PR815 = R_1206
PTC800 PTC801 T1-T22 T25 T27 T29-T37 TC1-TC23 TC25-TC47 TC50 TC53-TC84 = TPC12
PU100 PU1501 = LM393DMR2G_MICRO8
PU101 = RT9069-33GB_SOT23-5
PU150 PU151 PU1500 = SN74LVC1G123DCUR_VSSOP8
PU200 = SN74AUP1T08DCKR_SC70-5
PU300 = 74LVC1G32GW_TSSOP5
PU400 = TPS61181ARTER_QFN16_3X3
PU500 = BQ24770RUYR_WQFN28_4X4
PU600 PU900 = NB680GD-Z_QFN12_2X3
PU601 = NB679GD-Z_QFN12_2X3
PU700 = NB685GQ-Z_QFN16_3X3
PU801 = SYX196DQNC_QFN10_3X3
PU808 PU901 = SY8057QDC_QFN16_3X3
PU1000 = SY8003DFC_DFN8_2X2
PU1100 = ISL95808HRZ-TS2378_DFN8_2X2
PU1101 = ISL95852HIZ-T_WLCSP64
PU1403 PU1404 = M74VHC1GT00DFT2G_SC70-5
Q1 Q6 Q15 Q16 Q23 = SSM3K7002FU_SC70-3
Q3 Q11 Q12 Q14 Q20 Q21 = MMBT3904WH_SOT323-3
Q7 Q8 Q17 QA2 QT1 = DMN2400UV-7_SOT-563-6
Q9 = LP2301ALT1G_SOT23-3
Q18 = AO7404_SC70-3
R299 = R1206_0OHM
SW1 SW2 = SW_TAFG3-12WQR_3P
SW3 = SW_TS-A52-3-P1-S017_4P
U1 = G601A31U_ADFN6_1P5X1P5
U2 = NPCT650JAAYX_QFN32_5X5
U3 U13 U17 U26 U46 UV3 = APE8937GN2_DFN8_2X2
U4 = SN74AVC4T774_UQFN16_2P6X1P8
U5 U38 U44 U51 U52 = NL17SZ14DFT2G_SOT353-5
U6 = TPS68470YFFR_DSBGA_56P
U7 U12 U15 U18 U20 U22 U50 = EM5209VF_DFN14_3X2
U8 U19 U30 UH1-UH5 = SN74AHC1G08DCKR_SC70-5
U9 = TPS79801QDGNRQ1_MSOP8
U14 = SN65LVPE501RGER_VQFN24_4X4
U16 U39 = W25Q128FVPIQ_WSON8
U21 = TPA6132A2RTER_QFN16_3X3
U23 U24 = MC74VHC1G32DFT2G_SC70-5
U25 = PS8407ATQFN40GTR2A1_TQFN40_5X5
U27 = PS8713BTQFN24GTR2_TQFN24_4X4
U28 = W25Q80DVZPIG_WSON8
U29 = TS3USB221ARSER_UQFN10_2X1P5
U31 = HD3SS460RHRR_QFN28_3P5X5P5
U32 = TPS65982_BGA_96P
U33 U35 = EDFA164A1MA-GD-F_FBGA_253P
U34 = MEC1641-PZV_TFBGA_144P
U41 = AP22850SH8-7_W-DFN2020-8
U43 = SY6288C20AAC_SOT23-5
U45 UC2 = 74AUP1G07GW_TSSOP5
U47 = PS8338BQFN60GTR-A0_QFN60_5X9
U48 U49 = TPS22961DNYR_WSON8
UA1 = TS5A23157RSER_QFN10_2X1P5
UA2 = ALC1006-CG_QFN48_6X6
UA3 = ALC3266-CG_QFN56_7X7
UC1 = SKL-Y-REV1P2_BGA_1515P-T
US1 = TPS2544RTER_WQFN16_3X3
UV1 UV2 = PS8330BQFN48GTR2-A0_QFN48_7X7
Y1 YH2 = Y_X3G024000DC1H_4P
Y2 = Y_9H03200031_2P
YH1 = Y_9H03220008_2P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
1N4148WS-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74LVC1G32GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50208-00201-P03_2P
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0)
  rect 1.194x1.702 smd: 3(-1.3,-1.95) 4(2.1,-1.95)
ACES_50278-00201-001_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.925) 4(4.1,-4.925)
ACES_50278-01001-001_10P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0) 7(7.5,0) 8(8.75,0) 9(10,0) 10(11.25,0)
  rect 1.295x3.353 smd: 11(-2.85,-4.925) 12(14.1,-4.925)
ACES_50463-0104A-001_10P
  oval 0.203x1.194 smd: 1(0,0) 2(-0.4,0) 3(-0.8,0) 4(-1.2,0) 5(-1.6,0) 6(-2,0) 7(-2.4,0) 8(-2.8,0) 9(-3.2,0) 10(-3.6,0)
  rect 0.889x2.007 smd: 11(-5.85,-1.37) 12(2.25,-1.37)
ACES_50506-01241-P01_12P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0)
  rect 0.991x2.007 smd: 13(-2.1,-3.05) 14(7.6,-3.05)
ACES_50506-01841-P01_18P-NPM
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50515-03941-P02_39P
  oval 0.305x1.448 smd: 1(0,0) 3(-0.6,0) 5(-1.2,0) 7(-1.8,0) 9(-2.4,0) 11(-3,0) 13(-3.6,0) 15(-4.2,0) 17(-4.8,0) 19(-5.4,0) 21(-6,0) 23(-6.6,0) 25(-7.2,0) 27(-7.8,0) 29(-8.4,0) 31(-9,0) 33(-9.6,0) 35(-10.2,0) 37(-10.8,0) 39(-11.4,0)
  oval 0.305x0.66 smd: 2(-0.3,-3.75) 4(-0.9,-3.75) 6(-1.5,-3.75) 8(-2.1,-3.75) 10(-2.7,-3.75) 12(-3.3,-3.75) 14(-3.9,-3.75) 16(-4.5,-3.75) 18(-5.1,-3.75) 20(-5.7,-3.75) 22(-6.3,-3.75) 24(-6.9,-3.75) 26(-7.5,-3.75) 28(-8.1,-3.75) 30(-8.7,-3.75) 32(-9.3,-3.75) 34(-9.9,-3.75) 36(-10.5,-3.75) 38(-11.1,-3.75)
  rect 0.508x1.448 smd: 40(-12.25,0) 41(0.85,0)
ACES_50521-01041-P01_10P
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.5) 12(5.5,-2.5)
ACES_50696-0200M-P01_20P-NPM
  oval 0.305x0.787 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0)
  rect 0.406x0.787 smd: 21(1,-2.5) 22(-10.5,-2.5)
ALC1006-CG_QFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
ALC3266-CG_QFN56_7X7
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7.1,-5.2) 30(7.1,-4.8) 31(7.1,-4.4) 32(7.1,-4) 33(7.1,-3.6) 34(7.1,-3.2) 35(7.1,-2.8) 36(7.1,-2.4) 37(7.1,-2) 38(7.1,-1.6) 39(7.1,-1.2) 40(7.1,-0.8) 41(7.1,-0.4) 42(7.1,0)
  oval 0.203x0.889 smd: 15(0.95,-6.15) 16(1.35,-6.15) 17(1.75,-6.15) 18(2.15,-6.15) 19(2.55,-6.15) 20(2.95,-6.15) 21(3.35,-6.15) 22(3.75,-6.15) 23(4.15,-6.15) 24(4.55,-6.15) 25(4.95,-6.15) 26(5.35,-6.15) 27(5.75,-6.15) 28(6.15,-6.15) 43(6.15,0.95) 44(5.75,0.95) 45(5.35,0.95) 46(4.95,0.95) 47(4.55,0.95) 48(4.15,0.95) 49(3.75,0.95) 50(3.35,0.95) 51(2.95,0.95) 52(2.55,0.95) 53(2.15,0.95) 54(1.75,0.95) 55(1.35,0.95) 56(0.95,0.95)
  rect 4.597x4.597 smd: 57(3.55,-2.6)
AO7404_SC70-3
  oval 0.61x0.66 smd: 1(0,0) 2(-0.65,-1.95) 3(0.65,-1.95)
AON7405_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7407_DFN8-5
  oval 0.356x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.57x0.57 smd: 5(0.975,1.4)
AON7934_DFN3X3A8-10
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.76) 6(1.3,2.76) 7(0.65,2.76) 8(0,2.76)
  rect 2.54x1.041 smd: 9(0.975,1.813)
  rect 2.54x0.559 smd: 10(0.975,0.708)
AP22850SH8-7_W-DFN2020-8
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.21) 6(1,2.21) 7(0.5,2.21) 8(0,2.21)
  rect 1.6x0.889 smd: 9(0.75,1.105)
APE8937GN2_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
AZ1065-06QPRDG_MSOP8
  oval 0.381x1.575 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.35) 6(1.3,4.35) 7(0.65,4.35) 8(0,4.35)
BAT54CW-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BAT54HT1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.225,0)
BELLW_80149-2021_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(4.75,-7.55) 13(5,0) 14(5.25,-7.55) 15(5.5,0) 16(5.75,-7.55) 17(6,0) 18(6.25,-7.55) 19(6.5,0) 20(6.75,-7.55) 21(7,0) 22(7.25,-7.55) 23(7.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
BQ24770RUYR_WQFN28_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_D3
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_NEC
  rect 0.787x1.092 smd: 1(0,0) 2(2.45,0)
CYNTE_PCMB041B-1R0MS_2P
  rect 1.499x2.489 smd: 1(0,0) 2(3.7,0)
CYNTE_PCME051E-1R0MS_2P
  rect 1.905x2.794 smd: 1(0,0) 2(4.1,0)
DFLS160-7_POWERDI123-2
  rect 2.21x1.397 smd: 1(0,0)
  rect 0.889x1.397 smd: 2(-2.55,0)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN2400UV-7_SOT-563-6
  oval 0.305x0.559 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,1.7) 5(0.5,1.7) 6(0,1.7)
DMP3099L-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
E-T_3806K-F03N-33L_3P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0)
  rect 1.295x3.353 smd: 4(-2.85,-4.875) 5(5.35,-4.875)
E-T_6601K-Y61N-04L_61P
  oval 0.305x1.245 smd: 1(0,0) 3(0.6,0) 5(1.2,0) 7(1.8,0) 9(2.4,0) 11(3,0) 13(3.6,0) 15(4.2,0) 17(4.8,0) 19(5.4,0) 21(6,0) 23(6.6,0) 25(7.2,0) 27(7.8,0) 29(8.4,0) 31(9,0) 33(9.6,0) 35(10.2,0) 37(10.8,0) 39(11.4,0) 41(12,0) 43(12.6,0) 45(13.2,0) 47(13.8,0) 49(14.4,0) 51(15,0) 53(15.6,0) 55(16.2,0) 57(16.8,0) 59(17.4,0) 61(18,0)
  oval 0.305x0.94 smd: 2(0.3,3.25) 4(0.9,3.25) 6(1.5,3.25) 8(2.1,3.25) 10(2.7,3.25) 12(3.3,3.25) 14(3.9,3.25) 16(4.5,3.25) 18(5.1,3.25) 20(5.7,3.25) 22(6.3,3.25) 24(6.9,3.25) 26(7.5,3.25) 28(8.1,3.25) 30(8.7,3.25) 32(9.3,3.25) 34(9.9,3.25) 36(10.5,3.25) 38(11.1,3.25) 40(11.7,3.25) 42(12.3,3.25) 44(12.9,3.25) 46(13.5,3.25) 48(14.1,3.25) 50(14.7,3.25) 52(15.3,3.25) 54(15.9,3.25) 56(16.5,3.25) 58(17.1,3.25) 60(17.7,3.25)
  rect 0.305x1.143 smd: 62(-0.65,0.6) 63(18.65,0.6)
E-T_6705K-Y26N-00L_26P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0)
  rect 0.991x2.007 smd: 27(-2.1,-3.15) 28(14.6,-3.15)
E-T_6918K-Y04N-00L_4P-T
  oval 0.305x0.787 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0)
  rect 0.406x0.787 smd: 5(-4.5,-2.5) 6(1.5,-2.5)
EDFA164A1MA-GD-F_FBGA_253P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) A12(5.501,0) A13(6.002,0) A14(6.502,0) A15(7.002,0) A16(7.502,0) A17(8.002,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) B12(5.501,-0.5) B13(6.002,-0.5) B14(6.502,-0.5) B15(7.002,-0.5) B16(7.502,-0.5) B17(8.002,-0.5) C1(0,-1) C2(0.5,-1) C3(1,-1) C4(1.5,-1) C5(2.001,-1) C6(2.501,-1) C7(3.001,-1) C8(3.501,-1) C9(4.001,-1) C10(4.501,-1) C11(5.001,-1) C12(5.501,-1) C13(6.002,-1) C14(6.502,-1) C15(7.002,-1) C16(7.502,-1) C17(8.002,-1) D1(0,-1.5) D2(0.5,-1.5) D3(1,-1.5) D4(1.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D9(4.001,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) D12(5.501,-1.5) D13(6.002,-1.5) D14(6.502,-1.5) D15(7.002,-1.5) D16(7.502,-1.5) D17(8.002,-1.5) E1(0,-2.001) E2(0.5,-2.001) E3(1,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E9(4.001,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) E12(5.501,-2.001) E13(6.002,-2.001) E14(6.502,-2.001) E15(7.002,-2.001) E16(7.502,-2.001) E17(8.002,-2.001) F1(0,-2.501) F2(0.5,-2.501) F3(1,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F12(5.501,-2.501) F13(6.002,-2.501) F14(6.502,-2.501) F15(7.002,-2.501) F16(7.502,-2.501) F17(8.002,-2.501) G1(0,-3.001) G2(0.5,-3.001) G3(1,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G12(5.501,-3.001) G13(6.002,-3.001) G14(6.502,-3.001) G15(7.002,-3.001) G16(7.502,-3.001) G17(8.002,-3.001) H1(0,-3.501) H2(0.5,-3.501) H3(1,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H12(5.501,-3.501) H13(6.002,-3.501) H14(6.502,-3.501) H15(7.002,-3.501) H16(7.502,-3.501) H17(8.002,-3.501) J1(0,-4.001) J2(0.5,-4.001) J3(1,-4.001) J4(1.5,-4.001) J5(2.001,-4.001) J12(5.501,-4.001) J13(6.002,-4.001) J14(6.502,-4.001) J15(7.002,-4.001) J16(7.502,-4.001) J17(8.002,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K12(5.501,-4.501) K13(6.002,-4.501) K14(6.502,-4.501) K15(7.002,-4.501) K16(7.502,-4.501) K17(8.002,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L12(5.501,-5.001) L13(6.002,-5.001) L14(6.502,-5.001) L15(7.002,-5.001) L16(7.502,-5.001) L17(8.002,-5.001) M1(0,-5.501) M2(0.5,-5.501) M3(1,-5.501) M4(1.5,-5.501) M5(2.001,-5.501) M6(2.501,-5.501) M7(3.001,-5.501) M8(3.501,-5.501) M9(4.001,-5.501) M10(4.501,-5.501) M11(5.001,-5.501) M12(5.501,-5.501) M13(6.002,-5.501) M14(6.502,-5.501) M15(7.002,-5.501) M16(7.502,-5.501) M17(8.002,-5.501) N1(0,-6.002) N2(0.5,-6.002) N3(1,-6.002) N4(1.5,-6.002) N5(2.001,-6.002) N6(2.501,-6.002) N7(3.001,-6.002) N8(3.501,-6.002) N9(4.001,-6.002) N10(4.501,-6.002) N11(5.001,-6.002) N12(5.501,-6.002) N13(6.002,-6.002) N14(6.502,-6.002) N15(7.002,-6.002) N16(7.502,-6.002) N17(8.002,-6.002) P1(0,-6.502) P2(0.5,-6.502) P3(1,-6.502) P4(1.5,-6.502) P5(2.001,-6.502) P6(2.501,-6.502) P7(3.001,-6.502) P8(3.501,-6.502) P9(4.001,-6.502) P10(4.501,-6.502) P11(5.001,-6.502) P12(5.501,-6.502) P13(6.002,-6.502) P14(6.502,-6.502) P15(7.002,-6.502) P16(7.502,-6.502) P17(8.002,-6.502) R1(0,-7.002) R2(0.5,-7.002) R3(1,-7.002) R4(1.5,-7.002) R5(2.001,-7.002) R6(2.501,-7.002) R7(3.001,-7.002) R8(3.501,-7.002) R9(4.001,-7.002) R10(4.501,-7.002) R11(5.001,-7.002) R12(5.501,-7.002) R13(6.002,-7.002) R14(6.502,-7.002) R15(7.002,-7.002) R16(7.502,-7.002) R17(8.002,-7.002) T1(0,-7.502) T2(0.5,-7.502) T3(1,-7.502) T4(1.5,-7.502) T5(2.001,-7.502) T6(2.501,-7.502) T7(3.001,-7.502) T8(3.501,-7.502) T9(4.001,-7.502) T10(4.501,-7.502) T11(5.001,-7.502) T12(5.501,-7.502) T13(6.002,-7.502) T14(6.502,-7.502) T15(7.002,-7.502) T16(7.502,-7.502) T17(8.002,-7.502) U1(0,-8.002) U2(0.5,-8.002) U3(1,-8.002) U4(1.5,-8.002) U5(2.001,-8.002) U6(2.501,-8.002) U7(3.001,-8.002) U8(3.501,-8.002) U9(4.001,-8.002) U10(4.501,-8.002) U11(5.001,-8.002) U12(5.501,-8.002) U13(6.002,-8.002) U14(6.502,-8.002) U15(7.002,-8.002) U16(7.502,-8.002) U17(8.002,-8.002)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
EMIST_SUL-12A2M_1P
  rect 6.909x1.194 smd: 1(0,0)
EMIST_SV-11A1M_1P
  rect 2.591x2.718 smd: 1(0,0)
ESD101-B1-02ELS_TSSLP-2-4-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD108-B1-CSP0201_WLL-2-1-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
ESD207-B1-02EL_TSLP-2-19-2
  rect 0.356x0.61 smd: 1(0,0) 2(0.65,0)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G601A31U_ADFN6_1P5X1P5
  oval 0.254x1.092 smd: 1(0,0)
  oval 0.254x0.991 smd: 2(0.5,-0.051) 3(1,-0.051) 4(1,1.449) 5(0.5,1.449) 6(0,1.449)
H_1P2
  round 1.702 hole 1.194: 1(0,0)
H_1P3X0P4N
  oval 1.295x0.406 hole 1.295x0.406 unplated: (0,0)
H_1P4X0P4N
  oval 1.397x0.406 hole 1.397x0.406 unplated: (0,0)
H_1P5
  round 2.007 hole 1.499: 1(0,0)
H_1P5X2P1
  oval 2.007x2.616 hole 1.499x2.108: 1(0,0)
H_1P8X1P5
  oval 2.311x2.007 hole 1.803x1.499: 1(0,0)
H_2P3
  round 2.819 hole 2.311: 1(0,0)
H_2P8
  round 3.302 hole 2.794: 1(0,0)
H_4P6
  round 5.105 hole 4.597: 1(0,0)
HD3SS460RHRR_QFN28_3P5X5P5
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 15(4.5,3.6) 16(4,3.6) 17(3.5,3.6) 18(3,3.6) 19(2.5,3.6) 20(2,3.6) 21(1.5,3.6) 22(1,3.6) 23(0.5,3.6) 24(0,3.6)
  oval 0.889x0.254 smd: 11(5.05,1.05) 12(5.05,1.55) 13(5.05,2.05) 14(5.05,2.55) 25(-0.55,2.55) 26(-0.55,2.05) 27(-0.55,1.55) 28(-0.55,1.05)
  rect 3.988x2.007 smd: 29(2.25,1.8)
HRS_DF40C-60DS-0P4V-51_60P-T
  oval 0.203x0.711 smd: 1(0,0) 2(0,-3.08) 3(-0.4,0) 4(-0.4,-3.08) 5(-0.8,0) 6(-0.8,-3.08) 7(-1.2,0) 8(-1.2,-3.08) 9(-1.6,0) 10(-1.6,-3.08) 11(-2,0) 12(-2,-3.08) 13(-2.4,0) 14(-2.4,-3.08) 15(-2.8,0) 16(-2.8,-3.08) 17(-3.2,0) 18(-3.2,-3.08) 19(-3.6,0) 20(-3.6,-3.08) 21(-4,0) 22(-4,-3.08) 23(-4.4,0) 24(-4.4,-3.08) 25(-4.8,0) 26(-4.8,-3.08) 27(-5.2,0) 28(-5.2,-3.08) 29(-5.6,0) 30(-5.6,-3.08) 31(-6,0) 32(-6,-3.08) 33(-6.4,0) 34(-6.4,-3.08) 35(-6.8,0) 36(-6.8,-3.08) 37(-7.2,0) 38(-7.2,-3.08) 39(-7.6,0) 40(-7.6,-3.08) 41(-8,0) 42(-8,-3.08) 43(-8.4,0) 44(-8.4,-3.08) 45(-8.8,0) 46(-8.8,-3.08) 47(-9.2,0) 48(-9.2,-3.08) 49(-9.6,0) 50(-9.6,-3.08) 51(-10,0) 52(-10,-3.08) 53(-10.4,0) 54(-10.4,-3.08) 55(-10.8,0) 56(-10.8,-3.08) 57(-11.2,0) 58(-11.2,-3.08) 59(-11.6,0) 60(-11.6,-3.08)
HRS_DF40C-100DS-0P4V-51_100P-T
  oval 0.203x0.711 smd: 1(0,0) 2(0,-3.08) 3(0.4,0) 4(0.4,-3.08) 5(0.8,0) 6(0.8,-3.08) 7(1.2,0) 8(1.2,-3.08) 9(1.6,0) 10(1.6,-3.08) 11(2,0) 12(2,-3.08) 13(2.4,0) 14(2.4,-3.08) 15(2.8,0) 16(2.8,-3.08) 17(3.2,0) 18(3.2,-3.08) 19(3.6,0) 20(3.6,-3.08) 21(4,0) 22(4,-3.08) 23(4.4,0) 24(4.4,-3.08) 25(4.8,0) 26(4.8,-3.08) 27(5.2,0) 28(5.2,-3.08) 29(5.6,0) 30(5.6,-3.08) 31(6,0) 32(6,-3.08) 33(6.4,0) 34(6.4,-3.08) 35(6.8,0) 36(6.8,-3.08) 37(7.2,0) 38(7.2,-3.08) 39(7.6,0) 40(7.6,-3.08) 41(8,0) 42(8,-3.08) 43(8.4,0) 44(8.4,-3.08) 45(8.8,0) 46(8.8,-3.08) 47(9.2,0) 48(9.2,-3.08) 49(9.6,0) 50(9.6,-3.08) 51(10,0) 52(10,-3.08) 53(10.4,0) 54(10.4,-3.08) 55(10.8,0) 56(10.8,-3.08) 57(11.2,0) 58(11.2,-3.08) 59(11.6,0) 60(11.6,-3.08) 61(12,0) 62(12,-3.08) 63(12.4,0) 64(12.4,-3.08) 65(12.8,0) 66(12.8,-3.08) 67(13.2,0) 68(13.2,-3.08) 69(13.6,0) 70(13.6,-3.08) 71(14,0) 72(14,-3.08) 73(14.4,0) 74(14.4,-3.08) 75(14.8,0) 76(14.8,-3.08) 77(15.2,0) 78(15.2,-3.08) 79(15.6,0) 80(15.6,-3.08) 81(16,0) 82(16,-3.08) 83(16.4,0) 84(16.4,-3.08) 85(16.8,0) 86(16.8,-3.08) 87(17.2,0) 88(17.2,-3.08) 89(17.6,0) 90(17.6,-3.08) 91(18,0) 92(18,-3.08) 93(18.4,0) 94(18.4,-3.08) 95(18.8,0) 96(18.8,-3.08) 97(19.2,0) 98(19.2,-3.08) 99(19.6,0) 100(19.6,-3.08)
HRS_FH35C-45S-0P3SHW-50_45P-T
  oval 0.305x0.787 smd: 1(0,0) 3(0.6,0) 5(1.2,0) 7(1.8,0) 9(2.4,0) 11(3,0) 13(3.6,0) 15(4.2,0) 17(4.8,0) 19(5.4,0) 21(6,0) 23(6.6,0) 25(7.2,0) 27(7.8,0) 29(8.4,0) 31(9,0) 33(9.6,0) 35(10.2,0) 37(10.8,0) 39(11.4,0) 41(12,0) 43(12.6,0) 45(13.2,0)
  oval 0.305x0.66 smd: 2(0.3,2.875) 4(0.9,2.875) 6(1.5,2.875) 8(2.1,2.875) 10(2.7,2.875) 12(3.3,2.875) 14(3.9,2.875) 16(4.5,2.875) 18(5.1,2.875) 20(5.7,2.875) 22(6.3,2.875) 24(6.9,2.875) 26(7.5,2.875) 28(8.1,2.875) 30(8.7,2.875) 32(9.3,2.875) 34(9.9,2.875) 36(10.5,2.875) 38(11.1,2.875) 40(11.7,2.875) 42(12.3,2.875) 44(12.9,2.875)
  rect 0.406x0.94 smd: 46(-0.7,0.275) 47(13.9,0.275)
INPAQ_HCM1012GH900BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
ISL95808HRZ-TS2378_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.549x0.889 smd: 9(0.75,1.1)
ISL95852HIZ-T_WLCSP64
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) C1(0,-1) C2(0.5,-1) C3(1,-1) C4(1.5,-1) C5(2.001,-1) C6(2.501,-1) C7(3.001,-1) C8(3.501,-1) D1(0,-1.5) D2(0.5,-1.5) D3(1,-1.5) D4(1.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) E1(0,-2.001) E2(0.5,-2.001) E3(1,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) F1(0,-2.501) F2(0.5,-2.501) F3(1,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) G1(0,-3.001) G2(0.5,-3.001) G3(1,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) H1(0,-3.501) H2(0.5,-3.501) H3(1,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501)
JAE_DX07S024XJ1_24P-T
  round 0.762 hole 0.762 unplated: (-0.85,-0.66)
  oval 0.94x0.762 hole 0.94x0.762 unplated: (6.35,-0.66)
  oval 0.305x1.092 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  round 0.61 hole 0.406: B1(5.55,-1.31) B2(5.15,-2.01) B3(4.35,-2.01) B4(3.95,-1.31) B5(3.55,-2.01) B6(3.15,-1.31) B7(2.35,-1.31) B8(1.95,-2.01) B9(1.55,-1.31) B10(1.15,-2.01) B11(0.35,-2.01) B12(-0.05,-1.31)
  oval 1.092x2.108 hole 0.61x1.6: G1(-1.85,-2.06) G2(7.35,-2.06) G3(-1.85,-5.06) G4(7.35,-5.06)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
KC_FBMA-L11-160808-800LMT_2P
  rect 0.889x1.092 smd: 1(0,0) 2(1.5,0)
LCN_BAM04-20093-0500_20P
  oval 0.203x0.762 smd: 1(0,0) 2(0,-3.95) 3(0.4,0) 4(0.4,-3.95) 5(0.8,0) 6(0.8,-3.95) 7(1.2,0) 8(1.2,-3.95) 9(1.6,0) 10(1.6,-3.95) 11(2,0) 12(2,-3.95) 13(2.4,0) 14(2.4,-3.95) 15(2.8,0) 16(2.8,-3.95) 17(3.2,0) 18(3.2,-3.95) 19(3.6,0) 20(3.6,-3.95)
  rect 0.559x0.508 smd: 21(-1.115,-1.525) 22(-1.115,-2.425) 23(4.715,-1.525) 24(4.715,-2.425)
LCN_DAN05-67216-S500_75P-T-S
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(14.5,0) 60(14.75,-7.55) 61(15,0) 62(15.25,-7.55) 63(15.5,0) 64(15.75,-7.55) 65(16,0) 66(16.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
LCN_DAN05-67216-S503_75P-T-S
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 67(16.5,0) 68(16.75,-7.55) 69(17,0) 70(17.25,-7.55) 71(17.5,0) 72(17.75,-7.55) 73(18,0) 74(18.25,-7.55) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.775) 77(19.6,-0.775)
LED_HT-191UD5_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LM393DMR2G_MICRO8
  oval 0.381x1.041 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.24) 6(1.3,4.24) 7(0.65,4.24) 8(0,4.24)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
M74VHC1GT00DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MAG_MMD-05AE-R15MEM1L_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
MAG_MMD-06AEI1R5M-M1L_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
MC74VHC1G32DFT2G_SC70-5
  oval 0.457x0.711 smd: 1(-0.65,-0.925) 2(0,-0.925) 3(0.65,-0.925) 4(0.65,0.925) 5(-0.65,0.925)
MEC1641-PZV_TFBGA_144P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) A12(5.501,0) A13(6.002,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) B12(5.501,-0.5) B13(6.002,-0.5) C1(0,-1) C2(0.5,-1) C3(1,-1) C4(1.5,-1) C5(2.001,-1) C6(2.501,-1) C7(3.001,-1) C8(3.501,-1) C9(4.001,-1) C10(4.501,-1) C11(5.001,-1) C12(5.501,-1) C13(6.002,-1) D1(0,-1.5) D2(0.5,-1.5) D3(1,-1.5) D4(1.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D9(4.001,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) D12(5.501,-1.5) D13(6.002,-1.5) E1(0,-2.001) E2(0.5,-2.001) E3(1,-2.001) E4(1.5,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) E12(5.501,-2.001) E13(6.002,-2.001) F1(0,-2.501) F2(0.5,-2.501) F3(1,-2.501) F4(1.5,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) F12(5.501,-2.501) F13(6.002,-2.501) G1(0,-3.001) G2(0.5,-3.001) G3(1,-3.001) G4(1.5,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) G12(5.501,-3.001) G13(6.002,-3.001) H1(0,-3.501) H2(0.5,-3.501) H3(1,-3.501) H4(1.5,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) H12(5.501,-3.501) H13(6.002,-3.501) J1(0,-4.001) J2(0.5,-4.001) J3(1,-4.001) J4(1.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) J12(5.501,-4.001) J13(6.002,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) K12(5.501,-4.501) K13(6.002,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001) L12(5.501,-5.001) L13(6.002,-5.001) M1(0,-5.501) M2(0.5,-5.501) M3(1,-5.501) M4(1.5,-5.501) M5(2.001,-5.501) M6(2.501,-5.501) M7(3.001,-5.501) M8(3.501,-5.501) M9(4.001,-5.501) M10(4.501,-5.501) M11(5.001,-5.501) M12(5.501,-5.501) M13(6.002,-5.501) N1(0,-6.002) N2(0.5,-6.002) N3(1,-6.002) N4(1.5,-6.002) N5(2.001,-6.002) N6(2.501,-6.002) N7(3.001,-6.002) N8(3.501,-6.002) N9(4.001,-6.002) N10(4.501,-6.002) N11(5.001,-6.002) N12(5.501,-6.002) N13(6.002,-6.002)
MMBT3904WH_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MURAT_BLM15AX100SN1D_2P
  rect 0.457x0.508 smd: 1(-0.05,0) 2(0.8,0)
MURAT_BLM15HD182SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX181SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX330SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM18EG221SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM21PG600SN1D_2P
  rect 0.991x1.753 smd: 1(0,0) 2(1.5,0)
MURAT_DLW21HN900HQ2L_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_DLW21SN670HQ2L_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
MURAT_LQG15HN1N0S02D_2P
  rect 0.533x0.559 smd: 1(0,0) 2(0.925,0)
MURAT_LQM2MPN2R2NG0L_2P
  rect 0.787x1.803 smd: 1(0,0) 2(1.6,0)
NB679GD-Z_QFN12_2X3
  oval 1.702x0.254 smd: 1(0,0) 2(0,-1) 7(1.3,-0.5)
  oval 0.254x0.889 smd: 3(-0.1,-2.05) 4(0.4,-2.05) 5(0.9,-2.05) 6(1.4,-2.05) 9(1.4,1.05) 10(0.9,1.05) 11(0.4,1.05) 12(-0.1,1.05)
  oval 0.889x0.254 smd: 8(1.706,0)
NB680GD-Z_QFN12_2X3
  oval 1.702x0.254 smd: 1(0,0) 2(0,-1) 7(1.3,-0.5)
  oval 0.254x0.889 smd: 3(-0.1,-2.05) 4(0.4,-2.05) 5(0.9,-2.05) 6(1.4,-2.05) 9(1.4,1.05) 10(0.9,1.05) 11(0.4,1.05) 12(-0.1,1.05)
  oval 0.889x0.254 smd: 8(1.706,0)
NB685GQ-Z_QFN16_3X3
  oval 2.311x0.254 smd: 1(0,0) 2(0,-1) 9(1.7,-0.5)
  oval 0.254x0.889 smd: 3(-0.4,-2.05) 4(0.1,-2.05) 5(0.6,-2.05) 6(1.1,-2.05) 7(1.6,-2.05) 8(2.1,-2.05) 11(2.1,1.05) 12(1.6,1.05) 13(1.1,1.05) 14(0.6,1.05) 15(0.1,1.05) 16(-0.4,1.05)
  oval 1.092x0.254 smd: 10(2.31,0)
NL17SZ14DFT2G_SOT353-5
  oval 0.381x1.219 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
NPCT650JAAYX_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
P5103EMG_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PJSOT24CW_SOT323-3
  oval 0.66x0.864 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
PS8330BQFN48GTR2-A0_QFN48_7X7
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 25(5.5,7.1) 26(5,7.1) 27(4.5,7.1) 28(4,7.1) 29(3.5,7.1) 30(3,7.1) 31(2.5,7.1) 32(2,7.1) 33(1.5,7.1) 34(1,7.1) 35(0.5,7.1) 36(0,7.1)
  oval 0.889x0.254 smd: 13(6.3,0.8) 14(6.3,1.3) 15(6.3,1.8) 16(6.3,2.3) 17(6.3,2.8) 18(6.3,3.3) 19(6.3,3.8) 20(6.3,4.3) 21(6.3,4.8) 22(6.3,5.3) 23(6.3,5.8) 24(6.3,6.3) 37(-0.8,6.3) 38(-0.8,5.8) 39(-0.8,5.3) 40(-0.8,4.8) 41(-0.8,4.3) 42(-0.8,3.8) 43(-0.8,3.3) 44(-0.8,2.8) 45(-0.8,2.3) 46(-0.8,1.8) 47(-0.8,1.3) 48(-0.8,0.8)
  rect 3.708x3.708 smd: 49(2.75,3.55)
PS8338BQFN60GTR-A0_QFN60_5X9
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 15(5.6,0) 16(6,0) 17(6.4,0) 18(6.8,0) 19(7.2,0) 20(7.6,0) 31(7.6,4.975) 32(7.2,4.975) 33(6.8,4.975) 34(6.4,4.975) 35(6,4.975) 36(5.6,4.975) 37(5.2,4.975) 38(4.8,4.975) 39(4.4,4.975) 40(4,4.975) 41(3.6,4.975) 42(3.2,4.975) 43(2.8,4.975) 44(2.4,4.975) 45(2,4.975) 46(1.6,4.975) 47(1.2,4.975) 48(0.8,4.975) 49(0.4,4.975) 50(0,4.975)
  oval 1.016x0.203 smd: 21(8.288,0.688) 22(8.288,1.088) 23(8.288,1.488) 24(8.288,1.888) 25(8.288,2.288) 26(8.288,2.688) 27(8.288,3.088) 28(8.288,3.488) 29(8.288,3.888) 30(8.288,4.288) 51(-0.688,4.288) 52(-0.688,3.888) 53(-0.688,3.488) 54(-0.688,3.088) 55(-0.688,2.688) 56(-0.688,2.288) 57(-0.688,1.888) 58(-0.688,1.488) 59(-0.688,1.088) 60(-0.688,0.688)
  rect 7.01x2.997 smd: 61(3.8,2.488)
PS8407ATQFN40GTR2A1_TQFN40_5X5
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 21(3.6,5.1) 22(3.2,5.1) 23(2.8,5.1) 24(2.4,5.1) 25(2,5.1) 26(1.6,5.1) 27(1.2,5.1) 28(0.8,5.1) 29(0.4,5.1) 30(0,5.1)
  oval 0.889x0.203 smd: 11(4.35,0.75) 12(4.35,1.15) 13(4.35,1.55) 14(4.35,1.95) 15(4.35,2.35) 16(4.35,2.75) 17(4.35,3.15) 18(4.35,3.55) 19(4.35,3.95) 20(4.35,4.35) 31(-0.75,4.35) 32(-0.75,3.95) 33(-0.75,3.55) 34(-0.75,3.15) 35(-0.75,2.75) 36(-0.75,2.35) 37(-0.75,1.95) 38(-0.75,1.55) 39(-0.75,1.15) 40(-0.75,0.75)
  rect 3.607x3.607 smd: 41(1.8,2.55)
PS8713BTQFN24GTR2_TQFN24_4X4
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,4.1) 14(2,4.1) 15(1.5,4.1) 16(1,4.1) 17(0.5,4.1) 18(0,4.1)
  oval 0.889x0.254 smd: 7(3.3,0.8) 8(3.3,1.3) 9(3.3,1.8) 10(3.3,2.3) 11(3.3,2.8) 12(3.3,3.3) 19(-0.8,3.3) 20(-0.8,2.8) 21(-0.8,2.3) 22(-0.8,1.8) 23(-0.8,1.3) 24(-0.8,0.8)
  rect 2.692x2.692 smd: 25(1.25,2.05)
R0201_0OHM
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R1206_0OHM
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB751S40T1G_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RT9069-33GB_SOT23-5
  oval 0.508x0.965 smd: 1(0,0) 2(0.94,0) 3(1.879,0) 4(1.879,2.339) 5(0,2.339)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SINGA_2HE2016-100211F_19P-T
  oval 0.203x1.143 smd: 1(0,0) 3(-0.4,0) 5(-0.8,0) 7(-1.2,0) 9(-1.6,0) 11(-2,0) 13(-2.4,0) 15(-2.8,0) 17(-3.2,0) 19(-3.6,0)
  oval 0.61x0.787 hole 0.406: 2(-0.2,-2.725) 4(-0.6,-1.275) 6(-1,-2.725) 8(-1.4,-1.275) 10(-1.8,-2.725) 12(-2.2,-1.275) 14(-2.6,-2.725) 16(-3,-1.275) 18(-3.4,-2.725)
  oval 0.965x2.21 hole 0.66x1.905: 20(1.3,-0.575) 22(-4.9,-0.575)
  oval 0.965x2.007 hole 0.66x1.702: 21(1.3,-4.075) 23(-4.9,-4.075)
SINGA_2SJ3095-079111F_6P-T
  oval 0.991x1.6 hole 0.61x1.194: 1(0,0) 5(-9.5,0)
  oval 0.991x1.803 hole 0.61x1.397: 2(-9.5,5.4) 3(-9.5,8.5) 4(0,7.7) 6(-9.5,2.65) 7(0,2.55)
SKL-Y-REV1P2_BGA_1515P-T
  round 0.305 smd: A5(0.909,0) A7(1.364,0) A9(1.903,0) A11(2.547,0) A14(3.191,0) A16(3.835,0) A18(4.479,0) A20(5.123,0) A22(5.768,0) A24(6.412,0) A26(7.056,0) A28(7.7,0) A30(8.344,0) A32(8.988,0) A34(9.632,0) A36(10.277,0) A38(10.921,0) A40(11.565,0) A42(12.209,0) A44(12.853,0) A46(13.497,0) A48(14.141,0) A50(14.786,0) A52(15.43,0) A54(16.074,0) A56(16.718,0) A58(17.263,0) A60(17.711,0) A62(18.166,0) A64(18.621,0) AA2(0.272,-5.609) AA4(0.765,-5.609) AA6(1.257,-5.609) AA8(1.75,-5.609) AA10(2.243,-5.609) AA12(2.736,-5.609) AA53(15.885,-5.609) AA55(16.378,-5.609) AA57(16.871,-5.609) AB1(0,-5.931) AB3(0.518,-5.931) AB5(1.011,-5.931) AB7(1.504,-5.931) AB9(1.996,-5.931) AB11(2.489,-5.931) AB13(2.982,-5.936) AB54(16.132,-5.931) AB56(16.624,-5.931) AB58(17.117,-5.931) AB64(18.621,-5.931) AC2(0.272,-6.253) AC4(0.765,-6.253) AC6(1.257,-6.253) AC8(1.75,-6.253) AC10(2.243,-6.253) AC12(2.736,-6.253) AC53(15.885,-6.253) AC55(16.378,-6.253) AC57(16.871,-6.253) AD1(0,-6.575) AD3(0.518,-6.575) AD5(1.011,-6.575) AD7(1.504,-6.575) AD9(1.996,-6.575) AD11(2.489,-6.575) AD13(2.982,-6.58) AD54(16.132,-6.575) AD56(16.624,-6.575) AD58(17.117,-6.575) AD64(18.621,-6.575) AE2(0.272,-6.897) AE4(0.765,-6.897) AE6(1.257,-6.897) AE8(1.75,-6.897) AE10(2.243,-6.897) AE12(2.736,-6.897) AE53(15.885,-6.897) AE55(16.378,-6.897) AE57(16.871,-6.897) AF1(0,-7.219) AF3(0.518,-7.219) AF5(1.011,-7.219) AF7(1.504,-7.219) AF9(1.996,-7.219) AF11(2.489,-7.219) AF13(2.982,-7.224) AF54(16.132,-7.219) AF56(16.624,-7.219) AF58(17.117,-7.219) AF60(17.61,-7.219) AF62(18.103,-7.219) AF64(18.621,-7.219) AG2(0.272,-7.541) AG4(0.765,-7.541) AG6(1.257,-7.541) AG8(1.75,-7.541) AG10(2.243,-7.541) AG12(2.736,-7.541) AG53(15.885,-7.541) AG55(16.378,-7.541) AG57(16.871,-7.541) AG59(17.363,-7.541) AG61(17.856,-7.541) AG63(18.349,-7.541) AH1(0,-7.863) AH3(0.518,-7.863) AH5(1.011,-7.863) AH7(1.504,-7.863) AH9(1.996,-7.863) AH11(2.489,-7.863) AH13(2.982,-7.868) AH54(16.132,-7.863) AH56(16.624,-7.863) AH58(17.117,-7.863) AH60(17.61,-7.863) AH62(18.103,-7.863) AH64(18.621,-7.863) AJ2(0.272,-8.185) AJ4(0.765,-8.185) AJ6(1.257,-8.185) AJ8(1.75,-8.185) AJ10(2.243,-8.185) AJ12(2.736,-8.185) AJ53(15.885,-8.185) AJ55(16.378,-8.185) AJ57(16.871,-8.185) AJ59(17.363,-8.185) AJ61(17.856,-8.185) AJ63(18.349,-8.185) AK1(0,-8.507) AK3(0.518,-8.507) AK5(1.011,-8.507) AK7(1.504,-8.507) AK9(1.996,-8.507) AK11(2.489,-8.507) AK13(2.982,-8.512) AK54(16.132,-8.507) AK56(16.624,-8.507) AK58(17.117,-8.507) AK60(17.61,-8.507) AK62(18.103,-8.507) AK64(18.621,-8.507) AL2(0.272,-8.829) AL4(0.765,-8.829) AL6(1.257,-8.829) AL8(1.75,-8.829) AL10(2.243,-8.829) AL12(2.736,-8.829) AL53(15.885,-8.829) AL55(16.378,-8.829) AL57(16.871,-8.829) AL59(17.363,-8.829) AL61(17.856,-8.829) AL63(18.349,-8.829) AM1(0,-9.151) AM3(0.518,-9.151) AM5(1.011,-9.151) AM7(1.504,-9.151) AM9(1.996,-9.151) AM11(2.489,-9.151) AM13(2.982,-9.156) AM54(16.132,-9.151) AM56(16.624,-9.151) AM58(17.117,-9.151) AM60(17.61,-9.151) AM62(18.103,-9.151) AM64(18.621,-9.151) AN2(0.272,-9.473) AN4(0.765,-9.473) AN6(1.257,-9.473) AN8(1.75,-9.473) AN10(2.243,-9.473) AN12(2.736,-9.473) AN53(15.885,-9.473) AN55(16.378,-9.473) AN57(16.871,-9.473) AN59(17.363,-9.473) AN61(17.856,-9.473) AN63(18.349,-9.473) AP1(0,-9.796) AP3(0.518,-9.796) AP5(1.011,-9.796) AP7(1.504,-9.796) AP9(1.996,-9.796) AP11(2.489,-9.796) AP13(2.982,-9.801) AP54(16.132,-9.796) AP56(16.624,-9.796) AP58(17.117,-9.796) AP60(17.61,-9.796) AP62(18.103,-9.796) AP64(18.621,-9.796) AR2(0.272,-10.118) AR4(0.765,-10.118) AR6(1.257,-10.118) AR8(1.75,-10.118) AR10(2.243,-10.118) AR12(2.736,-10.118) AR53(15.885,-10.118) AR55(16.378,-10.118) AR57(16.871,-10.118) AR59(17.363,-10.118) AR61(17.856,-10.118) AR63(18.349,-10.118) AT1(0,-10.44) AT3(0.518,-10.44) AT5(1.011,-10.44) AT7(1.504,-10.44) AT9(1.996,-10.44) AT11(2.489,-10.44) AT13(2.982,-10.445) AT54(16.132,-10.44) AT56(16.624,-10.44) AT58(17.117,-10.44) AT60(17.61,-10.44) AT62(18.103,-10.44) AT64(18.621,-10.44) AU2(0.272,-10.762) AU4(0.765,-10.762) AU6(1.257,-10.762) AU8(1.75,-10.762) AU10(2.243,-10.762) AU12(2.736,-10.762) AU53(15.885,-10.762) AU55(16.378,-10.762) AU57(16.871,-10.762) AU59(17.363,-10.762) AU61(17.856,-10.762) AU63(18.349,-10.762) AV1(0,-11.084) AV3(0.518,-11.084) AV5(1.011,-11.084) AV7(1.504,-11.084) AV9(1.996,-11.084) AV11(2.489,-11.084) AV13(2.982,-11.084) AV15(3.429,-11.115) AV16(3.835,-11.115) AV18(4.479,-11.115) AV20(5.123,-11.115) AV22(5.768,-11.115) AV24(6.412,-11.115) AV26(7.056,-11.115) AV28(7.7,-11.115) AV30(8.344,-11.115) AV32(8.988,-11.115) AV34(9.632,-11.115) AV36(10.277,-11.115) AV38(10.921,-11.115) AV40(11.565,-11.115) AV42(12.209,-11.115) AV44(12.853,-11.115) AV46(13.497,-11.115) AV48(14.141,-11.115) AV50(14.786,-11.115) AV52(15.43,-11.115) AV54(16.132,-11.084) AV56(16.624,-11.084) AV58(17.117,-11.084) AV60(17.61,-11.084) AV62(18.103,-11.084) AV64(18.621,-11.084) AW2(0.272,-11.406) AW4(0.765,-11.406) AW6(1.257,-11.406) AW8(1.75,-11.406) AW10(2.243,-11.406) AW12(2.736,-11.406) AW17(4.157,-11.361) AW19(4.801,-11.361) AW21(5.446,-11.361) AW23(6.09,-11.361) AW25(6.734,-11.361) AW27(7.378,-11.361) AW29(8.022,-11.361) AW31(8.666,-11.361) AW33(9.31,-11.361) AW35(9.955,-11.361) AW37(10.599,-11.361) AW39(11.243,-11.361) AW41(11.887,-11.361) AW43(12.531,-11.361) AW45(13.175,-11.361) AW47(13.819,-11.361) AW49(14.464,-11.361) AW51(15.108,-11.361) AW53(15.752,-11.369) AW55(16.378,-11.406) AW57(16.871,-11.406) AW59(17.363,-11.406) AW61(17.856,-11.406) AW63(18.349,-11.406) AY14(3.316,-11.501) AY16(3.835,-11.607) AY18(4.479,-11.607) AY20(5.123,-11.607) AY22(5.768,-11.607) AY24(6.412,-11.607) AY26(7.056,-11.607) AY28(7.7,-11.607) AY30(8.344,-11.607) AY32(8.988,-11.607) AY34(9.632,-11.607) AY36(10.277,-11.607) AY38(10.921,-11.607) AY40(11.565,-11.607) AY42(12.209,-11.607) AY44(12.853,-11.607) AY46(13.497,-11.607) AY48(14.141,-11.607) AY50(14.786,-11.607) AY52(15.43,-11.607) B3(0.429,-0.429) B4(0.859,-0.429) B6(1.288,-0.429) B8(1.717,-0.429) B10(2.225,-0.272) B12(2.869,-0.272) B15(3.513,-0.272) B17(4.157,-0.272) B19(4.801,-0.272) B21(5.446,-0.272) B23(6.09,-0.272) B25(6.734,-0.272) B27(7.378,-0.272) B29(8.022,-0.272) B31(8.666,-0.272) B33(9.31,-0.272) B35(9.955,-0.272) B37(10.599,-0.272) B39(11.243,-0.272) B41(11.887,-0.272) B43(12.531,-0.272) B45(13.175,-0.272) B47(13.819,-0.272) B49(14.464,-0.272) B51(15.108,-0.272) B53(15.752,-0.272) B55(16.396,-0.272) B58(17.088,-0.363) B61(17.79,-0.429) B62(18.191,-0.429) B64(18.621,-0.455) BA1(0,-11.728) BA3(0.518,-11.728) BA5(1.011,-11.728) BA7(1.504,-11.728) BA9(1.996,-11.728) BA11(2.489,-11.728) BA13(2.982,-11.728) BA15(3.513,-11.854) BA17(4.157,-11.854) BA19(4.801,-11.854) BA21(5.446,-11.854) BA23(6.09,-11.854) BA25(6.734,-11.854) BA27(7.378,-11.854) BA29(8.022,-11.854) BA31(8.666,-11.854) BA33(9.31,-11.854) BA35(9.955,-11.854) BA37(10.599,-11.854) BA39(11.243,-11.854) BA41(11.887,-11.854) BA43(12.531,-11.854) BA45(13.175,-11.854) BA47(13.819,-11.854) BA49(14.464,-11.854) BA51(15.108,-11.854) BA53(15.752,-11.861) BA56(16.624,-11.728) BA58(17.117,-11.728) BA60(17.61,-11.728) BA62(18.103,-11.728) BA64(18.621,-11.728) BB2(0.272,-12.05) BB4(0.765,-12.05) BB6(1.257,-12.05) BB8(1.75,-12.05) BB10(2.243,-12.05) BB12(2.762,-12.1) BB14(3.191,-12.1) BB16(3.835,-12.1) BB18(4.479,-12.1) BB20(5.123,-12.1) BB22(5.768,-12.1) BB24(6.412,-12.1) BB26(7.056,-12.1) BB28(7.7,-12.1) BB30(8.344,-12.1) BB32(8.988,-12.1) BB34(9.632,-12.1) BB36(10.277,-12.1) BB38(10.921,-12.1) BB40(11.565,-12.1) BB42(12.209,-12.1) BB44(12.853,-12.1) BB46(13.497,-12.1) BB48(14.141,-12.1) BB50(14.786,-12.1) BB52(15.43,-12.1) BB54(16.074,-12.1) BB57(16.871,-12.05) BB59(17.363,-12.05) BB61(17.856,-12.05) BB63(18.349,-12.05) BC1(0,-12.372) BC3(0.518,-12.372) BC5(1.011,-12.372) BC7(1.504,-12.372) BC9(1.996,-12.372) BC11(2.615,-12.519) BC15(3.513,-12.346) BC17(4.157,-12.346) BC19(4.801,-12.346) BC21(5.446,-12.346) BC23(6.09,-12.346) BC25(6.734,-12.346) BC27(7.378,-12.346) BC29(8.022,-12.346) BC31(8.666,-12.346) BC33(9.31,-12.346) BC35(9.955,-12.346) BC37(10.599,-12.346) BC39(11.243,-12.346) BC41(11.887,-12.346) BC43(12.531,-12.346) BC45(13.175,-12.346) BC47(13.819,-12.346) BC49(14.464,-12.346) BC51(15.108,-12.346) BC53(15.752,-12.346) BC55(16.396,-12.346) BC58(17.117,-12.372) BC60(17.61,-12.372) BC62(18.103,-12.372) BC64(18.621,-12.372) BD2(0.272,-12.694) BD4(0.765,-12.694) BD6(1.257,-12.694) BD8(1.75,-12.694) BD10(2.243,-12.69) BD14(3.191,-12.593) BD16(3.835,-12.593) BD18(4.479,-12.593) BD20(5.123,-12.593) BD22(5.768,-12.593) BD24(6.412,-12.593) BD26(7.056,-12.593) BD28(7.7,-12.593) BD30(8.344,-12.593) BD32(8.988,-12.593) BD34(9.632,-12.593) BD36(10.277,-12.593) BD38(10.921,-12.593) BD40(11.565,-12.593) BD42(12.209,-12.593) BD44(12.853,-12.593) BD46(13.497,-12.593) BD48(14.141,-12.593) BD50(14.786,-12.593) BD52(15.43,-12.593) BD54(16.074,-12.593) BD56(16.718,-12.593) BD59(17.443,-12.778) BD61(17.856,-12.694) BD63(18.349,-12.694) BE12(2.869,-12.839) BE15(3.513,-12.839) BE17(4.157,-12.839) BE19(4.801,-12.839) BE21(5.446,-12.839) BE23(6.09,-12.839) BE25(6.734,-12.839) BE27(7.378,-12.839) BE29(8.022,-12.839) BE31(8.666,-12.839) BE33(9.31,-12.839) BE35(9.955,-12.839) BE37(10.599,-12.839) BE39(11.243,-12.839) BE41(11.887,-12.839) BE43(12.531,-12.839) BE45(13.175,-12.839) BE47(13.819,-12.839) BE49(14.464,-12.839) BE51(15.108,-12.839) BE53(15.752,-12.839) BE55(16.396,-12.839) BE57(17.04,-12.839) BF1(0,-13.016) BF3(0.518,-13.016) BF5(1.011,-13.016) BF7(1.504,-13.016) BF9(2.002,-13.021) BF11(2.547,-13.086) BF14(3.191,-13.086) BF16(3.835,-13.086) BF18(4.479,-13.086) BF20(5.123,-13.086) BF22(5.768,-13.086) BF24(6.412,-13.086) BF26(7.056,-13.086) BF28(7.7,-13.086) BF30(8.344,-13.086) BF32(8.988,-13.086) BF34(9.632,-13.086) BF36(10.277,-13.086) BF38(10.921,-13.086) BF40(11.565,-13.086) BF42(12.209,-13.086) BF44(12.853,-13.086) BF46(13.497,-13.086) BF48(14.141,-13.086) BF50(14.786,-13.086) BF52(15.43,-13.086) BF54(16.074,-13.086) BF56(16.718,-13.086) BF59(17.474,-13.18) BF62(18.103,-13.016) BF64(18.621,-13.016) BG2(0.272,-13.338) BG4(0.765,-13.338) BG6(1.257,-13.338) BG8(1.75,-13.338) BG10(2.14,-13.431) BG12(2.869,-13.332) BG15(3.513,-13.332) BG17(4.157,-13.332) BG19(4.801,-13.332) BG21(5.446,-13.332) BG23(6.09,-13.332) BG25(6.734,-13.332) BG27(7.378,-13.332) BG29(8.022,-13.332) BG31(8.666,-13.332) BG33(9.31,-13.332) BG35(9.955,-13.332) BG37(10.599,-13.332) BG39(11.243,-13.332) BG41(11.887,-13.332) BG43(12.531,-13.332) BG45(13.175,-13.332) BG47(13.819,-13.332) BG49(14.464,-13.332) BG51(15.108,-13.332) BG53(15.752,-13.332) BG55(16.396,-13.332) BG57(17.04,-13.332) BG61(17.856,-13.338) BG63(18.349,-13.338) BH11(2.547,-13.578) BH14(3.191,-13.578) BH16(3.835,-13.578) BH18(4.479,-13.578) BH20(5.123,-13.578) BH22(5.768,-13.578) BH24(6.412,-13.578) BH26(7.056,-13.578) BH28(7.7,-13.578) BH30(8.344,-13.578) BH32(8.988,-13.578) BH34(9.632,-13.578) BH36(10.277,-13.578) BH38(10.921,-13.578) BH40(11.565,-13.578) BH42(12.209,-13.578) BH44(12.853,-13.578) BH46(13.497,-13.578) BH48(14.141,-13.578) BH50(14.786,-13.578) BH52(15.43,-13.578) BH54(16.074,-13.578) BH56(16.718,-13.578) BH59(17.362,-13.578) BJ1(0,-13.718) BJ3(0.429,-13.794) BJ4(0.859,-13.794) BJ6(1.288,-13.794) BJ8(1.717,-13.794) BJ10(2.225,-13.825) BJ12(2.869,-13.825) BJ15(3.513,-13.825) BJ17(4.157,-13.825) BJ19(4.801,-13.825) BJ21(5.446,-13.825) BJ23(6.09,-13.825) BJ25(6.734,-13.825) BJ27(7.378,-13.825) BJ29(8.022,-13.825) BJ31(8.666,-13.825) BJ33(9.31,-13.825) BJ35(9.955,-13.825) BJ37(10.599,-13.825) BJ39(11.243,-13.825) BJ41(11.887,-13.825) BJ43(12.531,-13.825) BJ45(13.175,-13.825) BJ47(13.819,-13.825) BJ49(14.464,-13.825) BJ51(15.108,-13.825) BJ53(15.752,-13.825) BJ55(16.396,-13.825) BJ57(17.04,-13.825) BJ61(17.762,-13.794) BJ62(18.191,-13.794) BJ64(18.621,-13.718) BK11(2.547,-14.071) BK14(3.191,-14.071) BK16(3.835,-14.071) BK18(4.479,-14.071) BK20(5.123,-14.071) BK22(5.768,-14.071) BK24(6.412,-14.071) BK26(7.056,-14.071) BK28(7.7,-14.071) BK30(8.344,-14.071) BK32(8.988,-14.071) BK34(9.632,-14.071) BK36(10.277,-14.071) BK38(10.921,-14.071) BK40(11.565,-14.071) BK42(12.209,-14.071) BK44(12.853,-14.071) BK46(13.497,-14.071) BK48(14.141,-14.071) BK50(14.786,-14.071) BK52(15.43,-14.071) BK54(16.074,-14.071) BK56(16.718,-14.071) BK59(17.413,-13.995) BL1(0,-14.173) BL3(0.429,-14.223) BL4(0.859,-14.223) BL6(1.288,-14.223) BL8(1.717,-14.223) BL10(2.225,-14.317) BL12(2.869,-14.317) BL15(3.513,-14.317) BL17(4.157,-14.317) BL19(4.801,-14.317) BL21(5.446,-14.317) BL23(6.09,-14.317) BL25(6.734,-14.317) BL27(7.378,-14.317) BL29(8.022,-14.317) BL31(8.666,-14.317) BL33(9.31,-14.317) BL35(9.955,-14.317) BL37(10.599,-14.317) BL39(11.243,-14.317) BL41(11.887,-14.317) BL43(12.531,-14.317) BL45(13.175,-14.317) BL47(13.819,-14.317) BL49(14.464,-14.317) BL51(15.108,-14.317) BL53(15.752,-14.317) BL55(16.396,-14.317) BL57(17.04,-14.31) BL61(17.762,-14.223) BL62(18.191,-14.223) BL64(18.621,-14.173) BM11(2.547,-14.564) BM14(3.191,-14.564) BM16(3.835,-14.564) BM18(4.479,-14.564) BM20(5.123,-14.564) BM22(5.768,-14.564) BM24(6.412,-14.564) BM26(7.056,-14.564) BM28(7.7,-14.564) BM30(8.344,-14.564) BM32(8.988,-14.564) BM34(9.632,-14.564) BM36(10.277,-14.564) BM38(10.921,-14.564) BM40(11.565,-14.564) BM42(12.209,-14.564) BM44(12.853,-14.564) BM46(13.497,-14.564) BM48(14.141,-14.564) BM50(14.786,-14.564) BM52(15.43,-14.564) BM54(16.074,-14.564) BM56(16.718,-14.564) BM59(17.409,-14.464) BN1(0,-14.627) BN3(0.429,-14.653) BN4(0.859,-14.653) BN6(1.288,-14.653) BN8(1.717,-14.653) BN10(2.225,-14.81) BN12(2.869,-14.81) BN15(3.513,-14.81) BN17(4.157,-14.81) BN19(4.801,-14.81) BN21(5.446,-14.81) BN23(6.09,-14.81) BN25(6.734,-14.81) BN27(7.378,-14.81) BN29(8.022,-14.81) BN31(8.666,-14.81) BN33(9.31,-14.81) BN35(9.955,-14.81) BN37(10.599,-14.81) BN39(11.243,-14.81) BN41(11.887,-14.81) BN43(12.531,-14.81) BN45(13.175,-14.81) BN47(13.819,-14.81) BN49(14.464,-14.81) BN51(15.108,-14.81) BN53(15.752,-14.81) BN55(16.396,-14.81) BN58(17.088,-14.719) BN61(17.762,-14.653) BN62(18.191,-14.653) BN64(18.621,-14.627) BP1(0,-15.082) BP3(0.455,-15.082) BP5(0.909,-15.082) BP7(1.364,-15.082) BP9(1.903,-15.082) BP11(2.547,-15.082) BP14(3.191,-15.082) BP16(3.835,-15.082) BP18(4.479,-15.082) BP20(5.123,-15.082) BP22(5.768,-15.082) BP24(6.412,-15.082) BP26(7.056,-15.082) BP28(7.7,-15.082) BP30(8.344,-15.082) BP32(8.988,-15.082) BP34(9.632,-15.082) BP36(10.277,-15.082) BP38(10.921,-15.082) BP40(11.565,-15.082) BP42(12.209,-15.082) BP44(12.853,-15.082) BP46(13.497,-15.082) BP48(14.141,-15.082) BP50(14.786,-15.082) BP52(15.43,-15.082) BP54(16.074,-15.082) BP56(16.718,-15.082) BP58(17.257,-15.082) BP60(17.711,-15.082) BP62(18.166,-15.082) BP64(18.621,-15.082) C11(2.547,-0.518) C14(3.191,-0.518) C16(3.835,-0.518) C18(4.479,-0.518) C20(5.123,-0.518) C22(5.768,-0.518) C24(6.412,-0.518) C26(7.056,-0.518) C28(7.7,-0.518) C30(8.344,-0.518) C32(8.988,-0.518) C34(9.632,-0.518) C36(10.277,-0.518) C38(10.921,-0.518) C40(11.565,-0.518) C42(12.209,-0.518) C44(12.853,-0.518) C46(13.497,-0.518) C48(14.141,-0.518) C50(14.786,-0.518) C52(15.43,-0.518) C54(16.074,-0.518) C56(16.713,-0.518) C59(17.421,-0.623) D1(0,-0.909) D3(0.429,-0.859) D4(0.859,-0.859) D6(1.288,-0.859) D8(1.717,-0.859) D10(2.225,-0.765) D12(2.869,-0.765) D15(3.513,-0.765) D17(4.157,-0.765) D19(4.801,-0.765) D21(5.446,-0.765) D23(6.09,-0.765) D25(6.734,-0.765) D27(7.378,-0.765) D29(8.022,-0.765) D31(8.666,-0.765) D33(9.31,-0.765) D35(9.955,-0.765) D37(10.599,-0.765) D39(11.243,-0.765) D41(11.887,-0.765) D43(12.531,-0.765) D45(13.175,-0.765) D47(13.819,-0.765) D49(14.464,-0.765) D51(15.108,-0.765) D53(15.752,-0.765) D55(16.459,-0.853) D57(17.035,-0.785) D61(17.762,-0.859) D62(18.191,-0.859) D64(18.621,-0.909) E11(2.547,-1.011) E14(3.191,-1.011) E16(3.835,-1.011) E18(4.479,-1.011) E20(5.123,-1.011) E22(5.768,-1.011) E24(6.412,-1.011) E26(7.056,-1.011) E28(7.7,-1.011) E30(8.344,-1.011) E32(8.988,-1.011) E34(9.632,-1.011) E36(10.277,-1.011) E38(10.921,-1.011) E40(11.565,-1.011) E42(12.209,-1.011) E44(12.853,-1.011) E46(13.497,-1.011) E48(14.141,-1.011) E50(14.786,-1.011) E52(15.43,-1.011) E54(16.074,-1.011) E56(16.82,-1.138) E59(17.399,-1.128) F1(0,-1.364) F3(0.429,-1.288) F4(0.859,-1.288) F6(1.288,-1.288) F8(1.717,-1.288) F10(2.225,-1.257) F12(2.869,-1.257) F15(3.513,-1.257) F17(4.157,-1.257) F19(4.801,-1.257) F21(5.446,-1.257) F23(6.09,-1.257) F25(6.734,-1.257) F27(7.378,-1.257) F29(8.022,-1.257) F31(8.666,-1.257) F33(9.31,-1.257) F35(9.955,-1.257) F37(10.599,-1.257) F39(11.243,-1.257) F41(11.887,-1.257) F43(12.531,-1.257) F45(13.175,-1.257) F47(13.819,-1.257) F49(14.464,-1.257) F51(15.108,-1.257) F53(15.752,-1.257) F55(16.396,-1.257) F61(17.788,-1.288) F62(18.191,-1.288) F64(18.621,-1.37) G11(2.547,-1.504) G14(3.191,-1.504) G16(3.835,-1.504) G18(4.479,-1.504) G20(5.123,-1.504) G22(5.768,-1.504) G24(6.412,-1.504) G26(7.056,-1.504) G28(7.7,-1.504) G30(8.344,-1.504) G32(8.988,-1.504) G34(9.632,-1.504) G36(10.277,-1.504) G38(10.921,-1.504) G40(11.565,-1.504) G42(12.209,-1.504) G44(12.853,-1.504) G46(13.497,-1.504) G48(14.141,-1.504) G50(14.786,-1.504) G52(15.43,-1.504) G54(16.074,-1.504) G56(16.728,-1.53) G58(17.129,-1.445) H2(0.272,-1.744) H4(0.765,-1.744) H6(1.257,-1.744) H8(1.75,-1.744) H10(2.14,-1.651) H12(2.869,-1.75) H15(3.513,-1.75) H17(4.157,-1.75) H19(4.801,-1.75) H21(5.446,-1.75) H23(6.09,-1.75) H25(6.734,-1.75) H27(7.378,-1.75) H29(8.022,-1.75) H31(8.666,-1.75) H33(9.31,-1.75) H35(9.955,-1.75) H37(10.599,-1.75) H39(11.243,-1.75) H41(11.887,-1.75) H43(12.531,-1.75) H45(13.175,-1.75) H47(13.819,-1.75) H49(14.464,-1.75) H51(15.108,-1.75) H53(15.752,-1.75) H55(16.396,-1.758) H59(17.441,-1.702) H61(17.856,-1.744) J1(0,-2.066) J3(0.518,-2.066) J5(1.011,-2.066) J7(1.504,-2.066) J9(1.996,-2.066) J11(2.547,-1.996) J14(3.191,-1.996) J16(3.835,-1.996) J18(4.479,-1.996) J20(5.123,-1.996) J22(5.768,-1.996) J24(6.412,-1.996) J26(7.056,-1.996) J28(7.7,-1.996) J30(8.344,-1.996) J32(8.988,-1.996) J34(9.632,-1.996) J36(10.277,-1.996) J38(10.921,-1.996) J40(11.565,-1.996) J42(12.209,-1.996) J44(12.853,-1.996) J46(13.497,-1.996) J48(14.141,-1.996) J50(14.786,-1.996) J52(15.43,-1.996) J54(16.074,-1.996) J56(16.718,-1.996) J58(17.116,-1.935) J60(17.61,-2.066) J62(18.103,-2.066) J64(18.621,-2.066) K12(2.869,-2.243) K15(3.513,-2.243) K17(4.157,-2.243) K19(4.801,-2.243) K21(5.446,-2.243) K23(6.09,-2.243) K25(6.734,-2.243) K27(7.378,-2.243) K29(8.022,-2.243) K31(8.666,-2.243) K33(9.31,-2.243) K35(9.955,-2.243) K37(10.599,-2.243) K39(11.243,-2.243) K41(11.887,-2.243) K43(12.531,-2.243) K45(13.175,-2.243) K47(13.819,-2.243) K49(14.464,-2.243) K51(15.108,-2.243) K53(15.752,-2.243) K55(16.396,-2.243) L2(0.272,-2.388) L4(0.765,-2.388) L6(1.257,-2.388) L8(1.75,-2.388) L10(2.243,-2.388) L14(3.191,-2.489) L16(3.835,-2.489) L18(4.479,-2.489) L20(5.123,-2.489) L22(5.768,-2.489) L24(6.412,-2.489) L26(7.056,-2.489) L28(7.7,-2.489) L30(8.344,-2.489) L32(8.988,-2.489) L34(9.632,-2.489) L36(10.277,-2.489) L38(10.921,-2.489) L40(11.565,-2.489) L42(12.209,-2.489) L44(12.853,-2.489) L46(13.497,-2.489) L48(14.141,-2.489) L50(14.786,-2.489) L52(15.43,-2.489) L54(16.074,-2.489) L57(16.971,-2.309) L59(17.363,-2.388) L61(17.856,-2.388) M1(0,-2.71) M3(0.518,-2.71) M5(1.011,-2.71) M7(1.504,-2.71) M9(1.996,-2.71) M11(2.489,-2.71) M15(3.513,-2.736) M17(4.157,-2.736) M19(4.801,-2.736) M21(5.446,-2.736) M23(6.09,-2.736) M25(6.734,-2.736) M27(7.378,-2.736) M29(8.022,-2.736) M31(8.666,-2.736) M33(9.31,-2.736) M35(9.955,-2.736) M37(10.599,-2.736) M39(11.243,-2.736) M41(11.887,-2.736) M43(12.531,-2.736) M45(13.175,-2.736) M47(13.819,-2.736) M49(14.464,-2.736) M51(15.108,-2.736) M53(15.752,-2.736) M56(16.652,-2.551) M58(17.117,-2.71) M64(18.621,-2.71) N2(0.272,-3.032) N4(0.765,-3.032) N6(1.257,-3.032) N8(1.75,-3.032) N10(2.243,-3.032) N12(2.736,-3.032) N14(3.191,-2.982) N16(3.835,-2.982) N18(4.479,-2.982) N20(5.123,-2.982) N22(5.768,-2.982) N24(6.412,-2.982) N26(7.056,-2.982) N28(7.7,-2.982) N30(8.344,-2.982) N32(8.988,-2.982) N34(9.632,-2.982) N36(10.277,-2.982) N38(10.921,-2.982) N40(11.565,-2.982) N42(12.209,-2.982) N44(12.853,-2.982) N46(13.497,-2.982) N48(14.141,-2.982) N50(14.786,-2.982) N52(15.43,-2.982) N54(16.088,-2.954) N55(16.487,-2.916) N57(16.871,-3.032) P1(0,-3.354) P3(0.518,-3.354) P5(1.011,-3.354) P7(1.504,-3.354) P9(1.996,-3.354) P11(2.489,-3.354) P13(2.982,-3.359) P52(15.734,-3.264) P54(16.132,-3.354) P56(16.624,-3.354) P58(17.117,-3.354) P64(18.621,-3.354) R2(0.272,-3.676) R4(0.765,-3.676) R6(1.257,-3.676) R8(1.75,-3.676) R10(2.243,-3.676) R12(2.736,-3.676) R53(15.885,-3.676) R55(16.378,-3.676) R57(16.871,-3.676) T1(0,-3.998) T3(0.518,-3.998) T5(1.011,-3.998) T7(1.504,-3.998) T9(1.996,-3.998) T11(2.489,-3.998) T13(2.982,-4.003) T54(16.132,-3.998) T56(16.624,-3.998) T58(17.117,-3.998) T64(18.621,-3.998) U2(0.272,-4.32) U4(0.765,-4.32) U6(1.257,-4.32) U8(1.75,-4.32) U10(2.243,-4.32) U12(2.736,-4.32) U53(15.885,-4.32) U55(16.378,-4.32) U57(16.871,-4.32) V1(0,-4.642) V3(0.518,-4.642) V5(1.011,-4.642) V7(1.504,-4.642) V9(1.996,-4.642) V11(2.489,-4.642) V13(2.982,-4.647) V54(16.132,-4.642) V56(16.624,-4.642) V58(17.117,-4.642) V64(18.621,-4.642) W2(0.272,-4.964) W4(0.765,-4.964) W6(1.257,-4.964) W8(1.75,-4.964) W10(2.243,-4.964) W12(2.736,-4.964) W53(15.885,-4.964) W55(16.378,-4.964) W57(16.871,-4.964) Y1(0,-5.287) Y3(0.518,-5.287) Y5(1.011,-5.287) Y7(1.504,-5.287) Y9(1.996,-5.287) Y11(2.489,-5.287) Y13(2.982,-5.292) Y54(16.132,-5.287) Y56(16.624,-5.287) Y58(17.117,-5.287) Y64(18.621,-5.287)
  round 0.33 smd: AA15(3.464,-5.671) AA16(3.96,-5.671) AA18(4.455,-5.671) AA19(4.95,-5.671) AA21(5.446,-5.671) AA23(5.941,-5.671) AA24(6.436,-5.671) AA26(6.931,-5.671) AA27(7.427,-5.671) AA29(7.922,-5.671) AA30(8.417,-5.671) AA32(8.913,-5.671) AA33(9.408,-5.671) AA35(9.903,-5.671) AA36(10.399,-5.671) AA38(10.894,-5.671) AA40(11.389,-5.671) AA41(11.884,-5.671) AA43(12.38,-5.671) AA44(12.875,-5.671) AA46(13.37,-5.671) AA47(13.866,-5.671) AA49(14.361,-5.671) AA50(14.856,-5.671) AA51(15.352,-5.671) AC15(3.464,-6.23) AC16(3.96,-6.23) AC18(4.455,-6.23) AC19(4.95,-6.23) AC21(5.446,-6.23) AC23(5.941,-6.23) AC24(6.436,-6.23) AC26(6.931,-6.23) AC27(7.427,-6.23) AC29(7.922,-6.23) AC30(8.417,-6.23) AC32(8.913,-6.23) AC33(9.408,-6.23) AC35(9.903,-6.23) AC36(10.399,-6.23) AC38(10.894,-6.23) AC40(11.389,-6.23) AC41(11.884,-6.23) AC43(12.38,-6.23) AC44(12.875,-6.23) AC46(13.37,-6.23) AC47(13.866,-6.23) AC49(14.361,-6.23) AC50(14.856,-6.23) AC51(15.352,-6.23) AE15(3.464,-6.789) AE16(3.96,-6.789) AE18(4.455,-6.789) AE19(4.95,-6.789) AE21(5.446,-6.789) AE23(5.941,-6.789) AE24(6.436,-6.789) AE26(6.931,-6.789) AE27(7.427,-6.789) AE29(7.922,-6.789) AE30(8.417,-6.789) AE32(8.913,-6.789) AE33(9.408,-6.789) AE35(9.903,-6.789) AE36(10.399,-6.789) AE38(10.894,-6.789) AE40(11.389,-6.789) AE41(11.884,-6.789) AE43(12.38,-6.789) AE44(12.875,-6.789) AE46(13.37,-6.789) AE47(13.866,-6.789) AE49(14.361,-6.789) AE50(14.856,-6.789) AE51(15.352,-6.789) AF15(3.464,-7.348) AF16(3.96,-7.348) AF18(4.455,-7.348) AF19(4.95,-7.348) AF21(5.446,-7.348) AF23(5.941,-7.348) AF24(6.436,-7.348) AF26(6.931,-7.348) AF27(7.427,-7.348) AF29(7.922,-7.348) AF30(8.417,-7.348) AF32(8.913,-7.348) AF33(9.408,-7.348) AF35(9.903,-7.348) AF36(10.399,-7.348) AF38(10.894,-7.348) AF40(11.389,-7.348) AF41(11.884,-7.348) AF43(12.38,-7.348) AF44(12.875,-7.348) AF46(13.37,-7.348) AF47(13.866,-7.348) AF49(14.361,-7.348) AF50(14.856,-7.348) AF51(15.352,-7.348) AH15(3.464,-7.907) AH16(3.96,-7.907) AH18(4.455,-7.907) AH19(4.95,-7.907) AH21(5.446,-7.907) AH23(5.941,-7.907) AH24(6.436,-7.907) AH26(6.931,-7.907) AH27(7.427,-7.907) AH29(7.922,-7.907) AH30(8.417,-7.907) AH32(8.913,-7.907) AH33(9.408,-7.907) AH35(9.903,-7.907) AH36(10.399,-7.907) AH38(10.894,-7.907) AH40(11.389,-7.907) AH41(11.884,-7.907) AH43(12.38,-7.907) AH44(12.875,-7.907) AH46(13.37,-7.907) AH47(13.866,-7.907) AH49(14.361,-7.907) AH50(14.856,-7.907) AH51(15.352,-7.907) AK15(3.464,-8.465) AK16(3.96,-8.465) AK18(4.455,-8.465) AK19(4.95,-8.465) AK21(5.446,-8.465) AK23(5.941,-8.465) AK24(6.436,-8.465) AK26(6.931,-8.465) AK27(7.427,-8.465) AK29(7.922,-8.465) AK30(8.417,-8.465) AK32(8.913,-8.465) AK33(9.408,-8.465) AK35(9.903,-8.465) AK36(10.399,-8.465) AK38(10.894,-8.465) AK40(11.389,-8.465) AK41(11.884,-8.465) AK43(12.38,-8.465) AK44(12.875,-8.465) AK46(13.37,-8.465) AK47(13.866,-8.465) AK49(14.361,-8.465) AK50(14.856,-8.465) AK51(15.352,-8.465) AL15(3.464,-9.024) AL16(3.96,-9.024) AL18(4.455,-9.024) AL19(4.95,-9.024) AL21(5.446,-9.024) AL23(5.941,-9.024) AL24(6.436,-9.024) AL26(6.931,-9.024) AL27(7.427,-9.024) AL29(7.922,-9.024) AL30(8.417,-9.024) AL32(8.913,-9.024) AL33(9.408,-9.024) AL35(9.903,-9.024) AL36(10.399,-9.024) AL38(10.894,-9.024) AL40(11.389,-9.024) AL41(11.884,-9.024) AL43(12.38,-9.024) AL44(12.875,-9.024) AL46(13.37,-9.024) AL47(13.866,-9.024) AL49(14.361,-9.024) AL50(14.856,-9.024) AL51(15.352,-9.024) AN15(3.464,-9.583) AN16(3.96,-9.583) AN18(4.455,-9.583) AN19(4.95,-9.583) AN21(5.446,-9.583) AN23(5.941,-9.583) AN24(6.436,-9.583) AN26(6.931,-9.583) AN27(7.427,-9.583) AN29(7.922,-9.583) AN30(8.417,-9.583) AN32(8.913,-9.583) AN33(9.408,-9.583) AN35(9.903,-9.583) AN36(10.399,-9.583) AN38(10.894,-9.583) AN40(11.389,-9.583) AN41(11.884,-9.583) AN43(12.38,-9.583) AN44(12.875,-9.583) AN46(13.37,-9.583) AN47(13.866,-9.583) AN49(14.361,-9.583) AN50(14.856,-9.583) AN51(15.352,-9.583) AR15(3.464,-10.142) AR16(3.96,-10.142) AR18(4.455,-10.142) AR19(4.95,-10.142) AR21(5.446,-10.142) AR23(5.941,-10.142) AR24(6.436,-10.142) AR26(6.931,-10.142) AR27(7.427,-10.142) AR29(7.922,-10.142) AR30(8.417,-10.142) AR32(8.913,-10.142) AR33(9.408,-10.142) AR35(9.903,-10.142) AR36(10.399,-10.142) AR38(10.894,-10.142) AR40(11.389,-10.142) AR41(11.884,-10.142) AR43(12.38,-10.142) AR44(12.875,-10.142) AR46(13.37,-10.142) AR47(13.866,-10.142) AR49(14.361,-10.142) AR50(14.856,-10.142) AR51(15.352,-10.142) AT15(3.464,-10.701) AT16(3.96,-10.701) AT18(4.455,-10.701) AT19(4.95,-10.701) AT21(5.446,-10.701) AT23(5.941,-10.701) AT24(6.436,-10.701) AT26(6.931,-10.701) AT27(7.427,-10.701) AT29(7.922,-10.701) AT30(8.417,-10.701) AT32(8.913,-10.701) AT33(9.408,-10.701) AT35(9.903,-10.701) AT36(10.399,-10.701) AT38(10.894,-10.701) AT40(11.389,-10.701) AT41(11.884,-10.701) AT43(12.38,-10.701) AT44(12.875,-10.701) AT46(13.37,-10.701) AT47(13.866,-10.701) AT49(14.361,-10.701) AT50(14.856,-10.701) AT51(15.352,-10.701) R15(3.464,-3.436) R16(3.96,-3.436) R18(4.455,-3.436) R19(4.95,-3.436) R21(5.446,-3.436) R23(5.941,-3.436) R24(6.436,-3.436) R26(6.931,-3.436) R27(7.427,-3.436) R29(7.922,-3.436) R30(8.417,-3.436) R32(8.913,-3.436) R33(9.408,-3.436) R35(9.903,-3.436) R36(10.399,-3.436) R38(10.894,-3.436) R40(11.389,-3.436) R41(11.884,-3.436) R43(12.38,-3.436) R44(12.875,-3.436) R46(13.37,-3.436) R47(13.866,-3.436) R49(14.361,-3.436) R50(14.856,-3.436) R51(15.352,-3.436) T15(3.464,-3.995) T16(3.96,-3.995) T18(4.455,-3.995) T19(4.95,-3.995) T21(5.446,-3.995) T23(5.941,-3.995) T24(6.436,-3.995) T26(6.931,-3.995) T27(7.427,-3.995) T29(7.922,-3.995) T30(8.417,-3.995) T32(8.913,-3.995) T33(9.408,-3.995) T35(9.903,-3.995) T36(10.399,-3.995) T38(10.894,-3.995) T40(11.389,-3.995) T41(11.884,-3.995) T43(12.38,-3.995) T44(12.875,-3.995) T46(13.37,-3.995) T47(13.866,-3.995) T49(14.361,-3.995) T50(14.856,-3.995) T51(15.352,-3.995) V15(3.464,-4.554) V16(3.96,-4.554) V18(4.455,-4.554) V19(4.95,-4.554) V21(5.446,-4.554) V23(5.941,-4.554) V24(6.436,-4.554) V26(6.931,-4.554) V27(7.427,-4.554) V29(7.922,-4.554) V30(8.417,-4.554) V32(8.913,-4.554) V33(9.408,-4.554) V35(9.903,-4.554) V36(10.399,-4.554) V38(10.894,-4.554) V40(11.389,-4.554) V41(11.884,-4.554) V43(12.38,-4.554) V44(12.875,-4.554) V46(13.37,-4.554) V47(13.866,-4.554) V49(14.361,-4.554) V50(14.856,-4.554) V51(15.352,-4.554) Y15(3.464,-5.113) Y16(3.96,-5.113) Y18(4.455,-5.113) Y19(4.95,-5.113) Y21(5.446,-5.113) Y23(5.941,-5.113) Y24(6.436,-5.113) Y26(6.931,-5.113) Y27(7.427,-5.113) Y29(7.922,-5.113) Y30(8.417,-5.113) Y32(8.913,-5.113) Y33(9.408,-5.113) Y35(9.903,-5.113) Y36(10.399,-5.113) Y38(10.894,-5.113) Y40(11.389,-5.113) Y41(11.884,-5.113) Y43(12.38,-5.113) Y44(12.875,-5.113) Y46(13.37,-5.113) Y47(13.866,-5.113) Y49(14.361,-5.113) Y50(14.856,-5.113) Y51(15.352,-5.113)
  round 0.325 smd: AA59(17.363,-5.609) AA61(17.856,-5.609) AA63(18.349,-5.609) AB60(17.61,-5.931) AB62(18.103,-5.931) AC59(17.363,-6.253) AC61(17.856,-6.253) AC63(18.349,-6.253) AD60(17.61,-6.575) AD62(18.103,-6.575) AE59(17.363,-6.897) AE61(17.856,-6.897) AE63(18.349,-6.897) H63(18.349,-1.744) L63(18.349,-2.388) M60(17.61,-2.71) M62(18.103,-2.71) N59(17.363,-3.032) N61(17.856,-3.032) N63(18.349,-3.032) P60(17.61,-3.354) P62(18.103,-3.354) R59(17.363,-3.676) R61(17.856,-3.676) R63(18.349,-3.676) T60(17.61,-3.998) T62(18.103,-3.998) U59(17.363,-4.32) U61(17.856,-4.32) U63(18.349,-4.32) V60(17.61,-4.642) V62(18.103,-4.642) W59(17.363,-4.964) W61(17.856,-4.964) W63(18.349,-4.964) Y60(17.61,-5.287) Y62(18.103,-5.287)
