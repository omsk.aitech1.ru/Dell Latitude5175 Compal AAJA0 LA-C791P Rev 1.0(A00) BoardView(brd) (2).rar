# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HP2_D_R_R: length 1
  TOP w0.381: RA4.2 7.46,140.05 L3.1
HP_AMP_EN: length 6
  TOP w0.119: RA23.2 136.65,103.14 RA26.2 137.02,103.11 R172.2 R173.2 138.45,102.62 139.58,101.49 140.23,101.49 140.35,101.6 U21.13
HP_IN_L_N: length 1.8
  TOP w0.254: U21.1 143.04,103.05 143.69,102.4 RA27.2
HP_IN_L_P: length 1.6
  TOP w0.254: RA25.1 143.56,103.29 143.3,103.55 U21.2
HP_IN_R_N: length 1.7
  TOP w0.254: RA22.2 143.66,105.07 143.33,104.74 143.33,104.74 143.14,104.55 U21.4
HP_IN_R_P: length 1.5
  TOP w0.254: U21.3 143.38,104.05 143.51,104.18 RA24.1
HP_OUT_L: length 3
  TOP w0.254: U21.16 141.85,101.96 142.11,101.69 142.57,101.69 143.38,100.88 RA29.1
HP_OUT_R: length 1.8
  TOP w0.254: RA20.1 142.32,106.37 141.85,105.9 U21.5
HP_PLUG#: length 3.6
  IN4 w0.089: v4(13.58,141.42) 15.06,141.42 v4(15.9,140.57)
  BOTTOM w0.119: RA46.1 16.33,140.14 v4(15.9,140.57)
HPVDD: length 2.1
  TOP w0.254: U21.12 138.39,103.05 138.05,103.39 C158.1
HPVSS: length 2.3
  TOP w0.254: C144.1 139.22,106.54 139.47,106.29 139.93,106.29 140.35,105.87 U21.8
HSYNC: length 70.3
  IN4 w0.089: v4(175.03,98.33) 174.51,97.81 163.25,97.81 161.56,96.12 151.36,96.12 147.99,99.49 142.8,99.49 142.22,100.07 139.95,100.07 138.78,98.9 134.08,98.9 133.45,98.28 121.09,98.28 120.75,98.62 116.09,98.62 v4(114.8,97.32)
  BOTTOM w0.119: v4(114.8,97.32) 114.39,96.92 109.78,96.92 109.53,97.16 JEDP1.16
HW_RST#: length 2.7
  TOP w0.119: D1.1 199.7,139.69 198.49,139.69 198.34,139.84 U1.5
I2C0_SCL: length 68.9
  IN1 w0.084: v2(37.24,94.83) 36.94,94.83 36.77,95.01 36.77,97.35 34.24,99.87 31.44,99.87 29.53,101.79 29.53,108.64 v2(32.03,111.14)
  IN3 w0.084: v2(37.24,94.83) 37.03,94.83 37.01,94.86 36.78,94.86 v3(36.33,95.3) ; v7(32.64,111.14) v2(32.03,111.14)
  IN4 w0.06: 53.16,113.86 54.43,113.86 54.72,113.57 55.48,113.57 55.76,113.86 59.43,113.86 60.85,115.28 61.04,115.28 v5(61.13,115.36)
  IN4 w0.089: v3(36.33,95.3) 36.26,95.37 36.26,98.13 39.47,101.34 41.91,101.34 42.77,102.2 46.7,102.2 47.41,101.49 48.2,101.49 48.63,101.92 v7(48.63,102.05) 48.63,102.39 48.23,102.78 48.23,104.15 47.75,104.63 47.75,104.94 48.21,105.4 48.21,106.34 49.45,107.58 49.45,108.82 49.68,109.05 49.68,112.17 49.97,112.45 50.07,112.45 50.07,112.45 50.59,112.45 51.49,113.35 51.58,113.35 52.62,113.35 53.13,113.86 53.16,113.86
  BOTTOM w0.119: v7(32.64,111.14) 34.21,111.14 34.76,111.68 Q17.3
I2C0_SCL_AMP: length 56.7
  IN1 w0.109: v2(36.47,86.6) v1(36.47,86.21)
  IN2 w0.079: v2(28.14,95.44) 28.12,95.44 27.08,94.4 25.32,94.4 21.64,98.09 21.64,108.97 21.64,108.97 21.64,110.49 22.11,110.96 22.11,114.44 22.91,115.24 22.91,121.42 22.53,121.79 22.53,122.11 20.6,124.04 20.6,126.25 19.25,127.6 v2(19.2,127.6)
  IN3 w0.084: v2(28.14,95.44) 28.14,95.12 32.4,90.87 33.64,90.87 35.93,88.58 35.93,87.15 v2(36.47,86.6) ; v2(19.2,127.6) 19.14,127.54 18.29,127.54 17.54,128.29 v7(17.09,128.29)
  BOTTOM w0.119: v7(17.09,128.29) 16.96,128.42 UA3.12
I2C0_SCL_AMP_R: length 2.7
  TOP w0.119: RA31.1 RA32.1 RA33.1 37.05,85.63 37.12,85.55 37.12,85.42 37.19,85.34 UA2.4
I2C0_SCL_AUD: length 38.3
  IN1 w0.109: v1(30.31,86.11) 30.28,86.13 30.28,86.31 30.23,86.36 30.23,87.04 30.05,87.21 30.05,89 31.75,90.7 33.63,90.7 36.7,93.77 36.76,93.77 37.72,94.73 37.72,97.15 34.44,100.43 31.55,100.43 30,101.98 30,108.44 32.51,110.94 32.51,112.05 v2(32.66,112.21)
  IN3 w0.084: v7(32.66,111.55) v2(32.66,112.21)
  BOTTOM w0.119: Q17.4 32.8,111.68 v7(32.66,111.55)
I2C0_SCL_AUD_SW: length 89.4
  GND1 w0.084: v1(29.81,86.11) 30.11,85.8 31.52,85.8 v11(31.85,86.13)
  IN1 w0.084: v1(37.03,86.21) 37.03,86.17 37.64,85.56 37.64,85.05 37.11,84.52 33.33,84.52 31.85,86 v11(31.85,86.13) ; v2(12.86,141.66) 12.86,138.15 12.53,137.81 12.53,135.91 11.32,134.7 11.32,133.6 10.11,132.38 10.11,127.37 19.66,117.81 20.81,117.81 22.37,116.25 22.37,113.43 21.38,112.43 21.38,97.73 25.06,94.05 30.08,94.05 31.25,95.22 33.49,95.22 33.64,95.22 34.45,94.41 34.45,93.92 34.45,93.42 33.38,92.35 33.26,92.35 33.26,92.35 31.96,92.35 30.84,91.22 28.85,89.24 28.85,87.73 29.34,87.25 29.34,86.44 29.67,86.11 v1(29.81,86.11)
  IN3 w0.084: v7(12.86,141.32) v2(12.86,141.66)
I2C0_SCL_AUD_SW_R: length 79.7
  TOP w0.119: UA1.4 29.81,87.17 29.76,87.12 29.28,87.12 29.02,87.39 28.81,87.39 v1(28.74,87.46)
  IN1 w0.084: v1(28.74,87.46) 28.65,87.54 28.65,89.3 31.89,92.53 32.7,92.53 32.7,92.53 33.18,92.53 33.19,92.53 33.31,92.53 34.27,93.5 34.27,93.62 34.27,93.84 34.27,93.84 34.27,94.33 33.57,95.04 31.32,95.04 30.15,93.87 24.98,93.87 21.19,97.65 21.19,112.51 22.19,113.5 22.19,116.17 20.74,117.62 19.59,117.62 9.92,127.29 9.92,132.46 11.14,133.68 11.14,134.78 12.34,135.98 12.34,137.89 12.68,138.23 12.68,141.34 v2(12.28,141.73)
  IN3 w0.084: v7(12.28,141.32) v2(12.28,141.73)
  BOTTOM w0.119: v7(12.28,141.32) 12.23,141.26 QA2.4
I2C0_SDA: length 76.8
  IN1 w0.084: v2(31.7,111.62) 31.62,111.55 31.62,111.03 29.32,108.73 29.32,101.7 31.35,99.66 34.15,99.66 36.56,97.26 36.56,94.92 36.8,94.67 v2(36.8,94.4)
  IN3 w0.06: 58.24,115.71 58.26,115.71 58.28,115.73 58.31,115.73 58.91,116.33 60.4,116.33 60.67,116.61 60.67,116.61 60.72,116.65 62.04,116.65 62.37,116.33 62.78,116.33 v10(63.1,116.01)
  IN3 w0.084: v7(32.11,111.62) v2(31.7,111.62) ; v7(47.87,103.38) 47.17,103.38 45.75,104.8 45.75,106.37 46.13,106.75 46.96,106.75 47.65,107.44 47.65,109.58 47.09,110.14 47.09,111.04 48.22,112.17 48.22,112.36 48.22,112.82 49.12,113.72 49.68,113.72 50.13,114.17 50.67,114.17 50.78,114.27 51.19,114.27 51.75,114.83 52.19,114.83 53,115.64 53.64,115.64 54.36,115.64 54.88,116.16 55.33,116.16 55.77,115.71 58.24,115.71 ; v2(36.8,94.4) 35.96,95.25 v3(35.96,95.25)
  IN4 w0.089: v7(47.87,103.38) 48.02,103.23 48.02,102.69 48.34,102.38 48.34,101.93 48.11,101.7 47.5,101.7 46.79,102.42 42.68,102.42 41.82,101.55 39.38,101.55 36.05,98.22 36.05,95.34 v3(35.96,95.25)
  BOTTOM w0.119: RH131.1 48.62,102.63 v7(47.87,103.38) ; Q17.6 32.83,112.68 32.11,111.95 v7(32.11,111.62)
I2C0_SDA_AMP: length 59.1
  IN1 w0.109: v2(37.99,85.83) 37.99,85.99 v1(38.2,86.21)
  IN2 w0.079: v2(28.09,96.08) 26.9,94.88 25.5,94.88 22.1,98.29 22.1,108.51 22.1,110.3 22.57,110.77 22.57,114.25 23.37,115.05 23.37,121.61 22.99,121.98 22.99,122.3 21.08,124.21 21.08,126.46 19.91,127.62 v2(19.84,127.62)
  IN3 w0.084: v2(37.99,85.83) 38.18,86.02 38.18,86.99 33.8,91.37 32.56,91.37 28.68,95.25 28.68,95.57 28.17,96.08 v2(28.09,96.08) ; v7(16.99,128.82) 17.67,128.82 18.43,128.06 19.58,128.06 19.84,127.8 v2(19.84,127.62)
  BOTTOM w0.119: v7(16.99,128.82) UA3.11
I2C0_SDA_AMP_R: length 2.7
  TOP w0.119: RA36.1 RA35.1 RA34.1 37.59,85.6 UA2.3
I2C0_SDA_AUD: length 40
  GND1 w0.119: v11(29.64,86.62) 30.28,86.62 30.78,86.11 v9(31.31,86.11)
  IN1 w0.109: v2(31.19,111.28) 31.19,111.24 29.01,109.05 29.01,101.6 31.21,99.39 32.93,99.39 35.12,97.21 35.12,92.97 33.33,91.19 31.95,91.19 31.55,91.19 29.56,89.2 29.56,87.01 29.71,86.86 29.64,86.79 v11(29.64,86.62)
  IN3 w0.084: v7(31.19,111.72) v2(31.19,111.28)
  BOTTOM w0.119: Q17.1 34.88,112.68 34.53,113.03 32.25,113.03 31.19,111.98 v7(31.19,111.72)
I2C0_SDA_AUD_SW: length 93.6
  TOP w0.119: UA1.10 32.35,86.74 32.37,86.77 v1(34.33,86.77) 37.33,86.77 37.62,86.48 RA34.2 ; v1(34.32,96.81) 35.39,96.81 35.65,96.56 35.65,94.71 36.04,94.32 41.99,94.32 42.42,93.89 v1(43.56,93.89)
  IN1 w0.084: v2(13.8,137.71) 13.85,137.66 13.85,136.33 11.96,134.44 11.96,133.34 10.74,132.12 10.74,127.63 19.93,118.44 21.31,118.44 23.01,116.75 23.01,113.16 22.01,112.17 22.01,97.99 24.4,95.61 26.44,95.61 27.11,94.94 30.44,94.94 31.09,95.59 33.09,95.59 v1(34.32,96.81) ; v1(43.56,93.89) 42.95,93.89 42.17,93.11 38.69,93.11 34.33,88.75 v1(34.33,86.77)
  IN3 w0.084: v7(13.8,138.12) v2(13.8,137.71)
I2C0_SDA_AUD_SW_R: length 74.8
  TOP w0.119: UA1.2 30.81,87.69 30.62,87.87 29.3,87.87 v1(29.24,87.81)
  IN1 w0.084: v2(13.22,137.68) 13.22,135.97 11.77,134.52 11.77,133.41 10.55,132.2 10.55,127.55 19.85,118.26 21.24,118.26 22.82,116.67 22.82,113.24 21.83,112.25 21.83,97.91 24.99,94.75 30.52,94.75 31.17,95.41 33.41,95.41 33.72,95.41 34.64,94.49 34.64,93.99 34.64,93.99 34.64,93.46 34.64,93.46 34.64,93.34 33.46,92.16 33.34,92.16 33.34,92.16 32.2,92.16 29.18,89.14 29.18,87.86 v1(29.24,87.81)
  IN3 w0.084: v7(13.22,138.12) v2(13.22,137.68)
  BOTTOM w0.119: QA2.1 13.23,138.12 v7(13.22,138.12)
I2C1_CLK_PD: length 9.7
  TOP w0.119: v1(41.5,48.81) 40.8,48.11 R489.2
  IN1 w0.084: v1(38.19,42.17) 38.47,42.45 38.47,42.68 39.14,43.36 39.14,47.48 40.48,48.82 41.49,48.82 v1(41.5,48.81)
I2C1_DAT_PD: length 9.5
  TOP w0.119: v1(41.5,49.7) 41.5,50.19 R488.2
  IN1 w0.084: v1(38.19,42.67) 38.95,43.43 38.95,47.55 40.49,49.09 40.89,49.09 v1(41.5,49.7)
I2C1_INT#_PD: length 10.7
  TOP w0.06: 38.69,42.86 U32.C1
  TOP w0.119: v1(39.49,44.28) 39.49,44.18 38.69,43.38 38.69,42.86
  IN1 w0.084: v1(39.49,44.28) 39.49,44.99 v2(39.85,45.35) ; v1(42.63,43.42) v2(42.63,43.08)
  IN2 w0.079: v2(42.63,43.08) 42.63,45.82 41.68,46.78 40.13,46.78 39.85,46.5 v2(39.85,45.35)
I2C2_CLK_PD: length 9.9
  TOP w0.119: R487.2 41.16,47.6 40.98,47.6 v1(40.8,47.42)
  IN1 w0.084: v1(39.19,40.67) 39.09,40.67 38.56,41.19 38.56,41.96 40.78,44.17 40.78,44.95 39.9,45.82 39.9,46.98 40.35,47.42 v1(40.8,47.42)
I2C2_DAT_PD: length 8.9
  TOP w0.119: R486.2 41.02,47.08 v1(40.78,46.84)
  IN1 w0.084: v1(39.69,40.67) 39.55,40.67 39.29,40.92 39.28,40.92 39.28,40.92 39.09,40.92 38.75,41.26 38.75,41.88 40.96,44.09 40.96,45.03 40.41,45.58 40.41,46.47 v1(40.78,46.84)
I2C2_INT#_PD: length 7.1
  TOP w0.119: R493.2 43.68,44.16 v1(43.08,44.16)
  IN1 w0.084: v1(43.08,44.16) 43.14,44.1 43.14,43 40.3,40.17 v1(39.19,40.17)
I2S_DATA_OUT: length 57.5
  TOP w0.119: UA2.10 34.79,84.74 v1(34.9,84.84)
  IN1 w0.084: v2(34.86,85.36) 34.86,84.88 v1(34.9,84.84)
  IN1 w0.109: v1(20.9,131.7) 20.9,130.89 22.93,128.87 22.93,127.78 21.49,126.34 21.49,123.05 22.26,122.28 22.26,117.77 23.81,116.23 23.81,114.37 24.15,114.04 24.15,112.54 23.59,111.98 23.59,111.09 22.26,109.77 22.26,98.73 24,96.99 24.61,96.99 v2(24.66,96.94)
  IN3 w0.086: v2(34.86,85.36) 34.86,85.41 34.57,85.7 34.57,88.19 33.12,89.64 31.92,89.64 25.93,95.62 25.45,95.62 24.74,96.33 24.74,96.87 v2(24.66,96.94)
I2S_DATA_OUT_R: length 5.7
  TOP w0.119: RA10.1 20.9,132.61 v13(20.64,132.87)
  IN3 w0.084: v7(17.08,131.6) 17.09,131.61 17.16,131.61 18.42,132.87 v13(20.64,132.87)
  BOTTOM w0.119: v7(17.08,131.6) 17.08,131.57 16.72,131.22 UA3.5
I2S_LRCK: length 63
  TOP w0.119: RA14.2 v1(23.85,131.09) ; v1(35.99,84.88) UA2.7
  IN1 w0.109: v1(23.85,131.09) 23.85,130.25 23.35,129.75 23.35,127.58 21.91,126.14 21.91,123.23 22.69,122.45 22.69,117.95 24.23,116.4 24.23,114.55 24.81,113.97 27.44,113.97 27.77,113.64 27.77,110.8 27.6,110.62 23.72,110.62 22.69,109.59 22.69,108.37 23.1,107.96 23.1,101.81 24.93,99.98 24.93,98.85 25.55,98.22 v2(25.55,96.33) ; v2(35.94,85.46) 35.94,84.93 v1(35.99,84.88)
  IN3 w0.084: 25.75,96.33 32.05,90.03 33.25,90.03 34.94,88.34 34.94,86.51 35.94,85.52 v2(35.94,85.46)
  IN3 w0.086: v2(25.55,96.33) 25.75,96.33
I2S_LRCK_R: length 8.8
  TOP w0.119: v13(23.32,132.83) 23.85,132.3 RA14.1
  IN3 w0.084: v13(23.32,132.83) 22.28,133.87 17.49,133.87 16.88,133.26 v7(16.88,133.21)
  BOTTOM w0.119: UA3.1 16.71,132.82 16.88,132.98 v7(16.88,133.21)
I2S_OUT: length 57.4
  TOP w0.119: RA12.2 v1(22.38,131.09) ; v1(35.59,84.89) UA2.8
  IN1 w0.109: v2(25.1,96.67) 25.09,96.67 25.09,97.12 24.56,97.65 23.7,97.65 22.47,98.88 22.47,109.68 23.8,111 23.8,111.9 24.36,112.45 24.36,114.12 24.02,114.46 24.02,116.32 22.47,117.86 22.47,122.36 21.7,123.14 21.7,126.24 23.14,127.67 23.14,128.96 22.26,129.83 22.26,130.98 v1(22.38,131.09) ; v1(35.59,84.89) 35.4,85.08 v2(35.4,85.56)
  IN3 w0.084: v2(35.4,85.56) 34.97,86
  IN3 w0.086: v2(25.1,96.67) 25.09,96.67 25.09,96.28 25.54,95.84 25.98,95.84 32,89.82 33.2,89.82 34.76,88.27 34.76,86.21 34.97,86
I2S_OUT_R: length 7.3
  TOP w0.119: RA12.1 22.38,132.56 v13(22.11,132.83)
  IN3 w0.084: v7(17.04,132.31) 18.23,133.5 21.44,133.5 v13(22.11,132.83)
  BOTTOM w0.119: v7(17.04,132.31) 16.94,132.31 16.65,132.02 UA3.3
I_ADP: length 85.2
  TOP w0.119: v1(148.7,107.71) 148.7,107.77 147.81,108.67 145.69,108.67 PR513.1
  IN1 w0.084: v2(149.48,107.05) 149.4,107.05 148.74,107.71 v1(148.7,107.71)
  IN2 w0.079: v2(149.48,107.05) 149.58,107.15 166.82,107.15 168.09,105.88 179.69,105.88 180.56,106.75 196.9,106.75 198.02,107.86 v2(198.4,107.86)
  IN3 w0.084: v2(198.4,107.86) v3(198.7,108.17)
  IN4 w0.089: v3(198.7,108.17) 198.7,109.18 199.06,109.54 199.06,111.97 201.6,114.51 201.6,124.2 198.61,127.19 197.66,127.19 196.24,128.61 196.24,129.17 195.86,129.55 195.47,129.55 v4(195.2,129.82) 194.86,130.16 194.86,130.92 194.32,131.45 v4(194.32,132.24)
I_BATT: length 87
  TOP w0.119: PR517.1 145.11,108.45 147.71,108.45 147.93,108.23 147.93,107.6 148.21,107.32 v1(148.72,107.32)
  IN1 w0.084: v2(148.87,106.95) 148.72,107.1 v1(148.72,107.32)
  IN2 w0.079: v2(198.02,107.23) 197.28,106.49 180.6,106.49 179.8,105.69 167.95,105.69 166.67,106.97 150.14,106.97 149.86,106.69 149.13,106.69 v2(148.87,106.95)
  IN3 w0.084: v3(197.62,107.59) 197.65,107.59 v2(198.02,107.23)
  IN4 w0.089: v4(193.32,132.24) 193.32,130.01 v4(193.48,129.85) 193.2,129.57 193.2,129.15 194.01,128.34 194.21,128.14 195.66,128.14 197.18,126.61 198.37,126.61 201.02,123.96 201.02,114.74 197.72,111.44 197.72,107.69 v3(197.62,107.59)
ILEDA: length 2
  GND1 w0.084: v9(130.16,126.98) 130.57,126.98 130.61,126.94 v2(130.57,126.94)
  IN3 w0.084: v2(130.57,126.94) 130.07,126.94 v7(129.9,126.76)
  BOTTOM w0.119: v7(129.9,126.76) 129.79,126.66 R480.1
ILEDB: length 1.3
  GND1 w0.084: v9(129.76,126.98) 129.69,126.91 129.69,126.41 v2(129.64,126.35)
  GND3 w0.084: v2(129.64,126.35) 129.29,126 v15(129.18,126)
ILMT_1.0V: length 0.9
  BOTTOM w0.254: PR819.2 PR821.1
  vias: v7(172.75,118.46) v7(174.29,116.13) v7(174.57,116.13)
INV_PWM: length 22.9
  TOP w0.119: MC2.1 117.06,109.93 R150.1 117.06,108.52 D12.1 116.8,108.28 115.6,107.08 115.6,103.99 v1(115.39,103.78)
  IN1 w0.084: v1(115.39,103.78) 116.59,103.78 116.68,103.88 118.03,103.88 119.48,102.44 124.09,102.44 125.3,103.65 127.66,103.65 128.73,102.58 v1(129.64,102.58)
IRQ_SERIRQ: length 173
  IN1 w0.084: v2(58.47,125.47) 58.51,125.42 59.23,125.42 59.78,125.98 60.76,125.98 64.57,129.79 65.8,129.79 66.07,130.06 70.66,130.06 70.85,129.87 71.82,129.87 72.57,129.12 75.61,129.12 76.56,130.07 77.58,130.07 78.1,130.59 86.43,130.59 88.02,132.19 89.87,132.19 90.53,131.52 92.97,131.52 93.54,132.1 97.58,132.1 97.84,131.84 98.99,131.84 99.77,132.62 104.85,132.62 105.65,133.42 109.46,133.42 112.17,130.71 112.17,129.67 113.96,127.88 116.88,127.88 117.34,127.41 118.16,127.41 118.87,126.7 118.87,123.54 119.51,122.9 119.66,122.9 120.3,122.26 125.56,122.26 127.24,123.94 128.21,123.94 129.16,124.89 130.69,124.89 131.86,126.05 132.82,126.05 135.34,128.58 136.98,128.58 137.98,129.58 141.66,129.58 142.04,129.96 143.12,129.96 143.78,130.62 145.36,130.62 145.65,130.33 146.45,130.33 147.21,131.1 147.21,131.64 148.74,133.16 152.65,133.16 153.06,132.76 168.11,132.76 172.05,128.82 180.33,128.82 182.87,131.36 182.87,132.19 184.05,133.37 187.79,133.37 189.87,131.28 v2(189.87,130.95)
  IN3 w0.084: v2(58.47,125.47) 58.47,125.64 v7(58.29,125.82) ; v2(189.87,130.95) 190.18,131.25 190.66,131.25 190.67,131.26 v3(191.24,131.26)
  IN4 w0.06: 191.31,131.33 191.97,131.99 192.46,131.99 192.54,132.08 192.54,132.45 v4(192.82,132.74) ; v7(58.29,125.82) 58.23,125.82 57.72,126.33 56.4,126.33 55.87,126.86 55.72,126.86 55,127.58 54.82,127.58
  IN4 w0.089: 54.82,127.58 51.48,127.58 51.18,127.28 49.54,127.28 v4(49.45,127.36) ; v3(191.24,131.26) 191.31,131.33
  BOTTOM w0.076: UC1.BN8 62.23,124.18 62.23,124.75 61.67,125.31 58.98,125.31 58.44,125.85 58.32,125.85 v7(58.29,125.82)
ISH_I2C0_SCL: length 230.2
  IN3 w0.084: v3(45.69,94) 45.69,93.31 48.34,90.66 62.39,90.66 63.1,91.37 81.2,91.37 83,93.17 84.7,93.17 85.97,94.44 97.29,94.44 98.56,93.16 109.11,93.16 110.65,91.63 115.66,91.63 115.8,91.49 155.36,91.49 v3(155.45,91.4) ; v3(211.95,115.86) 216.45,115.86 v7(216.89,115.42) ; v7(52.79,105.32) 52.79,105.14 52.67,105.02 52.67,105.02 51.57,103.92 51.57,103.92 51.18,103.53 51.18,102.56 51.13,102.52 51.13,102.13 51.61,101.65 51.61,98.72 50.35,97.46 50.35,94.96 50.51,94.8 50.51,94.78 50.75,94.55 50.75,94.32 51.02,94.05 v3(51.02,93.98)
  IN4 w0.06: 56.29,106.65 56.49,106.65 56.77,106.93 56.83,106.93 57.47,107.58 57.47,107.64 56.98,108.13 56.98,109.4 58.6,111.01 59.04,111.01 61.01,112.99 61.21,112.99 61.34,112.86 61.55,112.86 v5(61.62,112.79)
  IN4 w0.089: v3(211.95,115.86) 211.7,115.61 210.65,115.61 209.54,114.49 207.62,114.49 205.91,112.79 205.91,107.5 204.37,105.96 203.23,105.96 202.45,105.18 202.45,103.85 203.43,102.86 203.43,100.26 203.57,100.12 203.57,96.07 201.87,94.37 178.4,94.37 175.1,91.06 155.79,91.06 v3(155.45,91.4) ; 56.29,106.65 55.77,106.13 53.72,106.13 52.99,105.4 52.87,105.4 v7(52.79,105.32) ; v3(51.02,93.98) 49.99,93.98 49.22,94.74 47.59,94.74 46.84,94 v3(45.69,94)
  BOTTOM w0.119: JIO1.26 217.4,115.28 217.26,115.42 v7(216.89,115.42)
ISH_I2C0_SDA: length 237
  IN3 w0.084: v7(217.21,114.87) 217.44,115.1 217.44,115.61 216.67,116.37 v3(211.73,116.37) ; v3(45.16,93.92) 45.23,93.85 45.23,93.11 48.17,90.17 62.56,90.17 63.29,90.91 81.39,90.91 83.19,92.71 84.9,92.71 86.16,93.97 97.09,93.97 98.37,92.7 108.88,92.7 110.56,91.01 155.63,91.01 155.99,91.38 v3(155.99,91.46) ; v7(52.79,104.74) 51.64,103.59 51.64,102.69 51.6,102.64 51.6,102.42 51.6,102.41 51.6,102.38 52.08,101.9 52.08,101.22 52.08,98.52 50.82,97.26 50.82,95.15 50.98,94.99 50.98,94.98 51.24,94.71 51.24,94.48 51.56,94.17 v3(51.56,93.51)
  IN4 w0.06: 55.93,110.86 56.07,111 56.07,111.28 56.5,111.71 56.74,111.71 56.76,111.69 57.05,111.4 57.27,111.18 58.98,111.18 60.91,113.11 61.59,113.11 61.78,112.91 61.99,112.91 v5(62.11,112.79) ; 53.34,110.94 53.49,110.94 53.65,111.1 54.59,111.1 54.77,110.91
  IN4 w0.089: v3(45.16,93.92) 45.66,93.42 51.47,93.42 v3(51.56,93.51) ; 54.77,110.91 55.04,110.64 55.71,110.64 55.93,110.86 ; 53.34,110.94 53.21,110.94 52.31,110.04 52.31,105.22 v7(52.79,104.74) ; v3(211.73,116.37) 211.48,116.12 210.48,116.12 209.42,115.06 207.52,115.06 205.44,112.99 205.44,107.73 204.18,106.47 203.08,106.47 201.58,104.97 201.58,104.02 202.9,102.7 202.9,101.04 202.66,100.79 202.66,99.79 203.1,99.34 203.1,96.27 201.67,94.84 178.2,94.84 174.9,91.53 156.07,91.53 v3(155.99,91.46)
  BOTTOM w0.119: JIO1.28 217.21,114.88 v7(217.21,114.87)
ISH_I2C1_SCL: length 6.7
  IN4 w0.06: v4(55.57,111.69) 56.13,111.69 56.4,111.96 56.83,111.96 56.98,111.81 57.1,111.69 57.72,111.69 57.99,111.42 58.88,111.42 60.81,113.35 61.05,113.35 v5(61.13,113.43)
ISH_I2C1_SDA: length 9.4
  IN3 w0.06: 58.78,111.15 58.9,111.15 59.56,111.8 59.72,111.8 60.6,112.69 60.6,113.05 60.78,113.23 61.01,113.23 61.31,112.92 61.96,112.92 62.27,113.23 62.4,113.23 v10(62.61,113.43)
  IN3 w0.084: 58.78,111.15 55.27,111.15 55.18,111.24 v7(55.17,111.24)
  BOTTOM w0.119: RH102.1 55.02,111.39 v7(55.17,111.24)
ISH_UART_CTS#: length 41.2
  TOP w0.119: U4.10 46.04,131.68 46.41,131.31 46.52,131.31 46.76,131.08 48.38,131.08 v1(48.59,131.28)
  IN1 w0.084: v2(48.74,130.85) 48.59,131 v1(48.59,131.28)
  IN2 w0.079: v2(48.74,130.85) 48.74,130.44 48.45,130.16 48.04,130.16 47.26,129.38 47.26,123.36 46.67,122.77 46.28,122.77 46.07,122.56 46.07,121.78 46.35,121.5 46.35,116.19 47.35,115.18 47.58,115.18 50.31,112.45 50.82,112.45 50.82,112.45 51.08,112.45 51.09,112.44 51.45,112.44 51.69,112.2 52.36,112.2 v2(52.64,111.92)
  IN3 w0.06: 57.52,111.71 58.1,112.28 59.52,112.28 60.12,112.89 60.12,113.25 60.82,113.95 61.55,113.95 61.68,114.08 62.57,114.08 62.58,114.08 v10(62.61,114.08)
  IN3 w0.084: v7(52.68,112.26) 52.64,112.22 v2(52.64,111.92) 52.78,111.77 53.24,111.77 53.59,111.42 54.39,111.42 54.9,111.93 55.62,111.93 55.85,111.71 57.52,111.71
  BOTTOM w0.119: RC58.1 52.98,112.56 v7(52.68,112.26)
ISH_UART_CTS#_LS: length 18.7
  TOP w0.119: v1(45.95,134.9) 46.04,134.81 U4.3
  IN1 w0.084: v1(45.95,134.9) 46.21,135.16 v2(46.23,135.16)
  IN3 w0.084: v2(46.23,135.16) 46.23,135.17 47.29,135.17 v7(47.98,135.85)
  BOTTOM w0.119: JNGFF3.62 48.36,149.14 49.08,148.42 49.08,136.42 48.51,135.85 v7(47.98,135.85)
ISH_UART_RTS#: length 41.4
  TOP w0.119: v1(47.98,130.52) 47.77,130.73 46.76,130.73 46.5,130.99 46.19,130.99 45.64,131.54 U4.9
  IN1 w0.084: v2(48.31,130.5) 48.29,130.52 v1(47.98,130.52)
  IN2 w0.079: v2(51.94,111.75) 51.69,112 51.59,112 51.34,112.25 51.02,112.25 51,112.26 50.74,112.26 50.74,112.27 50.23,112.27 47.5,115 47.28,115 46.04,116.23 46.04,116.76 45.37,117.43 45.37,120.37 45.53,120.53 45.53,121.03 45.88,121.38 45.88,122.64 46.2,122.95 46.57,122.95 47.08,123.46 47.08,129.45 47.28,129.66 47.28,130.38 47.48,130.59 47.77,130.59 47.85,130.5 v2(48.31,130.5)
  IN3 w0.06: 57.55,111.34 58.25,112.04 59.62,112.04 60.36,112.79 60.36,113.15 60.92,113.71 61.65,113.71 61.69,113.75 v10(61.87,113.75)
  IN3 w0.084: v2(51.94,111.75) 51.89,111.8 51.87,111.8 52.36,111.31 v7(52.36,111.25) 52.56,111.05 54.54,111.05 55.06,111.56 55.3,111.56 55.53,111.34 57.55,111.34
  BOTTOM w0.119: v7(52.36,111.25) 52.55,111.44 52.58,111.44 52.99,111.85 53.13,111.85 RC59.1
ISH_UART_RTS#_LS: length 19.9
  TOP w0.119: v1(45.66,135.16) 45.64,135.13 U4.4
  IN1 w0.084: v2(46.51,135.75) 46.25,135.75 45.66,135.17 v1(45.66,135.16)
  IN3 w0.084: v2(46.51,135.75) 47.09,136.34 49,136.34 v7(49.4,136.74)
  BOTTOM w0.119: JNGFF3.64 48.44,149.64 49.4,148.68 v7(49.4,136.74)
ISH_UART_RXD: length 41.8
  TOP w0.119: v1(48.13,131.46) 47.85,131.75 46.92,131.75 46.84,131.83 U4.12
  IN1 w0.084: v2(48.13,131.13) v1(48.13,131.46)
  IN2 w0.079: v2(50.36,111.62) 50.25,111.62 48.64,113.23 47.72,113.23 46.66,114.29 46.66,115.08 45.64,116.09 45.64,116.64 45,117.28 45,120.53 45.16,120.68 45.16,121.18 45.49,121.52 45.49,122.77 46.05,123.32 46.23,123.32 46.71,123.8 46.71,129.61 46.91,129.81 46.91,130.83 47.48,131.4 47.79,131.4 48.06,131.13 v2(48.13,131.13)
  IN3 w0.06: v10(62.85,113.75) 62.73,113.75 62.61,113.88 62.52,113.88 62.44,113.96 61.73,113.96 61.6,113.83 60.87,113.83 60.24,113.2 60.24,112.84 59.57,112.16 58.17,112.16 57.53,111.52
  IN3 w0.084: 57.53,111.52 55.76,111.52 55.53,111.75 54.98,111.75 54.47,111.24 53.4,111.24 v7(53.19,111.45) 53.09,111.55 52.7,111.55 52.68,111.57 52.5,111.57 52.29,111.77 52.29,111.96 52.1,112.15 50.99,112.15 50.94,112.19 50.68,112.19 50.42,111.94 50.42,111.68 v2(50.36,111.62)
ISH_UART_RXD_LS: length 15.9
  TOP w0.119: U4.1 46.84,134.89 v1(46.86,134.91)
  IN1 w0.084: v1(46.86,134.91) 46.86,135.12 47.27,135.52 v2(47.27,135.85)
  IN3 w0.084: v7(47.6,135.96) 47.37,135.96 v2(47.27,135.85)
  BOTTOM w0.119: JNGFF3.58 48.06,148.14 48.49,147.72 48.49,137.12 47.6,136.23 v7(47.6,135.96)
ISH_UART_TXD: length 39
  TOP w0.119: v1(47.62,131.46) 46.71,131.46 46.44,131.73 U4.11
  IN1 w0.084: v2(47.62,131.05) v1(47.62,131.46)
  IN2 w0.079: v2(47.62,131.05) 47.09,130.52 47.09,129.73 46.89,129.53 46.89,123.61 46.42,123.14 46.13,123.14 45.7,122.71 45.7,121.46 45.34,121.1 45.34,120.61 45.19,120.45 45.19,117.35 45.83,116.71 45.83,116.18 47.2,114.81 47.42,114.81 50.16,112.08 50.58,112.08 v2(50.82,111.85)
  IN3 w0.084: v7(52.32,110.88) 52.28,110.88 51.59,111.57 51.59,111.72 51.38,111.93 50.9,111.93 v2(50.82,111.85)
  IN4 w0.06: 53.16,111.72 53.47,111.72 53.72,111.47 54.96,111.47 55.56,112.08 56.88,112.08 56.92,112.04 59.15,112.04 60.87,113.75 v5(61.37,113.75)
  IN4 w0.089: v7(52.32,110.88) 52.46,110.88 52.9,111.32 52.9,111.54 53.07,111.72 53.16,111.72
  BOTTOM w0.119: v7(52.32,110.88) 52.39,110.81 RC62.1
ISH_UART_TXD_LS: length 17.5
  TOP w0.119: U4.2 46.44,134.74 v1(46.51,134.81)
  IN1 w0.084: v1(46.51,134.81) 46.58,134.88 46.58,135.21 46.92,135.56 46.92,136.4 47.32,136.79 v2(47.57,136.79)
  IN3 w0.084: v7(48.79,136.92) 48.74,136.87 47.65,136.87 v2(47.57,136.79)
  BOTTOM w0.119: JNGFF3.60 48.17,148.64 48.82,148 48.82,136.95 v7(48.79,136.92)
ITP_PMODE: length 5.9
  BOTTOM w0.119: RC75.1 82.3,106.42 80.92,107.79 80.92,108.36 80.79,108.49 78.98,108.49 78.32,109.15 UC1.A60
JACK_PLUG#: length 18.2
  IN3 w0.084: v7(17.02,129.62) 17.97,129.62 18.85,128.74 19,128.74 v7(19.02,128.72)
  BOTTOM w0.119: v7(17.02,129.62) UA3.9 ; v7(19.02,128.72) 19.02,128.72 18.64,129.1 18.64,138.34 18.01,138.98 RA44.2 RA46.2 17.12,139.87 16.36,140.63 CA35.1 16.76,141.19 RA43.2
JTAG_CLK: length 14.4
  IN3 w0.084: v7(194.13,146.6) 193.54,146.01 193.32,146.01 190.82,143.51 v7(190.82,143.49) 190.82,143.28 189.74,142.2 189.74,138.28 190.56,137.46 190.56,136.52 190.82,136.26 v10(190.82,136.24)
  BOTTOM w0.119: v7(190.82,143.49) 190.82,143.17 R313.2 ; v7(194.13,146.6) 194.13,145.98 v14(194.5,145.61)
JTAG_RST#: length 4.5
  IN4 w0.089: v4(190.32,137.24) 190.32,137.53 189.59,138.27 v4(189.59,139.27)
  BOTTOM w0.119: R324.1 188.37,139.99 C233.1 189,139.36 189.5,139.36 v4(189.59,139.27)
JTAG_TDI: length 16.5
  IN3 w0.084: v10(190.32,136.24) 190.26,136.29 190.26,136.45 190.14,136.58 190.08,136.64 190.08,136.82 189.92,136.98 189.35,136.98 189.24,137.09 189.24,137.09 188.7,137.63 188.7,142.87 v7(188.87,143.04) 188.89,143.06 188.93,143.06 192.95,147.07 192.97,147.07 v7(193.13,147.23)
  BOTTOM w0.119: v14(191.66,145.95) 191.67,145.96 192.85,145.96 193.13,146.24 JDEG1.2 v7(193.13,147.23)
JTAG_TDO: length 15.2
  IN3 w0.084: v7(194.63,146.6) 194.31,146.92 193.97,146.92 193.4,146.35 193.18,146.35 190.09,143.26 v7(190.09,143.03) 189.38,142.32 189.38,138.37 190.32,137.44 v10(190.32,136.74)
  BOTTOM w0.119: v7(194.63,146.6) 194.63,146.29 195.35,145.57 v14(195.82,145.57)
JTAG_TMS: length 14.4
  IN3 w0.084: v7(189.06,138.79) 189.04,138.81 189.04,142.56 v7(189.51,143.03) 189.51,143.16 193.09,146.73 193.31,146.73 193.63,147.05 v7(193.63,147.29)
  BOTTOM w0.119: U34.A10 190.22,137.84 190.22,138.27 189.7,138.79 v7(189.06,138.79) ; v14(193.18,145.56) 193.63,146.01 JDEG1.3 v7(193.63,147.29)
JUSBC1_GND:
  vias: v7(11.43,20.69) v7(11.79,20.69) v7(12.14,20.69) v7(12.47,20.69) v7(12.84,25.58) v7(12.84,25.24) v7(12.84,24.88) v7(12.8,20.69) v7(13.14,20.69) v7(13.2,25.58) v7(13.2,25.24) v7(13.2,24.88)
LAN_WAKE#: length 153.3
  TOP w0.119: v1(52.22,128.14) 52.33,128.03 RH18.1
  IN1 w0.084: v2(184.67,137.84) 184.14,137.84 180.97,134.67 180.97,133.78 179.76,132.57 179.29,132.57 178,131.28 178,130.56 177.66,130.22 177.18,130.22 176.76,130.65 172.5,130.65 168.02,135.13 139.86,135.13 135.9,131.18 133.76,131.18 132.24,129.65 129.58,129.65 129.43,129.81 127.69,129.81 126.94,130.56 125.99,130.56 125.39,131.15 124.05,131.15 120.1,135.11 95.99,135.11 95.59,135.51 95.08,135.51 94.55,134.97 86.86,134.97 85.32,133.43 77.05,133.43 76.86,133.62 74.68,133.62 74.49,133.43 72.58,133.43 71.98,134.03 69.04,134.03 67.93,132.93 65.69,132.93 65.3,133.31 62.91,133.31 60.35,130.75 59.44,130.75 58.98,130.29 57.72,130.29 56.97,129.54 56.97,129.51 56.34,128.88 54.88,128.88 54.53,129.22 54.05,129.22 53.76,128.94 53.02,128.94 v1(52.22,128.14)
  IN3 w0.084: v2(184.67,137.84) 184.67,137.71 185.55,136.83 v3(186.1,136.83)
  IN4 w0.089: v5(189.32,136.74) 186.2,136.74 v3(186.1,136.83)
LAN_WAKE#_R: length 14.9
  TOP w0.119: v1(53.62,128.03) 54.19,128.03 RH17.2
  IN1 w0.084: v2(53.57,128.39) 53.62,128.34 v1(53.62,128.03)
  IN3 w0.06: 61.42,124.4 61.58,124.25 61.58,124.21 62.72,123.07 63.53,123.07 64.12,122.48 v10(64.12,122.27)
  IN3 w0.084: v2(53.57,128.39) 53.57,128.39 54.12,128.94 55.55,128.94 56.14,128.35 57.44,128.35 57.46,128.32 57.5,128.32 57.53,128.3 57.54,128.3 61.06,124.78 61.06,124.77 61.42,124.4
LCD_TST: length 150.8
  TOP w0.119: D16.3 100.7,102.95 101.09,102.55 101.09,100.46 101.4,100.15 103.52,100.15 v1(103.73,100.37)
  IN1 w0.084: v2(104.12,100.11) 103.86,100.37 v1(103.73,100.37)
  IN3 w0.084: v3(104.71,100.37) 104.38,100.37 v2(104.12,100.11)
  IN4 w0.089: v4(106.88,100.73) 105.07,100.73 v3(104.71,100.37) ; v4(126.16,103.19) 126.53,103.19 127.41,104.07 128.89,104.07 129.4,104.57 130.29,104.57 131.64,105.92 132.13,105.92 132.93,106.72 136.19,106.72 137.19,105.72 142.69,105.72 143.98,104.43 143.98,103.55 144.61,102.92 148.02,102.92 150.09,104.98 150.6,104.98 150.81,104.76 150.81,103.79 151.12,103.48 151.86,103.48 153.54,105.17 155.69,105.17 155.91,105.39 157.47,105.39 158.04,104.82 159.07,104.82 159.42,105.17 166.86,105.17 167.07,105.38 174.82,105.38 175.29,104.91 180.31,104.91 181.86,106.46 182.85,107.44 183.7,107.44 184.74,108.49 189.09,108.49 191.58,110.98 192.9,110.98 193.93,112.01 193.93,114.39 194.93,115.38 194.93,122.62 194.22,123.33 193.27,123.33 191.59,125.01 185.8,125.01 184.78,126.03 184.78,130.46 184.18,131.06 184.18,133.38 184.18,133.93 184.43,134.18 184.43,135.4 184.8,135.77 185.49,135.77 185.7,135.98 185.7,136.93 185.89,137.12 185.89,137.42 186.05,137.58 186.27,137.58 186.41,137.44 189.12,137.44 v12(189.32,137.24)
  BOTTOM w0.119: JEDP1.24 107.13,97.96 106.88,98.21 v4(106.88,100.73) 107.53,101.38 110.98,101.38 111.81,100.55 113.92,100.55 114.77,101.4 117.59,101.4 118.28,102.09 125.35,102.09 126.16,102.9 v4(126.16,103.19)
LDO2-CAP: length 6.4
  BOTTOM w0.203: UA3.22 12.58,126.27 12.42,126.11 12.42,125.76 12.22,125.55
  BOTTOM w0.254: RA58.2 10.11,121.5 11.35,122.75 CA66.1 11.35,123.41 11.56,123.61 11.56,124.42 11.8,124.67 CA59.1 12.15,124.86 12.15,125.49 12.22,125.55
LED_IFB1: length 34.1
  IN1 w0.254: v1(115.6,101.72) 116.53,101.72 v2(117.12,102.3)
  IN2 w0.254: v2(127.03,110.76) 126.16,110.76 124.3,108.91 123.21,108.91 118.11,103.81 118.11,102.61 117.6,102.1 117.32,102.1 v2(117.12,102.3)
  IN3 w0.254: v2(127.03,110.76) 127.48,111.21 v7(127.48,111.77) ; v7(117.12,101.69) v2(117.12,102.3)
  BOTTOM w0.254: JEDP1.32 104.73,100.41 105.99,101.67 111.18,101.67 111.99,100.86 113.82,100.86 114.66,101.69 v7(117.12,101.69)
LED_IFB2: length 37.6
  TOP w0.254: v1(117.14,101.49) 116.71,101.49 116.51,101.69 PC414.1
  IN1 w0.254: v2(117.47,101.26) 117.22,101.51 117.17,101.51 v1(117.14,101.49)
  IN2 w0.254: v2(127.69,110.51) 127.51,110.51 127.05,110.05 127.05,109.36 125.68,107.99 123.3,107.99 118.85,103.54 118.85,101.92 118.49,101.56 117.78,101.56 v2(117.47,101.26)
  IN3 w0.254: v2(117.47,101.26) 117.83,101.26 v7(117.86,101.23) ; v2(127.69,110.51) 127.69,110.87 127.98,111.17 v7(127.98,111.77)
  BOTTOM w0.254: v7(117.86,101.23) 117.86,100.96 115.19,98.3 115.19,94.58 114.81,94.19 104.5,94.19 104.43,94.26 JEDP1.33
LED_IFB3: length 37.5
  TOP w0.254: v1(115.98,102.28) 115.29,102.28 114.73,101.72 PC415.1
  IN1 w0.254: v1(115.98,102.28) 116.46,102.76 117.4,102.76 v2(117.47,102.68)
  IN2 w0.254: v2(117.47,102.68) 117.53,102.73 117.53,103.73 123.06,109.26 124.15,109.26 126.16,111.27 127.97,111.27 v2(128.68,110.56)
  IN3 w0.254: v2(117.47,102.68) 117.6,102.56 v7(117.6,102.28) ; v7(128.8,110.94) 128.68,110.82 v2(128.68,110.56)
  BOTTOM w0.254: v7(117.6,102.28) 114.68,102.28 113.62,101.22 112.26,101.22 111.45,102.02 105.56,102.02 104.13,100.59 JEDP1.34
LED_IFB4: length 39.4
  TOP w0.254: v1(117.5,101.97) 117.45,102.02 117.04,102.02 116.53,102.53 PC416.1
  IN1 w0.254: v2(118.21,100.95) 118.21,101.26 v1(117.5,101.97)
  IN2 w0.254: v2(128.3,109.9) 127.86,109.46 127.71,109.46 125.88,107.64 123.44,107.64 119.2,103.39 119.2,101.77 118.38,100.95 v2(118.21,100.95)
  IN3 w0.254: v2(128.3,109.9) 128.3,109.82 v7(128.68,109.44) ; v7(118.21,101.51) v2(118.21,100.95)
  BOTTOM w0.254: JEDP1.35 103.83,94.26 104.26,93.84 114.96,93.84 115.55,94.43 115.55,98.15 118.24,100.84 118.24,101.49 v7(118.21,101.51)
LED_IFB5: length 34.9
  IN1 w0.084: v2(113.82,101.55) 113.97,101.7 v1(113.97,101.89) 113.97,102.24 115.24,103.51 116.65,103.51 116.84,103.7 117.96,103.7 119.4,102.25 124.16,102.25 125.3,103.39 125.58,103.39 v2(125.7,103.27)
  IN2 w0.079: v2(125.7,103.27) 125.7,105.67 v2(127.98,107.94)
  IN3 w0.084: v7(127.98,108.62) v2(127.98,107.94)
  IN3 w0.254: v2(113.82,101.55) 113.79,101.58 v7(113.44,101.58)
  BOTTOM w0.254: v7(113.44,101.58) 112.46,101.58 111.66,102.38 105.03,102.38 103.53,100.88 JEDP1.36
LED_IFB6: length 37.5
  TOP w0.254: PC418.1 117.78,102.53 v1(118.01,102.3)
  IN1 w0.254: v1(118.01,102.3) v2(118.29,102.02)
  IN2 w0.254: v2(118.29,102.02) 118.29,102.28 118.47,102.46 118.47,103.66 123.23,108.42 v2(124.97,108.42)
  IN3 w0.254: v7(118.59,101.74) 118.57,101.74 v2(118.29,102.02) ; v7(127.38,107.93) 125.46,107.93 v2(124.97,108.42)
  BOTTOM w0.254: v7(127.38,107.93) 127.48,108.03 PU400.14 ; JEDP1.37 103.23,94.3 104.05,93.48 115.11,93.48 115.9,94.28 115.9,98 118.59,100.69 v7(118.59,101.74)
LID_CL_SIO#: length 60.2
  IN3 w0.084: v7(194.82,133.74) 194.82,133.97 197.09,136.24 v7(198.02,136.24)
  IN4 w0.089: v4(221.54,116.85) 218.48,116.85 218.28,117.04 216.65,117.04 215.74,117.95 215.74,132.79 214.44,134.09 214.44,138.94 208.62,144.77 200.39,144.77 199.2,143.58 v4(199.18,143.58)
  BOTTOM w0.119: v4(221.54,116.85) 221.51,116.88 JIO1.17 ; v4(199.18,143.58) 199.55,143.21 199.55,136.41 R338.2 198.97,135.87 198.6,136.24 v7(198.02,136.24)
LINE1_L: length 185.9
  TOP w0.254: v1(146.72,100.52) 146.72,101.53 RA28.1 146.74,101.64 145.97,102.4 RA27.1
  IN1 w0.254: v1(146.72,100.52) 146.28,100.08 v2(145.73,100.08) ; v2(6.4,129.35) 5.79,129.35 5.28,128.84 5.28,126.56 6.35,125.49 9.19,125.49 18.74,115.94 18.74,114.44 19.44,113.74 19.44,107.41 18.85,106.81 18.85,95.25 23.51,90.58 26.75,90.58 28.47,92.29 30.53,92.29 31.96,93.72 32.68,93.72 v2(32.94,93.45)
  IN3 w0.254: v3(145.72,96.97) 145.67,97.02 145.67,100.02 v2(145.73,100.08) ; v2(6.4,129.35) v7(6.07,129.02)
  IN3 w0.305: v2(32.94,93.45) 33.24,93.16 33.89,93.16 35.51,91.54 v3(38.61,91.54)
  IN4 w0.305: v3(38.61,91.54) 38.61,91.53 39.24,90.9 42.32,90.9 42.73,91.31 81.64,91.31 83.16,92.84 86.17,92.84 87.49,94.15 97.98,94.15 98.66,93.47 115.11,93.47 115.7,94.06 118.8,94.06 119.76,93.09 136.64,93.09 136.83,93.28 142.04,93.28 142.54,93.79 142.55,93.79 145.34,96.59 145.67,96.91 145.67,96.92 v3(145.72,96.97)
LINE1_L_AMP: length 15.8
  TOP w0.254: v1(143.52,100.24) 144.55,100.24 144.93,100.62 RA29.2 144.82,100.99 CA12.1 145.69,101.67 RA28.2
  IN1 w0.254: v1(143.52,100.24) 143.52,99.7 v2(143.48,99.66)
  IN3 w0.254: v3(141.36,98.2) 142.58,98.2 143.48,99.1 v2(143.48,99.66)
  IN4 w0.254: v3(141.36,98.2) 140.73,97.56 134.71,97.56 134.59,97.45 134.23,97.45 v4(134.07,97.6)
  BOTTOM w0.203: JIO4.35 133.92,97.78 134.07,97.63 v4(134.07,97.6)
LINE1_R: length 186.4
  TOP w0.254: RA21.1 RA22.1 145.02,105.07 148.23,101.86 148.23,101.21 147.9,100.88 v1(147.78,100.88)
  IN1 w0.254: v2(5.94,126.74) 6.6,126.08 9.33,126.08 19.25,116.16 19.25,114.65 19.95,113.95 19.95,107.2 19.35,106.6 19.35,95.46 23.73,91.09 26.54,91.09 28.26,92.8 30.32,92.8 31.75,94.22 32.92,94.22 33.29,93.86 v2(33.34,93.86) ; v2(145.05,100.08) 145.05,100.18 145.43,100.56 146.15,100.56 146.47,100.88 v1(147.78,100.88)
  IN3 w0.254: v7(6.12,126.33) 6.12,126.56 v2(5.94,126.74) ; v3(144.97,97.02) 145.16,97.21 145.16,99.96 v2(145.05,100.08)
  IN3 w0.305: v3(39.06,91.91) 38.87,92.1 35.74,92.1 34.07,93.77 33.43,93.77 v2(33.34,93.86)
  IN4 w0.305: v3(39.06,91.91) 39.52,91.46 42.08,91.46 42.5,91.87 81.41,91.87 82.93,93.39 85.94,93.39 87.26,94.71 98.21,94.71 98.89,94.03 114.77,94.03 115.37,94.63 119.02,94.63 120,93.65 123.09,93.65 123.57,94.13 124.47,94.13 124.96,93.65 136.41,93.65 136.61,93.86 141.81,93.86 v3(144.97,97.02)
LINE1_R_AMP: length 29.3
  TOP w0.254: CA11.1 143.07,107.01 RA20.2 144.07,106.01 RA21.2 144.08,105.97 144.67,106.56 146.15,106.56 146.9,105.81 147.62,105.81 149.21,104.21 149.21,100.38 v1(149.22,100.37)
  IN1 w0.254: v1(149.22,100.37) v2(148.64,100.37)
  IN2 w0.254: v2(142.85,99.66) 143.42,99.09 147.36,99.09 v2(148.64,100.37)
  IN3 w0.254: v3(141.38,98.61) 142.28,98.61 142.85,99.18 v2(142.85,99.66)
  IN4 w0.254: v3(141.38,98.61) 141.25,98.61 140.59,97.94 134.57,97.94 v4(134.47,97.84)
  BOTTOM w0.203: JIO4.33 134.32,97.99 v4(134.47,97.84)
LINE_AMP_EN: length 187.6
  TOP w0.119: RA26.1 v1(137.1,102.62) ; v1(8.85,130.63) 8.85,130.99 RA16.2 RA15.1
  IN1 w0.084: v1(8.85,130.63) 8.85,130.29 v2(9.02,130.13) ; v2(137.11,102.28) 137.1,102.29 v1(137.1,102.62)
  IN2 w0.079: v2(82.66,91.66) 82.66,91.98 82.77,92.08 82.77,93.2 83.17,93.6 83.17,94.21 85.67,96.71 97.73,96.71 99.73,94.71 101.72,94.71 102.26,94.71 102.26,94.71 119.22,94.71 119.72,94.22 135.45,94.22 136.66,95.43 136.66,101.83 v2(137.11,102.28)
  IN3 w0.084: v2(9.02,130.13) 8.98,130.13 v3(8.74,129.89) ; v2(82.66,91.66) 83.13,91.66 v7(83.2,91.59)
  IN4 w0.089: v3(8.74,129.89) 8.88,129.75 8.88,127.15 8.31,126.58 8.31,123.08 7.64,122.41 7.64,120.73 8.79,119.57 12.46,119.57 18.8,113.24 18.8,105.17 17.96,104.33 v4(17.96,91.86)
  BOTTOM w0.119: v4(17.96,91.86) 17.96,95.7 18.36,96.1 20.92,96.1 22.01,95.02 22.01,93.72 22.34,93.39 24.18,93.39 24.43,93.63 25.97,93.63 28.62,90.99 43.34,90.99 43.72,91.36 80.79,91.36 82.96,91.36 v7(83.2,91.59)
LINE_L: length 4
  IN3 w0.254: v7(8.36,130.02) 8.11,130.02 7.39,129.3 7.39,129.07 6.43,128.11 v7(6.12,128.11)
  BOTTOM w0.203: v7(8.36,130.02) UA3.35
LINE_PLUG#: length 167.6
  TOP w0.119: v1(109.86,92.98) 109.56,93.28 50.39,93.28 48.92,94.74 44.91,94.74 43.44,93.28 39.36,93.28 37.34,91.25 29.97,91.25 29.31,91.91 24.9,91.91 21.54,95.27 v1(21.54,95.57)
  IN1 w0.084: v1(21.54,95.57) 21.54,95.86 v2(21.5,95.9) ; v1(109.86,92.98) 110.31,92.98 v2(110.43,93.1)
  IN3 w0.084: v2(21.5,95.9) 21.5,95.91 v7(21.5,96.36) ; v7(110.88,92.24) 110.88,92.26 110.43,92.71 v2(110.43,93.1)
  BOTTOM w0.119: RA43.1 17.23,140.64 17.83,140.05 17.83,139.77 23.77,133.82 23.77,132.54 22.78,131.55 22.78,126.66 22.35,126.23 22.35,102.95 21.5,102.1 v7(21.5,96.36) ; JIO4.38 133.52,94.65 130.64,91.77 111.35,91.77 v7(110.88,92.24)
LINE_R: length 4.3
  IN3 w0.254: v7(8.33,129.61) 8.23,129.61 7.81,129.19 7.81,128.76 6.3,127.24 v7(6.12,127.24)
  BOTTOM w0.203: v7(8.33,129.61) 8.34,129.62 UA3.34
LPC_AD0: length 216.7
  IN2 w0.079: v2(217.8,105.1) 217.8,105.28 218.64,106.13 218.64,115.16 218.22,115.58 218.22,116.07 218.22,120.52 218.53,120.82 218.53,132.36 215.95,134.94 210.52,134.94 210.34,135.12 206.43,135.12 204.66,133.35 202.41,133.35 202.05,133.72 198.86,133.72 198.54,133.4 196.9,133.4 196.12,134.18 195.3,134.18 194.79,134.69 192.33,134.69 v2(191.82,134.18) 191.38,134.61 189.71,134.61 189.19,134.1 183.97,134.1 181.85,131.98 181.11,131.98 180.84,131.71 180.84,130.95 180.11,130.23 178.41,130.23 177.92,129.73 173.58,129.73 169.86,133.45 166.67,133.45 165.73,134.39 139.37,134.39 135.7,130.72 132.47,130.72 131.99,130.25 130.05,130.25 129.5,130.8 125.83,130.8 124.91,131.72 124.23,131.72 123.07,132.89 121.12,132.89 119.52,134.49 111.81,134.49 111.01,133.69 108.31,133.69 108.31,133.69 106.15,133.69 106.05,133.78 99.1,133.78 99.01,133.69 86.45,133.69 85.76,133.01 77.37,133.01 75.58,131.22 65.37,131.22 62.58,128.42 60.04,128.42 58.78,127.17 57.85,127.17 v2(57.02,126.33)
  IN3 w0.084: v3(57.33,126.79) 57.02,126.47 v2(57.02,126.33) ; v10(192.32,133.24) 192.32,133.31 191.82,133.81 v2(191.82,134.18) ; v7(219.73,102.2) 219.73,102.28 218.08,103.93 218.08,104.81 v2(217.8,105.1)
  IN4 w0.06: v3(57.33,126.79) 57.91,126.79 58.42,126.28 58.74,126.28 59.46,125.56 61.57,125.56 62.85,124.27 62.85,124.02 62.93,123.94 63.16,123.71 v5(63.16,123.5)
LPC_AD1: length 215.9
  IN2 w0.079: v2(217.7,104.48) 217.45,104.73 217.45,105.24 218.43,106.22 218.43,115.08 218.02,115.5 218.02,116.16 218.02,120.65 218.32,120.95 218.32,132.27 215.86,134.73 210.44,134.73 210.26,134.91 206.52,134.91 204.75,133.15 202.33,133.15 201.96,133.51 198.94,133.51 198.62,133.19 196.81,133.19 196.03,133.97 195.08,133.97 194.6,134.45 192.66,134.45 v2(192.37,134.17) 192.03,133.83 191.17,133.83 190.81,134.19 189.67,134.19 189.37,133.89 184.07,133.89 180.2,130.02 178.5,130.02 178,129.53 173.5,129.53 169.78,133.25 166.58,133.25 165.64,134.19 140.33,134.19 137.9,131.75 137.02,131.75 135.78,130.51 132.55,130.51 132.08,130.04 129.96,130.04 129.41,130.59 125.75,130.59 124.82,131.52 124.15,131.52 122.98,132.68 121.04,132.68 119.54,134.18 111.79,134.18 111.1,133.49 108.4,133.49 108.39,133.48 106.06,133.48 105.97,133.58 99.19,133.58 99.09,133.48 86.53,133.48 85.84,132.8 77.45,132.8 75.67,131.01 65.45,131.01 62.66,128.22 60.12,128.22 58.87,126.96 57.96,126.96 57.58,126.59 v2(57.58,126.4)
  IN3 w0.06: 57.66,125.97 57.7,125.93 57.7,125.03 57.88,124.86 58.13,124.86 58.34,124.65 v3(58.71,124.65)
  IN3 w0.084: v2(192.37,134.17) 192.37,133.53 192.56,133.34 192.56,133.05 192.32,132.81 v10(192.32,132.74) ; v2(57.58,126.4) 57.58,126.05 57.66,125.97 ; v7(219.73,101.7) 219.44,101.99 219.44,102.27 217.7,104.02 v2(217.7,104.48)
  IN4 w0.06: v3(58.71,124.65) 58.71,124.82 58.89,125 59.17,125 59.21,124.96 61.32,124.96 62.25,124.02 62.25,123.3 v5(62.33,123.23)
LPC_AD2: length 213.5
  IN2 w0.079: v2(58.98,125.77) 59.17,125.96 59.17,126.08 60.69,127.6 62.92,127.6 65.71,130.39 75.92,130.39 77.71,132.18 86.1,132.18 86.62,132.7 95.23,132.7 95.43,132.5 97.71,132.5 97.9,132.31 99.02,132.31 99.67,132.96 105.71,132.96 106.34,132.34 108.12,132.34 108.65,132.87 112.45,132.87 112.97,132.35 116.11,132.35 116.74,132.98 118.77,132.98 120.23,131.52 121.86,131.52 122.92,130.46 125,130.46 125.49,129.97 129.15,129.97 129.69,129.42 132.33,129.42 132.81,129.9 136.04,129.9 137.28,131.13 138.15,131.13 140.59,133.57 165.39,133.57 166.33,132.63 169.39,132.63 173.32,128.71 179.78,128.71 183.56,132.49 190.95,132.49 191.07,132.36 191.49,132.36 v2(191.87,132.74) 191.94,132.74 192.44,133.24 193.33,133.24 193.42,133.33 193.86,133.33 194.08,133.11 194.61,133.11 195.99,133.11 196.57,132.53 198.84,132.53 199.2,132.89 201.26,132.89 202.88,131.27 203.79,131.27 206.81,134.3 209.97,134.3 210.16,134.11 215.61,134.11 217.48,132.24 217.48,124.13 216.77,123.43 216.77,119.17 217.39,118.55 217.39,115.79 217.39,115.2 217.82,114.77 217.82,106.56 v2(216.65,105.4)
  IN3 w0.084: v7(219.73,101.2) 219.23,101.7 219.23,102.18 217.34,104.07 217.34,104.69 216.65,105.38 v2(216.65,105.4) ; v2(58.98,125.77) 59.08,125.67 v3(59.08,124.78) ; v7(192.32,132.24) 192.32,132.29 v2(191.87,132.74)
  IN4 w0.06: v5(62.74,122.86) 62.73,122.86 62.66,122.86 62.5,123.03 62.21,123.03 62.13,123.1 62.13,123.14 62.13,123.14 62.13,123.31 62.13,123.32 62.13,123.71 61.95,123.89 61.81,123.89 61.7,124 61.7,124.14 61,124.84 59.14,124.84 v3(59.08,124.78)
LPC_AD3: length 212.2
  IN2 w0.079: v2(216.67,104.84) 217.04,105.21 217.04,105.41 218.02,106.39 218.02,114.86 217.6,115.29 217.6,119.68 217.35,119.92 217.35,123.68 217.69,124.01 217.69,132.33 215.7,134.32 210.25,134.32 210.07,134.5 206.71,134.5 204.33,132.13 202.31,132.13 201.34,133.1 199.11,133.1 198.76,132.75 196.66,132.75 196.09,133.32 194.69,133.32 194.69,133.32 194.17,133.32 193.95,133.54 193.33,133.54 193.24,133.44 192.29,133.44 191.97,133.12 191.72,133.12 v2(191.31,132.7) 191.02,132.7 190.93,132.79 183.56,132.79 179.68,128.91 173.48,128.91 169.55,132.84 166.41,132.84 165.47,133.78 140.5,133.78 138.07,131.34 137.19,131.34 135.96,130.1 132.72,130.1 132.25,129.63 129.78,129.63 129.23,130.18 125.58,130.18 124.65,131.1 123.98,131.1 122.81,132.27 119.79,132.27 118.86,133.2 115.44,133.2 114.8,132.56 113.05,132.56 112.53,133.08 108.57,133.08 108.56,133.07 105.89,133.07 105.8,133.17 99.36,133.17 99.21,133.02 86.65,133.02 86.01,132.38 77.62,132.38 75.84,130.6 65.63,130.6 62.83,127.81 60.29,127.81 59.04,126.55 59.03,126.55 57.99,125.51 v2(57.99,125.16)
  IN3 w0.06: v2(57.99,125.16) 58.27,125.16 v7(58.43,124.99)
  IN3 w0.084: v10(191.82,133.24) 191.31,132.73 v2(191.31,132.7) ; v2(216.67,104.84) 216.8,104.84 217.13,104.51 217.13,103.98 219.02,102.1 219.02,101.41 v7(219.73,100.7)
  BOTTOM w0.076: UC1.BP5 61,125.04 58.48,125.04 v7(58.43,124.99)
LPC_FRAME#: length 214.3
  IN2 w0.079: v2(216.69,104.3) 217.25,104.86 217.25,105.32 218.23,106.31 218.23,114.96 217.8,115.39 217.8,119.87 217.56,120.11 217.56,123.56 217.89,123.89 217.89,132.41 215.78,134.52 210.35,134.52 210.17,134.71 206.61,134.71 204.24,132.34 202.4,132.34 201.43,133.31 199.03,133.31 198.68,132.96 196.75,132.96 195.99,133.71 195.02,133.71 194.55,134.18 193.12,134.18 192.84,133.9 192.84,133.87 v2(192.76,133.8) 192.61,133.65 192.21,133.65 192.14,133.58 190.87,133.58 190.79,133.5 189.65,133.5 189.48,133.67 184.14,133.67 179.61,129.14 173.57,129.14 169.67,133.04 166.5,133.04 165.56,133.98 140.42,133.98 137.98,131.55 137.11,131.55 135.87,130.31 132.64,130.31 132.16,129.83 129.88,129.83 129.33,130.38 125.66,130.38 124.74,131.31 124.06,131.31 122.9,132.47 119.89,132.47 118.95,133.42 115.7,133.42 115.52,133.59 114.72,133.59 113.89,132.77 113.14,132.77 112.62,133.28 108.48,133.28 108.48,133.28 105.98,133.28 105.88,133.37 99.27,133.37 99.18,133.28 86.62,133.28 85.93,132.59 77.54,132.59 75.75,130.81 65.54,130.81 62.75,128.01 60.21,128.01 58.92,126.73 58.2,126.73 v2(58.1,126.62)
  IN3 w0.06: 57.97,125.97 v7(57.97,125.61)
  IN3 w0.084: 57.97,125.97 57.97,126.5 v2(58.1,126.62) ; v2(216.69,104.3) 216.69,104.13 218.81,102.01 218.81,101.12 v7(219.73,100.2) ; v2(192.76,133.8) 192.82,133.74 v10(192.82,133.24)
  BOTTOM w0.076: v7(57.97,125.61) 58.26,125.33 58.66,125.33 58.82,125.17 61.32,125.17 UC1.BP7
LPM_0.85VS_VCCIO: length 11
  TOP w0.254: PU808.14 37.49,138.47 37.19,138.17 37.19,136.82 36.4,136.03 34.67,136.03 33.96,135.32 33.96,132.3 PR801.2 33.93,132.23 PR800.2 PR802.1
LSTX: length 2.1
  TOP w0.119: R282.2 33.13,40.25 33.63,40.25 34.55,41.17 U32.L4
LX_0.85VS_VCCIO: length 3.5
  TOP w0.508: PR805.1 36.03,134.36 38.73,134.36 PL802.1
LX_1.0V: length 5.3
  TOP w0.508: v13(174.14,118.81) 174.9,118.81 175.17,118.54 175.17,116.6 PC811.2
  BOTTOM w0.508: PR815.1 177.75,118.2 177.73,118.22
M_A_CA_0_0: length 23
  IN3 w0.06: v10(77.97,120.84) 78.2,120.61 79.39,120.61
  IN3 w0.076: 79.39,120.61 79.41,120.64 79.73,120.64 80.21,121.12 81.23,121.12 81.36,121.25 81.36,121.7 81.37,121.72 81.37,121.72 81.5,121.85 81.5,121.85 81.68,121.85 81.69,121.85 82.1,121.85 82.58,121.37 86.45,121.37 87.64,122.56 88.3,122.56 88.98,123.23 88.98,125.65 88.41,126.22 88.41,126.43 87.96,126.88 87.57,126.88 87.56,126.89 87.54,126.89 87.04,127.39 85.23,127.39 84.88,127.73 84.88,128.13 84.78,128.23 84.28,128.23 84.2,128.31 84.2,128.46 84.53,128.79 v10(85.39,128.79)
M_A_CA_0_1: length 24.4
  IN3 w0.06: v10(76.99,120.84) 76.97,120.82 76.97,120.49 77.38,120.07 79.55,120.07 79.58,120.1
  IN3 w0.076: 79.58,120.1 81.31,120.1 81.57,120.37 87.66,120.37 90.05,122.76 90.05,123.43 90.37,123.76 90.37,124.65 90.05,124.98 90.05,126.31 90.27,126.53 90.27,127.23 90.05,127.45 89.43,128.11 88.42,128.37 v10(85.89,128.79)
M_A_CA_0_2: length 24.4
  IN3 w0.06: v10(78.71,122.45) 78.71,122.45 79.4,122.45 80.19,123.24
  IN3 w0.076: v6(85.95,124.84) 85.95,124.45 85.87,124.37 85.72,124.37 85.65,124.3 85.65,124.2 85.72,124.12 85.87,124.12 85.95,124.04 85.95,123.96 85.58,123.6 85.58,122.71 85.49,122.63 83.47,122.63 82.53,123.56 82.09,123.56 82.02,123.64 82.02,124.12 82.09,124.2 82.27,124.2 82.35,124.12 82.35,123.89 82.42,123.81 82.63,123.81 82.7,123.89 82.7,124.09 82.78,124.17 82.98,124.17 83.12,124.31 83.12,124.41 83.06,124.48 81.89,124.48 81.81,124.4 81.81,124.29 81.75,124.22 81.58,124.22 81.51,124.3 81.51,124.42 81.43,124.5 81.28,124.5 81.2,124.42 81.2,123.69 81.08,123.56 80.77,123.56 80.61,123.4 80.5,123.4 80.4,123.5 80.4,123.6 80.62,123.82 80.62,124.32 80.54,124.4 80.01,124.4 79.93,124.32 79.93,124.16 80.01,124.08 80.33,124.08 80.41,124.01 80.41,123.94 80.19,123.71 79.98,123.71 79.91,123.64 79.91,123.51 79.98,123.43 80.11,123.43 80.19,123.36 80.19,123.24
  IN4 w0.061: v6(85.95,124.84) 85.96,124.84 85.89,124.91 85.89,124.98 85.67,125.2 85.67,126.34 84.73,127.27 84.73,127.57 84.81,127.65 84.81,127.93 84.91,128.03 86.03,128.03 86.14,128.15 86.14,128.38 86.39,128.63 v5(86.39,128.79)
M_A_CA_0_3: length 23.7
  IN3 w0.06: v10(77.23,120.52) 77.56,120.19 78.98,120.19 78.99,120.21 79.46,120.21 79.54,120.29
  IN3 w0.076: v10(85.39,128.29) 85.39,128.43 85.48,128.53 86.25,128.53 86.34,128.43 86.58,128.43 88.34,128.21 88.77,128.11 89.31,127.99 89.59,127.71 89.59,126.66 89.87,126.38 89.87,124.93 90.22,124.58 90.22,123.84 89.87,123.49 89.87,122.83 87.57,120.54 81.4,120.54 81.15,120.29 79.54,120.29
M_A_CA_0_4: length 23.6
  IN3 w0.06: v10(77.48,120.84) 77.48,120.47 77.64,120.31 78,120.31 78.08,120.39 79.4,120.39 79.46,120.45
  IN3 w0.076: v10(85.89,128.29) 85.69,128.29 85.62,128.23 85.62,128.07 85.67,128.02 85.99,128.02 86.18,128.21 86.31,128.21 86.51,128.01 86.59,128.01 86.79,128.21 86.95,128.21 87.1,128.06 88.27,128.06 88.49,127.83 89.21,127.83 89.41,127.63 89.41,126.58 89.71,126.28 89.71,124.86 90.02,124.55 90.02,123.86 89.71,123.56 89.71,122.9 87.51,120.7 81.25,120.7 81,120.45 79.46,120.45
M_A_CA_0_5: length 21
  IN3 w0.06: v10(77.73,120.52) 77.73,120.99 77.78,121.04 78.11,121.04 78.21,120.94 78.21,120.82 78.26,120.76 79.32,120.76
  IN3 w0.076: 79.32,120.76 79.37,120.82 79.65,120.82 80.14,121.3 81.13,121.3 81.2,121.38 81.2,121.95 81.28,122.02 82.28,122.02 82.77,121.53 86.38,121.53 87.58,122.72 88.24,122.72 88.82,123.31 88.82,125.57 88.22,126.17 88.22,126.4 87.89,126.73 87.46,126.73 86.98,127.21 85.35,127.21 85.28,127.14 85.28,127.04 85.37,126.94 85.74,126.94 v10(85.89,126.79)
M_A_CA_0_6: length 21.7
  IN3 w0.06: 79.91,125.31 79.86,125.26 79.73,125.26 79.45,124.98 79.45,123.41 79.01,122.98 78.38,122.98 78.21,122.81 78.21,122.66 77.85,122.3 77.85,122.15 77.71,122.02 77.64,122.02 77.51,121.89 77.51,121.82 77.34,121.65 77.27,121.57 77.27,121.56 77.22,121.52 77.22,121.17 v10(77.23,121.16)
  IN3 w0.076: 79.91,125.31 81.87,127.28 82.15,127.28 82.51,126.93 82.61,126.93 82.72,127.03 82.72,127.14 82.37,127.49 82.37,127.6 82.47,127.7 82.58,127.7 82.83,127.46 82.94,127.46 83.04,127.56 83.04,127.67 82.82,127.89 82.82,128 83.02,128.2 83.13,128.2 83.26,128.06 83.26,128.06 83.34,127.98 83.64,127.98 83.72,127.9 83.72,127.75 83.64,127.68 83.41,127.68 83.34,127.6 83.34,127.45 83.41,127.37 84,127.37 84.07,127.29 84.07,127.12 84,127.04 83.13,127.04 82.88,126.78 82.88,126.64 82.95,126.57 83.13,126.57 83.23,126.67 84,126.67 84.07,126.59 84.07,126.43 84,126.35 83.74,126.35 83.66,126.27 83.66,126.21 83.91,125.96 84.08,125.96 84.5,126.38 84.61,126.38 84.72,126.28 84.82,126.28 84.93,126.39 85.06,126.39 85.12,126.33 85.42,126.33 85.73,126.02 85.96,126.02 86.15,126.22 86.15,126.38 86.39,126.62 v10(86.39,126.79)
M_A_CA_0_7: length 23.3
  IN3 w0.06: 79.8,124.49 79.78,124.47 79.78,123.08 79.35,122.65 78.63,122.65 78.49,122.51 78.34,122.51 78.05,122.22 v10(78.05,122.21)
  IN3 w0.076: 79.8,124.49 79.9,124.59 80.66,124.59 80.8,124.44 80.8,123.81 80.87,123.74 80.97,123.74 81.04,123.81 81.04,124.51 81.19,124.66 83.44,124.66 83.51,124.58 83.51,124.45 82.75,123.69 82.75,123.59 83.54,122.8 85.27,122.8 85.42,122.95 85.42,123.13 85.42,123.48 85.37,123.54 85.22,123.54 84.87,123.18 84.49,123.18 84.41,123.26 84.11,123.26 84.03,123.18 83.78,123.18 83.63,123.34 83.63,123.55 83.79,123.71 84,123.71 84.27,123.44 84.74,123.44 84.91,123.61 84.91,123.72 84.54,124.08 84.54,124.16 84.63,124.24 84.73,124.24 84.87,124.11 84.98,124.11 85.08,124.22 85.08,124.33 84.96,124.45 84.96,124.54 85.02,124.61 85.65,124.61 v6(85.68,124.58)
  IN4 w0.061: v5(85.39,126.29) 85.15,126.54 84.81,126.54 84.65,126.38 84.65,126.16 84.86,125.95 84.86,125.63 84.94,125.56 84.98,125.56 85.14,125.39 85.14,125.22 85.29,125.07 85.43,125.07 85.64,124.86 85.64,124.67 85.68,124.64 v6(85.68,124.58)
