# Allegro board Dell Latitude 5175  Compal AAJA0 LA-C791P Rev 1.0 BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SN65LVPE501RGER_VQFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.108x2.108 smd: 25(1.25,1.975)
SN74AHC1G08DCKR_SC70-5
  oval 0.381x1.295 smd: 1(0,0.15) 2(0.65,0.15) 3(1.3,0.15) 4(1.3,1.89) 5(0,1.89)
SN74AUP1T08DCKR_SC70-5
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0,2.2)
SN74AVC4T774_UQFN16_2P6X1P8
  oval 0.203x1.016 smd: 1(0,0)
  oval 0.203x0.914 smd: 2(0.4,-0.051) 3(0.8,-0.051) 4(1.2,-0.051) 9(1.2,1.826) 10(0.8,1.826) 11(0.4,1.826) 12(0,1.826)
  oval 0.914x0.203 smd: 5(1.939,0.288) 6(1.939,0.688) 7(1.939,1.088) 8(1.939,1.488) 13(-0.738,1.488) 14(-0.738,1.088) 15(-0.738,0.688) 16(-0.738,0.288)
SN74LVC1G123DCUR_VSSOP8
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.825) 6(1,2.825) 7(0.5,2.825) 8(0,2.825)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
SW_TAFG3-12WQR_3P
  round 0.889 hole 0.889 unplated: (-0.9,-0.9) (3.35,-0.9)
  custom 0.191x0.191 smd: 1(0,0) 3(2.45,0)
  oval 0.61x1.803 smd: 2(1.225,0)
  rect 1.321x0.838 hole 0.991x0.406: 4(2.975,-2) 5(-0.525,-2)
SW_TS-A52-3-P1-S017_4P
  rect 0.889x0.991 smd: 1(0,0) 2(3.9,0) 3(0,3.85) 4(3.9,3.85)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8003DFC_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.549x0.838 smd: 9(0.75,1.1)
SY8057QDC_QFN16_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.6x1.6 smd: 17(1.55,-0.75)
SYX196DQNC_QFN10_3X3
  oval 0.254x0.61 smd: 1(0,0) 2(0.45,0) 3(0.9,0) 4(1.35,0) 5(1.8,0) 6(2.25,0)
  rect 1.118x0.229 smd: 7(2.215,-0.662)
  rect 0.864x2.007 smd: 8(2.09,-2)
  custom 0.47x0.47 smd: 9(1.077,-1.775)
  rect 0.787x1.143 smd: 10(0.113,-1.6)
TAI-T_HCB1608KF-121T3_L0603_2P
  rect 0.991x0.787 smd: 1(0,0) 2(1.6,0)
TAI-T_HCB2012KF-121T50_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TAIWI_USB034-107CRL-TWD_10P-T
  round 1.041 hole 0.787: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-8,1.3) 6(-5.75,1.3) 7(-3.5,1.3) 8(-1.25,1.3) 9(1,1.3)
  round 0.965 hole 0.762: 10(-8.2,0.03)
  oval 1.372x2.667 hole 0.61x1.905: 11(-10.9,1.21) 12(-11.4,-7.55) 13(3.9,1.21) 14(4.4,-7.55)
TOKO_1239AS-H-4R7M-P2_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
TOKO_1269AS-H-1R0M-P2_2P
  rect 0.787x2.007 smd: 1(0,0) 2(2,0)
TOKO_FDSD0412-H-R47M-P3_2P
  rect 1.702x2.388 smd: 1(0,0) 2(3.5,0)
TPA6132A2RTER_QFN16_3X3
  oval 0.254x1.016 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,2.975) 10(1,2.975) 11(0.5,2.975) 12(0,2.975)
  oval 1.016x0.254 smd: 5(2.238,0.738) 6(2.238,1.238) 7(2.238,1.738) 8(2.238,2.238) 13(-0.738,2.238) 14(-0.738,1.738) 15(-0.738,1.238) 16(-0.738,0.738)
  rect 1.702x1.702 smd: 17(0.75,1.488)
TPC12
  round 0.305 smd: 1(0,0)
TPS2544RTER_WQFN16_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.651x1.651 smd: 17(0.75,1.55)
TPS22961DNYR_WSON8
  oval 0.305x0.559 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS61181ARTER_QFN16_3X3
  oval 0.254x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.153) 10(1,3.153) 11(0.5,3.153) 12(0,3.153)
  oval 0.838x0.254 smd: 5(2.327,0.827) 6(2.327,1.327) 7(2.327,1.827) 8(2.327,2.327) 13(-0.827,2.327) 14(-0.827,1.827) 15(-0.827,1.327) 16(-0.827,0.827)
  rect 1.702x1.702 smd: 17(0.75,1.577)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TPS68470YFFR_DSBGA_56P
  round 0.3 smd: A1(0,0) A2(0.4,0) A3(0.8,0) A4(1.2,0) A5(1.6,0) A6(2,0) A7(2.4,0) B1(0,-0.4) B2(0.4,-0.4) B3(0.8,-0.4) B4(1.2,-0.4) B5(1.6,-0.4) B6(2,-0.4) B7(2.4,-0.4) C1(0,-0.8) C2(0.4,-0.8) C3(0.8,-0.8) C4(1.2,-0.8) C5(1.6,-0.8) C6(2,-0.8) C7(2.4,-0.8) D1(0,-1.2) D2(0.4,-1.2) D3(0.8,-1.2) D4(1.2,-1.2) D5(1.6,-1.2) D6(2,-1.2) D7(2.4,-1.2) E1(0,-1.6) E2(0.4,-1.6) E3(0.8,-1.6) E4(1.2,-1.6) E5(1.6,-1.6) E6(2,-1.6) E7(2.4,-1.6) F1(0,-2) F2(0.4,-2) F3(0.8,-2) F4(1.2,-2) F5(1.6,-2) F6(2,-2) F7(2.4,-2) G1(0,-2.4) G2(0.4,-2.4) G3(0.8,-2.4) G4(1.2,-2.4) G5(1.6,-2.4) G6(2,-2.4) G7(2.4,-2.4) H1(0,-2.8) H2(0.4,-2.8) H3(0.8,-2.8) H4(1.2,-2.8) H5(1.6,-2.8) H6(2,-2.8) H7(2.4,-2.8)
TPS79801QDGNRQ1_MSOP8
  oval 0.381x1.575 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,4.35) 6(1.3,4.35) 7(0.65,4.35) 8(0,4.35)
  rect 1.88x1.753 smd: 9(0.975,2.175)
TS3USB221ARSER_UQFN10_2X1P5
  oval 0.254x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 6(1.5,1.65) 7(1,1.65) 8(0.5,1.65) 9(0,1.65)
  oval 0.889x0.254 smd: 5(1.8,0.825) 10(-0.3,0.825)
TS5A23157RSER_QFN10_2X1P5
  oval 0.305x0.584 smd: 1(0,0) 4(1.5,0) 6(1.5,1.27) 9(0,1.27)
  oval 0.254x0.584 smd: 2(0.5,0) 3(1,0) 7(1,1.27) 8(0.5,1.27)
  oval 0.635x0.305 smd: 5(1.61,0.635) 10(-0.11,0.635)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
TVWDF1004AD0_DFN9
  oval 0.203x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
W25Q80DVZPIG_WSON8
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
W25Q128FVPIQ_WSON8
  oval 0.66x1.092 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.9) 6(2.54,5.9) 7(1.27,5.9) 8(0,5.9)
  rect 4.293x3.404 smd: 9(1.905,2.95)
WM7211IMS-RV_LGA5-8
  rect 0.508x0.991 smd: 1(0,0) 2(0,1.35) 3(-0.85,1.35) 4(-0.85,0)
  rect 0.406x2.311 smd: 5(0.775,0.675) 7(-1.625,0.675)
  rect 1.295x0.406 smd: 6(-0.425,2.375) 8(-0.425,-1.025)
Y_9H03200031_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_9H03220008_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.85V_VCCIO_PG: PR806.1 PU808.4 R35.2
0.85VS_MODE: PC808.1 PR809.1 PU808.7
0.95V_PRIM_PG: PR913.1 PU901.4 R164.2
0.95VCC_SENSE_R: PR917.1 PU901.5
0.95VSS_SENSE_R: PR918.1 PU901.6
1.0V_PRIM_PG: PR818.2 PU801.2 R391.2
1.2V_DDR_OT: PR701.2 PU700.11
1.2V_DDR_PG: PR712.1 PU700.12 R139.2
1.8V_PRIM_PG: PR1001.2 PU1000.2 R143.2
3.3V_NGFF1_EN: D6.3 U34.G4
3V_EN: PC612.1 PR608.2 PU600.11
3V_PRIM_PG: PR905.1 PU900.3 R364.2
3V_VIN: PC601.1 PC602.1 PC604.1 PC605.1 PL600.2 PU600.1
3VALW_PG: D3.1 PQ112.2 PR130.1 PR605.1 PU600.3
3VP_EN: PC912.1 PR906.1 PR915.2 PU900.11
3VP_VIN: PC902.1 PC903.1 PC904.1 PC905.1 PL900.2 PU900.1
5V_EN: PR607.2 PR612.1 PU601.11
5VALW_PG: PR618.1 PU601.3 R388.2
+0.6VSP: PC716.1 PC717.1 PU700.5 PU700.8
+0.85VS_VCCIO: CC14.1 CC15.1 CC20.1 CC21.1 CC22.1 CC23.1 CC24.1 CC25.1 CC26.1 CC27.1 CC30.1 CC31.1 CC32.1 CC33.1 CC34.1 CC35.1 CC36.1 CC38.1 CC43.1 CC45.1 CC50.1 CC57.1 CC60.1 CC92.1 CC93.1 PJP800.2 R406.1 RC10.1 RC70.2 UC1.AC23 UC1.AC24 UC1.AE23 UC1.AE24 UC1.AE26 UC1.AF24 UC1.AF26 UC1.AH26 UC1.AK26 UC1.AL26 UC1.AN26 UC1.AR26 UC1.AT26 UC1.AV26 UC1.AV28 UC1.AV30 UC1.AV32 UC1.AV34 UC1.AV36 UC1.AV38 UC1.AV40 UC1.AV42 UC1.AV44 UC1.AV46 UC1.AV48 UC1.AV50 UC1.AW27 UC1.AW29 UC1.AW31 UC1.AW33 UC1.AW35 UC1.AW37 UC1.AW39 UC1.AW41 UC1.AW43 UC1.AW45 UC1.AW47 UC1.AW49 UC1.AW51
+0.85VS_VCCIOP: PC803.1 PC804.1 PJP800.1 PL802.2 PR808.1 PU808.1
+0.95V_PRIM: PJP901.2 RC18.1
+0.95V_PRIMP: PC916.1 PC917.1 PC924.1 PJP901.1 PL904.2 PR917.2 PU901.1
+1.0V_APLL: CC75.1 CC79.1 CC124.1 L11.2 UC1.AA18 UC1.AA19
+1.0V_MPHYGT: CC80.1 CC114.1 CC115.1 RC51.2 UC1.T1 UC1.T15 UC1.T16 UC1.U2
+1.0V_MPHYPLL: CC76.1 CC88.1 CC89.1 L15.2 UC1.V15 UC1.V16
+1.0V_PRIM: C331.1 C337.1 C338.1 CC84.1 CC121.1 L11.1 PJP801.2 RC17.1 RC24.1 RC26.1 RC29.1 RC91.1 RC99.1 RC103.1 RC108.1 U48.1 U48.2 U48.7 U50.1 U50.2 U50.6 U50.7
+1.0V_PRIMP: PC816.1 PC817.1 PC818.1 PC819.1 PC820.1 PJP801.1 PL804.2 PR817.1
+1.0V_VCCPLL: CC116.1 RC67.2 UC1.R27 UC1.T27
+1.0V_VCCST: C26.1 C323.1 C329.1 CC118.1 PC1111.1 PR1106.1 PR1108.1 PR1111.1 R423.1 R445.2 RC67.1 RC90.1 RC96.2 RH108.1 U34.B11 UC1.V26 UC1.Y26
+1.0V_XDP: CC120.1 CC122.1 JXDP1.43 JXDP1.44 RC77.1 RC103.2
+1.0VA_GATE: C319.1 C322.1 L15.1 R438.2 RC19.1 RC51.1 RC102.1
+1.0VS_VCCSTG: C321.1 CC117.1 PR1114.1 R441.2 RC68.2 RC94.1 RC95.1 RC97.1 RC98.1 RC118.1 RC119.1 RC120.1 RC123.1 UC1.R26 UC1.T26
+1.2V_DDR: C91.1 C92.1 C93.1 C131.1 C191.1 C227.1 C228.1 C229.1 C230.1 C232.1 C237.1 C240.1 C244.1 C245.1 C246.1 C247.1 C248.1 C252.1 C253.1 C254.1 C256.1 C258.1 C259.1 C260.1 C269.1 C271.1 C276.1 C282.1 C283.1 C284.1 C285.1 C332.1 CC7.1 CC8.1 CC9.1 CC10.1 CC11.1 CC12.1 CC16.1 CC17.1 CC18.1 CC19.1 CC91.1 CC94.1 CC95.1 CC96.1 CC97.1 CC98.1 CC99.1 CC104.1 CC107.1 L10.1 PJP700.2 R64.1 R76.1 R119.1 R437.1 U26.1 U26.2 U33.A6 U33.A7 U33.A9 U33.A11 U33.A13 U33.B9 U33.B12 U33.B17 U33.C3 U33.C12 U33.C17 U33.E1 U33.E17 U33.G2 U33.G12 U33.G17 U33.H1 U33.H16 U33.K1 U33.K12 U33.K17 U33.L1 U33.L17 U33.M2 U33.M3 U33.M7 U33.M10 U33.M12 U33.N1 U33.P17 U33.R15 U33.T8 U33.U2 U33.U3 U33.U5 U33.U7 U33.U10 U33.U11 U33.U14 U35.A6 U35.A7 U35.A9 U35.A11 U35.A13 U35.B9 U35.B12 U35.B17 U35.C3 U35.C12 U35.C17 U35.E1 U35.E17 U35.G2 U35.G12 U35.G17 U35.H1 U35.H16 U35.K1 U35.K12 U35.K17 U35.L1 U35.L17 U35.M2 U35.M3 U35.M7 U35.M10 U35.M12 U35.N1 U35.P17 U35.R15 U35.T8 U35.U2 U35.U3 U35.U5 U35.U7 U35.U10 U35.U11 U35.U14 U49.1 U49.2 U49.7 UC1.AH64 UC1.AK64 UC1.AT64 UC1.AV64 UC1.BA25 UC1.BA27 UC1.BA29 UC1.BA31 UC1.BA33 UC1.BA35 UC1.BA37 UC1.BA41 UC1.BA43 UC1.BA45 UC1.BA47 UC1.BA49 UC1.BA51 UC1.BN64 UC1.BP24 UC1.BP26 UC1.BP32 UC1.BP34 UC1.BP40 UC1.BP42 UC1.BP48 UC1.BP50 UC1.BP56 UC1.BP58 UC1.BP64 UC2.5
+1.2V_DDRP: PC710.1 PC711.1 PC712.1 PC713.1 PC720.1 PJP700.1 PL701.2 PR704.1 PU700.6
+1.2V_UF_DVDD: C57.1 C58.1 C121.1 C356.1 JUFC.1 R109.2
+1.2V_VCCPLL_OC: C324.1 R437.2 R442.2 UC1.AE27 UC1.AF27
+1.2V_WF_DVDD: C62.1 C63.1 JWFC.23 R55.2
+1.2VS: C190.1 CX1.1 CX2.1 CX3.1 CX13.1 CX15.1 CX16.1 R217.2 U25.12 U25.19 U25.20 U25.31 U25.40
+1.8V_IO_OUT: C75.1 C358.1 RH12.2 RH13.2 U6.E7
+1.8V_MEM: C67.1 C101.1 C107.1 C108.1 C120.1 C225.1 C243.1 C251.1 C270.1 R98.2 U33.A15 U33.A16 U33.B2 U33.R1 U33.T1 U33.T16 U35.A15 U35.A16 U35.B2 U35.R1 U35.T1 U35.T16
+1.8V_PCH_GPP: CC105.1 CC106.1 RC48.2 UC1.AE15 UC1.AE16 UC1.AN2 UC1.AP1
+1.8V_PRIM: C64.1 C65.1 C157.1 PJP1000.2 R52.1 RC48.1 RH1.2 RH2.2 RH6.2 RH10.2 RH29.2 RH31.2 RH34.2 RH36.2 RH38.2 RH39.2 RH87.2 RH88.2 U7.1 U7.2 U7.6 U7.7 U20.6 U20.7
+1.8V_PRIMP: PC1002.1 PC1003.1 PC1004.1 PJP1000.1 PL1001.2 PR1004.1
+1.8V_UF_VDD: C52.1 C119.1 C357.1 JUFC.3 R117.2
+1.8V_WF_DOVDD: C45.1 C88.1 C355.1 JWFC.24 R89.2
+1.8VA_LDO_PD: C212.1 U32.K1
+1.8VD_LDO_PD: C213.1 R297.2 U32.A2
+1.8VS: C47.1 C90.1 R1.1 R31.1 R108.2 RH85.2 RH86.2 U4.5 U4.14 U4.15
+1.8VS_AUDIO: C142.1 CA18.1 CA20.1 CA22.1 R160.2 RA19.2 UA2.13 UA2.17
+1.8VSP_ON: PC1000.1 PR1000.1 PU1000.7
+2.8V_UF_AVDD: C40.1 C51.1 C61.1 C361.1 C368.1 JUFC.2 R50.1 R59.2
+2.8V_VCM_OUT: C38.1 C42.1 C56.1 C359.1 JWFC.26 R40.1 R42.1 R57.2
+2.8V_WF_AVDD: C44.1 C117.1 C360.1 C367.1 JWFC.25 R110.2
+3.3V_BBAT_LDO: D9.2 JIO4.2
+3.3V_LDO_PD: C206.1 C208.1 R238.1 R239.1 R244.1 R246.1 R247.1 R251.1 R253.1 R263.1 R267.1 R268.1 R271.1 R272.1 R273.1 R275.1 R484.2 R486.1 R487.1 U28.8 U32.G1
+3.3V_PCH_GPP: CC101.1 CC102.1 CC103.1 CC109.1 CC111.1 CC112.1 RC44.2 UC1.AA2 UC1.AB1 UC1.AF1 UC1.AG2 UC1.AH1 UC1.AJ2 UC1.AN15 UC1.AP13 UC1.AT1 UC1.AU2 UC1.AV1 UC1.AW2
+3.3V_SPI: CH8.1 CH13.1 JSPI1.15 RC2.1 RH48.1 RH56.1 U16.8 U39.8
+3.3V_TBAT_LDO: D10.2 PD1500.2 PR109.2
+3.3V_VCCSPI: CC100.1 RC40.2 UC1.AT15 UC1.AV15
+3.3V_VOUT_PD: C214.1 U32.H2
+3.3VDX_SSD: C141.1 C172.1 C173.1 C296.1 C299.1 C300.1 JNGFF2.2 JNGFF2.4 JNGFF2.12 JNGFF2.14 JNGFF2.16 JNGFF2.18 JNGFF2.70 JNGFF2.72 JNGFF2.74 R161.2 R407.2 U51.5
+3V_1.8V_HDA: CC13.1 L24.2 UC1.AT23 UC1.AV22
+3V_LDO: C7.1 JIO4.29 PC120.2 PD1500.3 PQ107.3 PQ108.3 PR128.2 PR131.1 PR300.1 PR301.1 PR549.1 PR558.1 PU300.5 R17.1 R274.1 R351.1 RTCD1.2 U1.6
+3V_LDOP: PQ107.1 PR136.2
+3V_PRIM: C28.1 C77.1 C138.1 C169.1 JAPS2.12 JAPS2.18 JSPI1.16 PJP900.2 PR800.1 PR806.2 PR825.1 PR827.1 PR1001.1 Q7.6 Q9.3 R36.1 R73.1 R85.1 R123.1 R145.1 R185.1 R186.1 R387.1 RC2.2 RC11.1 RC12.1 RC40.1 RC42.1 RC43.1 RC44.1 RC50.1 RC54.1 RC55.1 RC82.1 RC87.1 RC88.1 RC107.1 RC112.1 RC113.1 RH53.2 RH54.2 RH70.1 RH72.2 RH75.2 RH76.2 RH81.2 RH83.2 RH89.2 RH95.2 RH96.2 RH97.2 RH98.1 RH105.1 RH106.1 RH109.2 RH110.2 RH115.2 RH116.2 RH117.2 RH119.2 RH122.2 RH123.2 RH126.2 RH127.2 RH128.1 RH130.2 U3.1 U3.2 U15.1 U15.2 U20.1 U20.2 U23.5 U24.5 U38.5 U44.5 U45.5 UH2.5 UH3.5
+3V_PRIMP: PC906.1 PC907.1 PC908.1 PC909.1 PJP900.1 PL901.2 PU900.5
+3V_SKYCAM: C46.1 C48.1 C81.1 C105.1 C116.1 C125.1 C362.1 R94.1 R95.1 R123.2 U6.A7 U6.B5 U6.B6 U6.D1 U6.G6 U6.H5 U9.8
+3V_TPM_S0: C5.1 C15.1 R70.2 R73.2 U2.8
+3VALW: C87.1 C115.1 C148.1 C155.1 C167.1 C182.1 C198.1 C267.1 C297.1 C298.1 C306.1 CZ3.1 JAPS2.16 JIO1.8 JUSH1.14 JUSH1.15 JUSH1.16 PC117.1 PC822.1 PC1409.1 PC1410.1 PC1412.1 PC1413.1 PJP602.2 PL903.1 PQ108.1 PR125.1 PR135.1 PR137.1 PR151.1 PR154.1 PR155.1 PR156.1 PR157.1 PR158.1 PR605.2 PR722.2 PR818.1 PR819.1 PR824.1 PR907.1 PR913.2 PR1105.1 PR1413.1 PR1421.1 PR1423.1 PR1424.1 PU100.8 PU150.8 PU151.8 PU801.7 PU1403.5 PU1404.5 PU1501.8 R175.1 R189.1 R245.1 R254.1 R350.1 R410.2 RZ2.1 U12.1 U12.2 U12.6 U12.7 U18.1 U18.2 U19.5 U22.1 U22.2 U22.6 U22.7 U29.10 U30.5 U41.6 U43.5 U46.1 U46.2 UH1.5
+3VALW_DSW: C180.1 CC64.1 R107.1 R175.2 R183.2 R185.2 RC114.1 RH15.1 RH17.1 RH20.1 RH58.1 RH59.1 RH62.1 UC1.AL15 UC1.AM13
+3VALW_EC: C22.1 C32.1 C33.1 C35.1 C36.1 C37.1 C234.1 C255.1 C263.1 L5.1 PC200.1 PU200.5 R22.1 R60.1 R61.1 R309.1 R310.1 R311.1 R312.1 R313.1 R314.1 R315.1 R317.1 R318.2 R319.2 R320.2 R321.2 R322.2 R323.2 R328.2 R329.1 R330.2 R331.2 R332.2 R336.2 R338.1 R339.2 R340.1 R342.2 R343.1 R344.1 R345.2 R347.2 R350.2 R351.2 R352.2 R353.1 R354.1 R357.1 R360.1 R361.1 R362.2 R363.2 R369.2 U34.A6 U34.F3 U34.F12 U34.K1 U34.K2 U34.K4 U34.K12 U34.L4 U34.N4
+3VALW_EC_L: C34.1 L5.2 U34.H3
+3VALW_PD: C204.1 C209.1 R254.2 R274.2 U32.B1 U32.H1
+3VALW_TPM: C21.1 C89.1 R107.2 U2.1
+3VALWP: PC606.1 PC607.1 PC608.1 PC609.1 PJP602.1 PL601.2 PU600.5
+3VLP: PC610.2 PU600.6
+3VLP1: PC910.2 PU900.6
+3VS: C53.1 C162.1 C186.1 C201.1 C202.1 C205.2 C316.1 C327.1 C333.1 C340.1 CU1.1 CU2.1 CV11.1 CV14.1 CV23.1 CV35.1 CV45.1 CX4.1 CX14.1 CZ5.1 JIO1.7 JIO1.9 JIO4.27 JIO4.28 JLPDE1.1 JLPDE1.2 JUSH1.19 Q1.2 Q4.2 Q4.5 R24.1 R70.1 R165.2 R179.1 R202.1 R204.1 R206.1 R208.1 R214.1 R218.1 R219.1 R221.1 R223.1 R228.1 R229.1 R232.1 R233.1 R262.1 R295.2 R296.2 R434.1 R440.1 R443.1 R444.1 R446.1 R449.1 R451.1 R453.2 R455.2 R457.1 R459.2 R461.1 R466.2 R469.2 R483.1 R497.1 RC14.1 RC38.2 RC58.2 RC59.2 RC60.2 RC62.2 RC76.1 RC85.1 RC89.1 RC124.1 RC128.1 RH40.2 RH41.2 RH42.2 RH43.1 RH44.1 RH45.2 RH61.2 RH63.2 RH65.2 RH66.1 RH80.2 RH91.2 RH99.2 RH100.2 RH101.2 RH102.2 RH114.2 RH120.2 RH124.2 RH131.2 RH132.2 RV2.1 RV3.1 RV6.1 RV9.1 RV11.1 RV14.2 RV19.1 RV24.1 RV26.1 RV27.1 RV29.1 RV30.2 RX3.1 U4.13 U25.11 U25.37 U27.1 U27.13 U31.22 U47.5 U47.21 U47.30 U47.51 U47.57 UH4.5 UH5.5 UV1.1 UV1.6 UV1.12 UV1.25 UV1.32 UV1.36 UV2.1 UV2.6 UV2.12 UV2.25 UV2.32 UV2.36
+3VS_AUDIO: C54.1 C140.1 CA10.1 CA13.1 CA14.1 CA15.1 CA33.1 JDMIC1.1 JUFC.30 L24.1 LA1.1 MIC1.1 MIC1.2 MIC2.1 Q17.2 Q17.5 QA2.2 QA2.5 R149.2 R182.1 RA31.2 RA36.2 RA38.1 RA56.1 UA1.8 UA2.12
+3VS_CAM: C55.1 C68.1 C69.1 C72.1 JCAM3.9 JCAM3.10 R58.2
+3VS_CR: C111.1 JIO1.1 JIO1.2 JIO1.3 JIO1.4 JIO1.5 JIO1.6 R115.2
+3VS_CRRP: C127.1 C139.1 R132.1 R133.1 R134.1 R151.1 R152.1 R153.1 R154.1 R497.2 U14.1 U14.13 U52.5
+3VS_HP: C178.1 C179.1 R157.1 R158.1 R173.1 R182.2 U21.14
+3VS_NFC: C184.1 C185.1 C188.1 JNFC1.1 JNFC1.2 JNFC1.19 R187.2 R188.1 R197.1 R501.1 R502.1
+3VS_TPM: C6.1 C25.1 C27.1 C50.1 R36.2 U2.14 U2.22 U5.5
+3VS_TS: C304.1 C305.1 C317.1 C320.1 JTS1.5 R432.2 RC52.2 RC53.2 RH118.2
+3VS_WLAN: C10.1 C11.1 C16.1 C17.1 C20.1 C29.1 C30.1 JNGFF3.2 JNGFF3.4 JNGFF3.72 JNGFF3.74 R15.2 U8.5
+3VS_WWAN: C1.1 C2.1 C3.1 C4.1 C13.1 C66.1 C73.1 C78.1 C85.1 C99.1 C102.1 JNGFF1.2 JNGFF1.4 JNGFF1.62 JNGFF1.64 JNGFF1.66 Q5.2 R5.1 R27.1 R93.2
+5V_DOCK: C181.1 JIO4.23 JIO4.24 JIO4.25 JIO4.26 R174.2
+5V_USB_P1: C343.1 C344.1 C345.1 JUSB1.1 MD2.8 US1.12
+5VALW: C103.1 C135.1 C143.1 C147.1 C183.1 C199.1 C200.1 C334.1 C335.1 C336.1 CZ4.1 JIO1.10 JUSH1.18 PC1101.1 PJP603.2 PL805.1 PL1000.1 PR409.2 PR1556.2 PR1557.2 PR1558.1 PU1100.6 R28.2 R193.1 R240.2 R243.1 R299.1 U3.4 U7.4 U12.4 U13.1 U13.2 U13.4 U15.4 U15.6 U15.7 U17.1 U17.2 U17.4 U18.4 U18.6 U18.7 U20.4 U22.4 U26.4 U46.4 U48.3 U49.3 U50.4 US1.1 UV3.1 UV3.2 UV3.4
+5VALW_PD: C223.1 C224.1 R299.2 U32.A11 U32.B11 U32.C11 U32.D11 U32.H10
+5VALWP: PC620.1 PC621.1 PC622.1 PC623.1 PJP603.1 PL603.2 PU601.5
+5VLP: PC624.2 PU601.6
+5VS: C60.1 C114.1 C174.1 CZ2.1 JUFC.31 JUFC.32 JUFC.33 JUFC.34 JUSH1.20 R116.2
+5VS_AUDIO: C133.1 CA39.1 CA44.1 LA2.2 LA3.2 LA10.2 LA11.1 LA12.1 R142.2
+5VS_NFC: C187.1 JNFC1.17 JNFC1.18 R192.2
+AVDD1: CA36.1 CA38.1 CA42.1 LA10.1 UA3.45
+AVDD2: CA60.1 CA63.1 RA19.1 RA58.1 UA3.24
+DVDD: CA8.1 CA9.1 LA1.2 RA17.1 RA44.1 RA52.1 RA53.1 UA3.7
+DVDDIO: CA56.1 CA62.1 RA56.2 UA3.19
+PVDD: CA23.1 CA24.1 CA29.1 LA2.1 UA2.41 UA2.44
+VBUS1: C348.2 C349.2 C350.2 C351.2 CT2.1 CT3.1 CT4.1 CT5.1 D38.1 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 PC106.1 PC108.1 PC109.1 PC115.1 PL103.1
+VBUS1_IN: C215.1 C216.1 C217.1 C218.1 C220.1 PC124.1 PC125.1 PD103.2 PQ104.5 PR121.1 PR546.1 U32.A6 U32.A7 U32.A8 U32.B7
+VBUS1_PD: C222.1 PC107.1 PC110.1 PC111.1 PC112.1 PC113.1 PL103.2 PR117.1 U32.A10 U32.B10 U32.H11 U32.J10 U32.J11 U32.K11
+VCC_CORE: PC1129.2 PC1130.2 PC1132.2 PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1204.1 PC1205.1 PC1206.1 PC1207.1 PC1208.1 PC1209.1 PC1225.1 PC1226.1 PC1227.1 PC1228.1 PC1229.1 PC1230.1 PC1231.1 PC1232.1 PC1233.1 PC1234.1 PC1237.1 PC1238.1 PC1239.1 PC1240.1 PC1241.1 PC1242.1 PC1243.1 PC1244.1 PC1245.1 PC1246.1 PC1247.1 PC1248.1 PC1249.1 PC1250.1 PC1257.1 PC1258.1 PC1259.1 PC1260.1 PC1261.1 PC1262.1 PC1263.1 PC1264.1 PC1265.1 PC1281.1 PC1282.1 PC1283.1 PC1284.1 PC1285.1 PC1286.1 PC1287.1 PC1288.1 PC1289.1 PC1290.1 PH1102.2 PL1104.2 PR1144.2 PR1146.2 RC23.1 UC1.A64 UC1.AA32 UC1.AA41 UC1.AC32 UC1.AC41 UC1.AE32 UC1.AE33 UC1.AE35 UC1.AE36 UC1.AE38 UC1.AE40 UC1.AE41 UC1.AF32 UC1.AF41 UC1.AH32 UC1.AH41 UC1.AK32 UC1.AK41 UC1.AL32 UC1.AL41 UC1.AN32 UC1.AN41 UC1.AR32 UC1.AR41 UC1.AT32 UC1.AT33 UC1.AT35 UC1.AT36 UC1.AT38 UC1.AT40 UC1.AT41 UC1.B64 UC1.D64 UC1.F64 UC1.H63 UC1.J64 UC1.L40 UC1.L42 UC1.L44 UC1.L46 UC1.L48 UC1.L50 UC1.L52 UC1.L54 UC1.L63 UC1.M33 UC1.M35 UC1.M37 UC1.M39 UC1.M41 UC1.M43 UC1.M45 UC1.M47 UC1.M49 UC1.M51 UC1.M53 UC1.M56 UC1.M58 UC1.M60 UC1.M62 UC1.M64 UC1.N32 UC1.N34 UC1.N36 UC1.N38 UC1.N40 UC1.N42 UC1.N54 UC1.N55 UC1.N57 UC1.N59 UC1.N61 UC1.N63 UC1.P56 UC1.P58 UC1.P60 UC1.P62 UC1.P64 UC1.R32 UC1.R41 UC1.R57 UC1.R59 UC1.R61 UC1.R63 UC1.T32 UC1.T41 UC1.V32 UC1.V41 UC1.Y32 UC1.Y41
+VCC_GT: PC1127.2 PC1128.2 PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1215.1 PC1216.1 PC1217.1 PC1218.1 PC1219.1 PC1220.1 PC1221.1 PC1222.1 PC1223.1 PC1224.1 PC1235.1 PC1236.1 PC1251.1 PC1252.1 PC1253.1 PC1254.1 PC1255.1 PC1256.1 PC1271.1 PC1272.1 PC1273.1 PC1274.1 PC1275.1 PC1276.1 PC1277.1 PC1278.1 PC1279.1 PC1280.1 PC1302.1 PC1303.1 PC1304.1 PH1101.2 PL1103.1 PR1143.2 PR1145.1 PR1147.1 RC56.1 UC1.AA53 UC1.AB54 UC1.AB56 UC1.AB58 UC1.AB60 UC1.AB62 UC1.AB64 UC1.AC43 UC1.AC44 UC1.AC46 UC1.AC47 UC1.AC49 UC1.AC50 UC1.AC51 UC1.AC53 UC1.AC55 UC1.AC57 UC1.AC59 UC1.AC61 UC1.AC63 UC1.AD54 UC1.AD56 UC1.AD58 UC1.AD60 UC1.AD62 UC1.AD64 UC1.AE53 UC1.AE55 UC1.AE57 UC1.AE59 UC1.AE61 UC1.AE63 UC1.AF43 UC1.AF44 UC1.AF46 UC1.AF47 UC1.AF49 UC1.AF50 UC1.AF51 UC1.AG53 UC1.AJ53 UC1.AK43 UC1.AK44 UC1.AK46 UC1.AK47 UC1.AK49 UC1.AK50 UC1.AK51 UC1.AN43 UC1.AN44 UC1.AN46 UC1.AN47 UC1.AN49 UC1.AN50 UC1.AN51 UC1.AT43 UC1.AT44 UC1.AT46 UC1.AT47 UC1.AT49 UC1.AT50 UC1.AT51 UC1.N44 UC1.N46 UC1.N48 UC1.N50 UC1.R51 UC1.R53 UC1.T43 UC1.T44 UC1.T46 UC1.T47 UC1.T49 UC1.T50 UC1.T51 UC1.T54 UC1.U53 UC1.U55 UC1.U57 UC1.U59 UC1.U61 UC1.U63 UC1.V54 UC1.V56 UC1.V58 UC1.V60 UC1.V62 UC1.V64 UC1.W53 UC1.W55 UC1.W57 UC1.W59 UC1.W61 UC1.W63 UC1.Y43 UC1.Y44 UC1.Y46 UC1.Y47 UC1.Y49 UC1.Y50 UC1.Y51 UC1.Y54 UC1.Y56 UC1.Y58 UC1.Y60 UC1.Y62 UC1.Y64
+VCC_SA: PC1112.2 PC1113.2 PC1115.2 PC1266.1 PC1267.1 PC1268.1 PC1269.1 PC1270.1 PC1291.1 PC1292.1 PC1293.1 PC1294.1 PC1295.1 PC1296.1 PC1297.1 PC1298.1 PC1299.1 PC1300.1 PC1301.1 PH1100.2 PL1102.2 PR1119.2 PR1124.2 RC21.1 RC33.1 UC1.AA29 UC1.AC29 UC1.AC30 UC1.AE29 UC1.AF29 UC1.AF30 UC1.AH29 UC1.AK29 UC1.AK30 UC1.AL29 UC1.AN29 UC1.AN30 UC1.AR29 UC1.L30 UC1.M31 UC1.N30 UC1.R29 UC1.T29 UC1.T30 UC1.V29 UC1.Y29 UC1.Y30
+VCC_SA_DDR: CC3.1 CC4.1 CC29.1 RC33.2 UC1.AT29 UC1.AT30
+VCCAPLLEBB_1P0: CC83.1 RC102.2 UC1.R15 UC1.R16
+VCCCLK1: CC85.1 RC24.2 UC1.V18 UC1.Y18
+VCCCLK2: CC86.1 RC26.2 UC1.V19 UC1.Y19
+VCCCLK3: RC91.2 UC1.V23 UC1.Y23
+VCCCLK4: CC119.1 RC108.2 UC1.V21 UC1.Y21
+VCCCLK5: CC87.1 RC29.2 RH103.2 UC1.R21 UC1.R23
+VCCCLK6: RC99.2 UC1.R19 UC1.T19
+VCCCOREG0: CC67.1 CC68.1 CC69.1 CC70.1 CC71.1 CC72.1 CC73.1 CC74.1 CC77.1 CC78.1 CC81.1 CC82.1 UC1.AA35 UC1.AA38 UC1.AC35 UC1.AC38 UC1.R35 UC1.R38 UC1.T35 UC1.T38 UC1.V35 UC1.V38 UC1.Y35 UC1.Y38
+VCCCOREG1: CC41.1 CC42.1 CC44.1 CC46.1 CC47.1 CC51.1 CC52.1 CC55.1 CC56.1 CC59.1 CC63.1 CC65.1 UC1.AF35 UC1.AF38 UC1.AH35 UC1.AH38 UC1.AK35 UC1.AK38 UC1.AL35 UC1.AL38 UC1.AN35 UC1.AN38 UC1.AR35 UC1.AR38
+VCCPRIM_1P0: CC28.1 CC37.1 CC39.1 CC40.1 CC48.1 CC113.1 RC17.2 UC1.AA15 UC1.AA16 UC1.AH13 UC1.AH15 UC1.AH18 UC1.AH19 UC1.AK18 UC1.AL18 UC1.AR21 UC1.AT21 UC1.V1 UC1.W2
+VCCPRIM_3P3: CC53.1 CC61.1 CC62.1 CC66.1 CC110.1 RC50.2 UC1.AC2 UC1.AD1 UC1.AH21 UC1.AK19 UC1.AK21 UC1.AL19
+VCCPRIM_CORE: CC49.1 CC54.1 RC18.2 UC1.AE18 UC1.AE19 UC1.AF18 UC1.AF19 UC1.AR16 UC1.AT16
+VCCSRAM_1P0: CC58.1 RC19.2 UC1.AA21 UC1.AA23 UC1.AK23 UC1.AL23 UC1.AN23 UC1.AR23
+VDDQ_CPU_CLK: CC6.1 L10.2 UC1.BA39
AGND: C144.2 C158.2 C178.2 C179.2 CA1.2 CA2.2 CA3.2 CA11.2 CA12.2 CA34.2 CA36.2 CA37.2 CA38.2 CA40.2 CA41.2 CA42.2 CA46.2 CA53.2 CA58.2 CA59.2 CA60.2 CA63.2 CA64.2 CA65.2 CA66.2 JIO4.31 JIO4.34 JIO4.36 JIO4.37 R156.1 R159.1 R172.1 RA2.2 RA24.2 RA25.2 RA40.2 RA61.2 RA62.2 RA63.2 U21.10 U21.15 U21.17 UA3.20 UA3.30 UA3.42
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C15.2 C16.2 C17.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.1 C75.2 C77.2 C78.2 C81.2 C82.2 C83.2 C85.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.1 C111.2 C112.1 C113.1 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C125.2 C127.2 C131.2 C133.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C142.2 C143.2 C145.2 C146.2 C147.2 C148.2 C155.2 C157.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C198.2 C199.2 C200.2 C201.2 C202.2 C203.2 C204.2 C205.1 C206.2 C207.2 C208.2 C209.2 C212.2 C213.2 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C225.2 C226.2 C227.2 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C240.2 C241.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C276.2 C282.2 C283.2 C284.2 C285.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C302.2 C304.2 C305.2 C306.2 C307.2 C316.2 C317.2 C318.2 C319.2 C320.2 C321.2 C322.2 C323.2 C324.2 C325.2 C326.2 C327.2 C329.2 C331.2 C332.2 C333.2 C334.2 C335.2 C336.2 C337.2 C338.2 C339.2 C340.2 C342.2 C343.2 C344.2 C345.2 C348.1 C349.1 C350.1 C351.1 C353.2 C354.2 C355.2 C356.2 C357.2 C358.2 C359.2 C360.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 CA4.2 CA5.2 CA6.2 CA7.2 CA8.2 CA9.2 CA10.2 CA13.2 CA14.2 CA15.2 CA16.2 CA17.2 CA18.2 CA19.2 CA23.2 CA24.2 CA25.2 CA27.2 CA29.2 CA30.2 CA31.2 CA32.2 CA33.2 CA35.2 CA39.2 CA43.2 CA44.2 CA45.2 CA47.2 CA48.2 CA49.2 CA50.2 CA56.2 CA57.2 CA61.2 CA62.2 CA68.2 CA69.2 CA70.2 CC1.2 CC2.2 CC3.2 CC4.2 CC5.2 CC6.2 CC7.2 CC8.2 CC9.2 CC10.2 CC11.2 CC12.2 CC13.2 CC14.2 CC15.2 CC16.2 CC17.2 CC18.2 CC19.2 CC20.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC53.2 CC54.2 CC55.2 CC56.2 CC57.2 CC58.2 CC59.2 CC60.2 CC61.2 CC62.2 CC63.2 CC64.2 CC65.2 CC66.2 CC67.2 CC68.2 CC69.2 CC70.2 CC71.2 CC72.2 CC73.2 CC74.2 CC75.2 CC76.2 CC77.2 CC78.2 CC79.2 CC80.2 CC81.2 CC82.2 CC83.2 CC84.2 CC85.2 CC86.2 CC87.2 CC88.2 CC89.2 CC90.2 CC91.2 CC92.2 CC93.2 CC94.2 CC95.2 CC96.2 CC97.2 CC98.2 CC99.2 CC100.2 CC101.2 CC102.2 CC103.2 CC104.2 CC105.2 CC106.2 CC107.2 CC108.2 CC109.2 CC110.2 CC111.2 CC112.2 CC113.2 CC114.2 CC115.2 CC116.2 CC117.2 CC118.2 CC119.2 CC120.2 CC121.2 CC122.2 CC123.2 CC124.2 CH1.2 CH2.2 CH3.2 CH4.2 CH5.2 CH6.2 CH7.2 CH8.2 CH9.2 CH10.2 CH11.1 CH12.2 CH13.2 CH14.2 CH15.2 CH24.2 CLIP1.1(TP-1) CLIP2.1 CLIP3.1 CLIP4.1 CLIP5.1(TP-1) CLRP1.2 CLRP2.1 CT1.2 CT5.2 CU1.2 CU2.2 CV9.2 CV10.2 CV11.2 CV14.2 CV23.2 CV24.2 CV33.2 CV35.2 CV45.2 CX1.2 CX2.2 CX3.2 CX4.2 CX13.2 CX14.2 CX15.2 CX16.2 CX17.2 CX18.2 CX19.2 CX20.2 CX21.2 CX22.2 CX23.2 CX24.2 CX25.2 CX26.2 CZ1.2 CZ2.2 CZ3.2 CZ4.2 CZ5.2 D2.2 D8.2 D11.2 D13.2 D14.2 D15.2 D17.2 D18.2 D19.2 D20.2 D21.2 D22.2 D23.2 D24.2 D25.2 D26.2 D27.2 D28.2 D29.2 D30.2 D31.2 D32.2 D33.2 D34.2 D38.2 D39.2 D40.2 D41.2 D42.2 DA2.2 DA5.2 DA6.2 DA8.1 DA9.1 DA10.2 DA11.2 DI1.1 DI2.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H10.1(TP-1) H11.1(TP-1) H23.1(TP-1) H24.1(TP-1) H25.1(TP-1) H26.1(TP-1) H35.1(TP-1) JAPS2.5 JAPS2.7 JAPS2.9 JAPS2.11 JAPS2.19 JAPS2.20 JCAM3.1 JCAM3.4 JCAM3.7 JCAM3.11 JCAM3.12 JDEG1.10 JDEG1.11 JDEG1.12 JDMIC1.4 JDMIC1.5 JDMIC1.6 JEDP1.3 JEDP1.7 JEDP1.11 JEDP1.15 JEDP1.17 JEDP1.25 JEDP1.26 JEDP1.27 JEDP1.28 JEDP1.29 JEDP1.30 JEDP1.44 JEDP1.46 JEDP1.47 JHDMI1.4 JHDMI1.7 JHDMI1.10 JHDMI1.13 JHDMI1.16 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JHP1.6 JHP1.7 JIO1.23 JIO1.29 JIO1.30 JIO1.32 JIO1.34 JIO1.35 JIO1.36 JIO1.38 JIO1.40 JIO1.41 JIO1.42 JIO1.44 JIO1.45 JIO1.49 JIO1.52 JIO4.45 JIO4.47 JIO4.49 JIO4.51 JIO4.52 JIO4.53 JIO4.55 JIO4.57 JIO4.58 JIO4.59 JIO4.61 JIO4.63 JIO4.64 JIO4.65 JIO4.67 JIO4.69 JIO4.70 JIO4.71 JIO4.73 JIO4.75 JIO4.76 JIO4.77 JIO4.79 JIO4.81 JIO4.82 JIO4.83 JIO4.85 JIO4.87 JIO4.88 JIO4.89 JIO4.91 JIO4.93 JIO4.94 JIO4.95 JIO4.97 JIO4.99 JIO4.100 JLPDE1.9 JLPDE1.11 JLPDE1.12 JNFC1.5 JNFC1.7 JNFC1.9 JNFC1.11 JNFC1.13 JNFC1.15 JNFC1.21 JNFC1.22 JNFC1.23 JNFC1.24 JNGFF1.3 JNGFF1.5 JNGFF1.11 JNGFF1.19 JNGFF1.25 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.63 JNGFF1.65 JNGFF1.68 JNGFF1.69 JNGFF2.1 JNGFF2.3 JNGFF2.9 JNGFF2.15 JNGFF2.21 JNGFF2.27 JNGFF2.33 JNGFF2.39 JNGFF2.45 JNGFF2.51 JNGFF2.57 JNGFF2.71 JNGFF2.73 JNGFF2.75 JNGFF2.76 JNGFF2.77 JNGFF3.1 JNGFF3.7 JNGFF3.18 JNGFF3.23 JNGFF3.24 JNGFF3.29 JNGFF3.30 JNGFF3.33 JNGFF3.36 JNGFF3.39 JNGFF3.45 JNGFF3.51 JNGFF3.57 JNGFF3.63 JNGFF3.69 JNGFF3.75 JNGFF3.76 JNGFF3.77 JPWR2.3 JPWR2.4 JPWR2.5 JRTC1.2 JRTC1.3 JRTC1.4 JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21 JSPI1.22 JSPKL.3 JSPKL.4 JT100.8 JT100.9 JT100.10 JT100.11 JT100.12 JTS1.3 JTS1.13 JTS1.14 JUFC.5 JUFC.7 JUFC.8 JUFC.15 JUFC.19 JUFC.23 JUFC.24 JUFC.25 JUFC.26 JUFC.27 JUFC.40 JUFC.41 JUSB1.4 JUSB1.7 JUSB1.11 JUSB1.12 JUSB1.13 JUSB1.14 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JUSH1.6 JUSH1.7 JUSH1.10 JUSH1.24 JUSH1.25 JUSH1.27 JUSH1.28 JWFC.1 JWFC.5 JWFC.9 JWFC.13 JWFC.17 JWFC.21 JWFC.29 JWFC.31 JWFC.34 JWFC.35 JWFC.36 JWFC.37 JWFC.38 JWFC.39 JWFC.40 JWFC.41 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 JXDP1.61 JXDP1.62 JXDP1.63 LA5.1 LA7.1 LT1.2 MC1.1 MC2.2 MD1.3 MD2.7 MIC1.5 MIC1.6 MIC1.7 MIC1.8 MIC2.2 MIC2.5 MIC2.6 MIC2.7 MIC2.8 PC100.2 PC101.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC113.2 PC114.1 PC115.2 PC117.2 PC118.2 PC119.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.2 PC126.2 PC127.2 PC150.2 PC151.2 PC200.2 PC400.2 PC401.2 PC402.2 PC404.2 PC405.2 PC406.2 PC407.2 PC500.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC511.2 PC512.2 PC513.2 PC514.2 PC515.2 PC516.2 PC517.2 PC518.2 PC519.2 PC520.2 PC521.2 PC522.2 PC526.2 PC527.1 PC530.2 PC531.2 PC532.2 PC538.2 PC539.2 PC541.2 PC542.2 PC544.2 PC601.2 PC602.2 PC604.2 PC605.2 PC606.2 PC607.2 PC608.2 PC609.2 PC610.1 PC611.2 PC612.2 PC613.2 PC614.2 PC616.2 PC617.2 PC618.2 PC620.2 PC621.2 PC622.2 PC623.2 PC624.1 PC630.2 PC635.2 PC700.2 PC702.2 PC703.2 PC704.2 PC710.2 PC711.2 PC712.2 PC713.2 PC714.2 PC715.2 PC716.2 PC717.2 PC718.2 PC719.2 PC800.2 PC802.2 PC803.2 PC804.2 PC805.2 PC806.2 PC807.2 PC808.2 PC809.2 PC810.2 PC812.2 PC813.2 PC814.2 PC817.2 PC818.2 PC819.2 PC820.2 PC821.2 PC822.2 PC823.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC907.2 PC908.2 PC909.2 PC910.1 PC911.2 PC912.2 PC913.2 PC914.2 PC915.2 PC916.2 PC917.2 PC918.2 PC919.2 PC920.2 PC921.2 PC924.2 PC1000.2 PC1001.2 PC1003.2 PC1004.2 PC1005.2 PC1101.2 PC1102.2 PC1103.2 PC1104.2 PC1105.2 PC1106.2 PC1107.2 PC1109.2 PC1110.2 PC1111.2 PC1114.2 PC1116.2 PC1117.2 PC1118.2 PC1121.1 PC1122.2 PC1125.1 PC1126.2 PC1133.2 PC1134.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1140.2 PC1141.2 PC1142.2 PC1143.2 PC1144.2 PC1145.2 PC1146.2 PC1147.2 PC1148.2 PC1149.2 PC1150.2 PC1151.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1206.2 PC1207.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1216.2 PC1217.2 PC1218.2 PC1219.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1225.2 PC1226.2 PC1227.2 PC1228.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1234.2 PC1235.2 PC1236.2 PC1237.2 PC1238.2 PC1239.2 PC1240.2 PC1241.2 PC1242.2 PC1243.2 PC1244.2 PC1245.2 PC1246.2 PC1247.2 PC1248.2 PC1249.2 PC1250.2 PC1251.2 PC1252.2 PC1253.2 PC1254.2 PC1255.2 PC1256.2 PC1257.2 PC1258.2 PC1259.2 PC1260.2 PC1261.2 PC1262.2 PC1263.2 PC1264.2 PC1265.2 PC1266.2 PC1267.2 PC1268.2 PC1269.2 PC1270.2 PC1271.2 PC1272.2 PC1273.2 PC1274.2 PC1275.2 PC1276.2 PC1277.2 PC1278.2 PC1279.2 PC1280.2 PC1281.2 PC1282.2 PC1283.2 PC1284.2 PC1285.2 PC1286.2 PC1287.2 PC1288.2 PC1289.2 PC1290.2 PC1291.2 PC1292.2 PC1293.2 PC1294.2 PC1295.2 PC1296.2 PC1297.2 PC1298.2 PC1299.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1408.2 PC1409.2 PC1410.2 PC1412.2 PC1413.2 PC1414.1 PC1415.2 PC1500.2 PD100.1 PD101.1 PD401.2 PQ105.3 PQ106.1 PQ106.4 PQ109.1 PQ109.4 PQ112.3 PQ150.1 PQ150.4 PQ151.3 PQ202.3 PQ300.3 PQ501.5 PQ501.6 PQ501.7 PQ504.3 PQ505.3 PQ512.3 PQ513.3 PQ800.3 PQ1100.5 PQ1100.6 PQ1100.7 PQ1500.3 PQ1501.1 PR118.2 PR126.2 PR127.2 PR134.2 PR153.2 PR302.2 PR527.2 PR533.2 PR535.2 PR543.2 PR545.2 PR547.2 PR548.2 PR550.2 PR557.2 PR606.1 PR610.1 PR611.2 PR612.2 PR706.2 PR707.2 PR710.2 PR718.2 PR802.2 PR804.2 PR809.2 PR812.2 PR820.2 PR821.2 PR826.2 PR828.2 PR830.2 PR906.2 PR909.2 PR911.1 PR916.2 PR918.2 PR921.2 PR922.2 PR1005.2 PR1122.2 PR1123.2 PR1151.2 PR1152.2 PR1414.2 PR1420.2 PR1422.2 PR1425.2 PR1504.2 PR1510.2 PU100.4 PU101.2 PU150.4 PU150.6 PU151.4 PU151.6 PU200.3 PU300.3 PU400.1 PU500.22 PU600.2 PU600.10 PU601.2 PU601.10 PU700.2 PU700.4 PU801.9 PU808.15 PU808.16 PU808.17 PU900.2 PU900.10 PU901.15 PU901.16 PU901.17 PU1000.4 PU1000.8 PU1000.9 PU1100.4 PU1100.9 PU1101.A1 PU1101.A2 PU1101.A3 PU1101.A4 PU1101.A5 PU1101.A6 PU1101.A7 PU1101.A8 PU1101.D4 PU1101.D5 PU1101.H1 PU1101.H3 PU1101.H8 PU1403.3 PU1404.3 PU1500.4 PU1500.6 PU1501.4 Q6.3 Q7.4 Q8.1 Q8.4 Q15.3 Q16.3 Q18.3 Q23.3 R3.1 R26.2 R34.1 R38.1 R41.1 R49.1 R54.2 R63.1 R65.2 R67.2 R71.2 R74.2 R77.2 R101.2 R102.2 R104.2 R105.1 R111.1 R118.2 R125.2 R135.1 R136.1 R137.1 R138.1 R144.1 R146.1 R147.1 R148.1 R150.2 R155.1 R162.1 R167.1 R168.2 R169.1 R177.1 R184.1 R195.1 R196.1 R198.1 R199.1 R200.1 R203.1 R205.1 R207.1 R209.2 R210.2 R212.1 R213.1 R220.1 R222.1 R224.1 R225.1 R226.1 R227.1 R230.1 R234.1 R235.2 R241.1 R249.2 R256.2 R258.2 R261.2 R282.1 R285.1 R286.1 R298.2 R316.2 R324.2 R335.2 R341.2 R346.2 R359.2 R365.2 R367.2 R389.2 R392.2 R395.1 R416.2 R419.2 R433.1 R435.2 R436.1 R439.1 R447.2 R448.1 R452.1 R456.1 R458.2 R460.1 R468.2 R496.2 R498.2 R500.2 RA9.2 RA30.2 RA37.2 RA39.1 RA49.2 RA61.1 RA62.1 RA63.1 RC9.2 RC20.1 RC22.1 RC35.2 RC36.2 RC37.2 RC39.1 RC41.1 RC45.2 RC46.2 RC47.2 RC57.1 RC61.2 RC64.2 RC65.1 RC69.1 RC71.1 RC73.1 RC74.1 RC81.2 RC83.1 RC84.1 RC93.2 RC104.2 RH9.1 RH24.1 RH30.1 RH32.1 RH33.1 RH35.1 RH46.2 RH47.2 RH49.1 RH64.1 RH67.2 RH73.1 RH90.2 RH129.1 RV1.1 RV4.1 RV8.1 RV10.1 RV12.2 RV13.2 RV15.2 RV17.2 RV18.1 RV20.2 RV21.2 RV22.2 RV23.1 RV25.1 RV28.1 RV31.2 RZ1.1 RZ3.1 SW1.1 SW1.3 SW1.4 SW1.5 SW2.1 SW2.3 SW2.4 SW2.5 SW3.2 SW3.4 U1.2 U2.9 U2.16 U2.23 U2.32 U2.33 U3.5 U3.9 U4.6 U4.7 U4.8 U4.16 U5.3 U6.A2 U6.B4 U6.F4 U6.F7 U6.G4 U6.H7 U7.11 U7.15 U8.3 U9.4 U9.9 U12.11 U12.15 U13.5 U13.9 U14.6 U14.10 U14.18 U14.21 U14.24 U14.25 U15.11 U15.15 U16.4 U17.5 U17.9 U18.11 U18.15 U19.3 U20.11 U20.15 U22.11 U22.15 U23.3 U24.3 U25.15 U25.35 U25.41 U26.5 U26.9 U27.10 U27.21 U27.25 U28.4 U28.9 U29.5 U29.6 U30.3 U31.29 U32.A1 U32.B8 U32.D6 U32.D8 U32.E5 U32.E6 U32.E7 U32.E8 U32.F5 U32.F6 U32.F7 U32.F8 U32.G5 U32.G6 U32.G7 U32.G8 U32.H4 U32.H5 U32.H8 U32.L1 U32.L11 U33.A2 U33.A3 U33.A4 U33.A5 U33.A8 U33.A12 U33.A14 U33.B1 U33.B3 U33.B4 U33.C1 U33.C2 U33.C4 U33.D1 U33.D2 U33.D3 U33.D4 U33.D12 U33.D14 U33.D17 U33.E5 U33.E6 U33.E7 U33.E8 U33.E9 U33.E10 U33.E11 U33.E12 U33.F1 U33.F5 U33.F12 U33.F13 U33.F17 U33.G1 U33.G5 U33.G15 U33.G16 U33.H5 U33.H12 U33.H14 U33.H15 U33.J5 U33.J17 U33.K5 U33.L5 U33.L12 U33.L14 U33.M1 U33.M4 U33.M5 U33.M6 U33.M8 U33.M11 U33.M17 U33.N6 U33.N13 U33.N17 U33.P1 U33.P4 U33.P8 U33.P11 U33.P14 U33.R7 U33.R8 U33.R16 U33.R17 U33.T7 U33.T15 U33.T17 U33.U4 U33.U6 U33.U9 U33.U12 U33.U13 U33.U15 U33.U16 U34.A2 U34.A3 U34.F4 U34.F11 U34.G2 U34.H4 U34.J4 U34.N3 U35.A2 U35.A3 U35.A4 U35.A5 U35.A8 U35.A12 U35.A14 U35.B1 U35.B3 U35.B4 U35.C1 U35.C2 U35.C4 U35.D1 U35.D2 U35.D3 U35.D4 U35.D12 U35.D14 U35.D17 U35.E5 U35.E6 U35.E7 U35.E8 U35.E9 U35.E10 U35.E11 U35.E12 U35.F1 U35.F5 U35.F12 U35.F13 U35.F17 U35.G1 U35.G5 U35.G15 U35.G16 U35.H5 U35.H12 U35.H14 U35.H15 U35.J5 U35.J17 U35.K5 U35.L5 U35.L12 U35.L14 U35.M1 U35.M4 U35.M5 U35.M6 U35.M8 U35.M11 U35.M17 U35.N6 U35.N13 U35.N17 U35.P1 U35.P4 U35.P8 U35.P11 U35.P14 U35.R7 U35.R8 U35.R16 U35.R17 U35.T7 U35.T15 U35.T17 U35.U4 U35.U6 U35.U9 U35.U12 U35.U13 U35.U15 U35.U16 U38.3 U39.4 U41.5 U43.2 U44.3 U45.3 U46.5 U46.9 U47.2 U47.11 U47.19 U47.52 U47.61 U48.5 U49.5 U50.11 U50.15 U51.3 U52.3 UA1.3 UA2.15 UA2.38 UA2.47 UA2.49 UA3.57 UC1.A5 UC1.A14 UC1.AA24 UC1.AA27 UC1.AA30 UC1.AA33 UC1.AA36 UC1.AA40 UC1.AA43 UC1.AA44 UC1.AA46 UC1.AA47 UC1.AA49 UC1.AA50 UC1.AA51 UC1.AA55 UC1.AA57 UC1.AA59 UC1.AA61 UC1.AA63 UC1.AB13 UC1.AC15 UC1.AC16 UC1.AC18 UC1.AC19 UC1.AC21 UC1.AC27 UC1.AC33 UC1.AC36 UC1.AC40 UC1.AD13 UC1.AE2 UC1.AE4 UC1.AE8 UC1.AE10 UC1.AE21 UC1.AE30 UC1.AE43 UC1.AE44 UC1.AE46 UC1.AE47 UC1.AE49 UC1.AE50 UC1.AE51 UC1.AF13 UC1.AF15 UC1.AF16 UC1.AF21 UC1.AF23 UC1.AF33 UC1.AF36 UC1.AF40 UC1.AF54 UC1.AF56 UC1.AF58 UC1.AF60 UC1.AF62 UC1.AF64 UC1.AG59 UC1.AH16 UC1.AH23 UC1.AH24 UC1.AH27 UC1.AH30 UC1.AH33 UC1.AH36 UC1.AH40 UC1.AH43 UC1.AH44 UC1.AH46 UC1.AH47 UC1.AH49 UC1.AH50 UC1.AH51 UC1.AH54 UC1.AJ59 UC1.AK1 UC1.AK3 UC1.AK5 UC1.AK7 UC1.AK9 UC1.AK11 UC1.AK13 UC1.AK15 UC1.AK16 UC1.AK24 UC1.AK27 UC1.AK33 UC1.AK36 UC1.AK40 UC1.AK54 UC1.AL16 UC1.AL21 UC1.AL24 UC1.AL27 UC1.AL30 UC1.AL33 UC1.AL36 UC1.AL40 UC1.AL43 UC1.AL44 UC1.AL46 UC1.AL47 UC1.AL49 UC1.AL50 UC1.AL51 UC1.AL53 UC1.AL59 UC1.AM54 UC1.AM64 UC1.AN16 UC1.AN18 UC1.AN19 UC1.AN21 UC1.AN24 UC1.AN27 UC1.AN33 UC1.AN36 UC1.AN40 UC1.AN59 UC1.AP54 UC1.AP64 UC1.AR2 UC1.AR4 UC1.AR6 UC1.AR8 UC1.AR10 UC1.AR12 UC1.AR15 UC1.AR18 UC1.AR27 UC1.AR30 UC1.AR33 UC1.AR36 UC1.AR40 UC1.AR43 UC1.AR44 UC1.AR46 UC1.AR47 UC1.AR49 UC1.AR50 UC1.AR51 UC1.AR59 UC1.AT27 UC1.AT54 UC1.AU53 UC1.AU55 UC1.AU57 UC1.AU59 UC1.AU61 UC1.AU63 UC1.AV16 UC1.AV20 UC1.AV24 UC1.AV52 UC1.AV54 UC1.AW17 UC1.AW19 UC1.AW21 UC1.AW23 UC1.AW25 UC1.AY16 UC1.AY24 UC1.AY26 UC1.AY28 UC1.AY30 UC1.AY32 UC1.AY34 UC1.AY36 UC1.AY38 UC1.AY40 UC1.AY42 UC1.AY44 UC1.AY46 UC1.AY48 UC1.AY50 UC1.AY52 UC1.BA1 UC1.BA3 UC1.BA5 UC1.BA7 UC1.BA9 UC1.BA11 UC1.BA53 UC1.BA58 UC1.BA64 UC1.BB20 UC1.BB22 UC1.BB24 UC1.BB26 UC1.BB28 UC1.BB30 UC1.BB32 UC1.BB34 UC1.BB36 UC1.BB38 UC1.BB40 UC1.BB42 UC1.BB44 UC1.BB46 UC1.BB48 UC1.BB50 UC1.BB52 UC1.BB54 UC1.BB59 UC1.BC17 UC1.BC29 UC1.BC47 UC1.BD20 UC1.BD38 UC1.BD56 UC1.BD63 UC1.BE12 UC1.BE29 UC1.BE31 UC1.BE33 UC1.BE35 UC1.BE47 UC1.BF20 UC1.BF38 UC1.BF56 UC1.BF59 UC1.BG2 UC1.BG4 UC1.BG6 UC1.BG8 UC1.BG12 UC1.BG15 UC1.BG17 UC1.BG29 UC1.BG63 UC1.BH20 UC1.BH22 UC1.BH24 UC1.BH26 UC1.BH28 UC1.BH32 UC1.BH34 UC1.BH36 UC1.BH38 UC1.BH40 UC1.BH42 UC1.BH44 UC1.BH46 UC1.BH48 UC1.BH50 UC1.BH52 UC1.BH54 UC1.BH56 UC1.BH59 UC1.BJ29 UC1.BJ47 UC1.BJ62 UC1.BK20 UC1.BK38 UC1.BK56 UC1.BL1 UC1.BL8 UC1.BL29 UC1.BL31 UC1.BL33 UC1.BL35 UC1.BL47 UC1.BM11 UC1.BM14 UC1.BM16 UC1.BM18 UC1.BM20 UC1.BM38 UC1.BN6 UC1.BN29 UC1.BP1 UC1.BP22 UC1.BP28 UC1.BP30 UC1.BP36 UC1.BP38 UC1.BP44 UC1.BP46 UC1.BP52 UC1.BP54 UC1.BP60 UC1.BP62 UC1.C14 UC1.C40 UC1.D1 UC1.D6 UC1.D8 UC1.D10 UC1.D62 UC1.E14 UC1.E16 UC1.E18 UC1.E20 UC1.E22 UC1.E24 UC1.E26 UC1.E28 UC1.E30 UC1.E32 UC1.E34 UC1.E36 UC1.E38 UC1.E40 UC1.E42 UC1.E44 UC1.E46 UC1.E48 UC1.E50 UC1.E52 UC1.E54 UC1.E56 UC1.E59 UC1.F62 UC1.G14 UC1.J3 UC1.J5 UC1.J7 UC1.J9 UC1.J14 UC1.J62 UC1.K15 UC1.K17 UC1.K19 UC1.K21 UC1.K23 UC1.K25 UC1.K27 UC1.K29 UC1.K31 UC1.K33 UC1.K35 UC1.K37 UC1.K39 UC1.K41 UC1.K43 UC1.K45 UC1.K47 UC1.K49 UC1.K51 UC1.K53 UC1.K55 UC1.L14 UC1.L57 UC1.L59 UC1.L61 UC1.M3 UC1.N14 UC1.N16 UC1.N18 UC1.N20 UC1.N22 UC1.N24 UC1.N26 UC1.P54 UC1.R2 UC1.R4 UC1.R6 UC1.R8 UC1.R10 UC1.R18 UC1.R24 UC1.R30 UC1.R33 UC1.R36 UC1.R40 UC1.R43 UC1.R44 UC1.R46 UC1.R47 UC1.R49 UC1.R50 UC1.R55 UC1.T13 UC1.T18 UC1.T21 UC1.T23 UC1.T24 UC1.T33 UC1.T36 UC1.T40 UC1.T56 UC1.T58 UC1.T60 UC1.T62 UC1.T64 UC1.V13 UC1.V24 UC1.V27 UC1.V30 UC1.V33 UC1.V36 UC1.V40 UC1.V43 UC1.V44 UC1.V46 UC1.V47 UC1.V49 UC1.V50 UC1.V51 UC1.Y1 UC1.Y3 UC1.Y5 UC1.Y7 UC1.Y9 UC1.Y11 UC1.Y13 UC1.Y15 UC1.Y16 UC1.Y24 UC1.Y27 UC1.Y33 UC1.Y36 UC1.Y40 UC2.3 UH1.3 UH2.3 UH3.3 UH4.3 UH5.3 US1.14 US1.17 UV1.18 UV1.24 UV1.31 UV1.49 UV2.18 UV2.24 UV2.31 UV2.49 UV3.5 UV3.9 Y1.2 Y1.4 YH2.2 YH2.4
GND_SIGNAL: PC408.2 PC409.2 PC410.2 PC411.2 PC412.2 PC413.2 PC414.2 PC415.2 PC416.2 PC417.2 PC418.2 PR405.2 PR407.2 PR408.2 PR535.1 PU400.10 PU400.17
GNDA_CHG: PC524.2 PC525.1 PC528.1 PC533.2 PC534.2 PC535.1 PC537.2 PC540.2 PR506.1 PR516.2 PR525.2 PR532.2 PR533.1 PU500.29
VBUS_ACDIS#: PQ106.2 PR117.2 PR118.1
VBUS_ACOK: JIO4.43 PQ105.2 PQ106.3 PQ151.2 PR135.2 PR138.2 PU100.7 PU150.1 U34.N9
VBUS_SENSE: R210.1 R308.2 R485.2 UC1.AE6
VCC_D3.D6: PC1102.1 PR1558.2 PU1101.D3 PU1101.D6
VCCGT_SENSE: PC1119.1 PR1130.1 RC56.2 UC1.N52
VCCIO_SENSE: PR810.2 RC10.2 UC1.AT24
VCCIO_SENSE_R: PR808.2 PR810.1 PU808.5
VCCIO_VID0: PR822.1 PTC800.1(TP-1)
VCCIO_VID1: PR807.1 PTC801.1(TP-1)
VCCPLL_OC_EN: R464.2 U49.4
VCCPRIM_VID0: PR920.1 UC1.BA13
VCCPRIM_VID1: PR914.1 UC1.BB12
VCCSA_SENSE: PC1501.2 PR1100.2 RC21.2 UC1.M29
VCCSENSE: PR1127.2 PR1131.2 RC23.2 UC1.L34
VCCST_EN: R170.2 R465.2 U50.3
VCCSTG_EN: C339.1 R178.2 R184.2 R463.2 U48.4
VIN_0.85VS_VCCPIO: PC802.1 PC805.1 PC806.1 PL805.2 PL806.2 PU808.10 PU808.11 PU808.12
VIN_0.95V_PRIM: PC914.1 PC918.1 PC919.1 PL903.2 PU901.10 PU901.11 PU901.12
VSSGT_SENSE: PU1101.F2 RC57.2 UC1.P52
VSSIO_SENSE: PR811.2 RC9.1 UC1.AR24
VSSIO_SENSE_R: PR811.1 PR812.1 PU808.6
VSSSA_SENSE: PU1101.G5 RC20.2 UC1.N28
VSSSENSE: PU1101.F7 RC22.2 UC1.L32
40_DOCK_DET#: DA7.2 JIO4.40 R362.1 U34.K10
+AC_DOCK_IN: C363.1 C364.1 JIO4.1 PD105.2 R499.1
+AMP_AVDD1: CA25.1 CA27.1 LA3.1 UA2.42 UA2.43
+BAT_DOCK: C365.1 C366.1 JIO4.3 JIO4.4 JIO4.5 JIO4.6 JIO4.7 JIO4.8 JIO4.9 JIO4.10 JIO4.11 JIO4.12 JIO4.13 JIO4.14 JIO4.15 JIO4.16 JIO4.17 JIO4.18 JIO4.19 JIO4.20 JIO4.21 JIO4.22 PD104.2 PD500.2 PQ510.5 PR539.1 PR544.2
+BAT_TABLET: PC100.1 PD102.2 PD504.2 PL101.1 PL102.1 PQ500.5
+BATT: JT100.1 JT100.2 JT100.3 PC101.1 PC105.1 PL101.2 PL102.2
+BMC_LDO_PD: C207.1 U32.E1
+CHG_VIN: JPWR2.1 PC116.1 PC126.1 PC127.1 PD501.2 PQ104.1 PQ104.2 PQ104.3 PR116.1 PR500.1 PR503.1 PR505.1 PR541.1 PR542.1
+DCIN: PC527.2 PR504.2 PU500.28
+EDP_COM: RC70.1 UC1.A50
+INV_PWR_SRC: C302.1 PC402.1 PC403.1 PQ400.3 PR400.1 PR404.1 R421.2
+LCDVDD: C164.1 C165.1 C175.1 C176.1 C177.1 JEDP1.19 JEDP1.20 JEDP1.21 JEDP1.22 JEDP1.23 R411.1 R425.2
+LED_AN: C160.1 C161.1 JEDP1.39 JEDP1.40 JEDP1.41 JEDP1.42 PC400.1 PC401.1 PC405.1 PC406.1 PC411.1 PD400.1 PU400.4
+PWR_SRC_AC: PC500.1 PC501.1 PC502.1 PC503.1 PC504.1 PC505.1 PC506.1 PC507.1 PC508.1 PL500.2 PQ501.2 PQ501.3 PQ501.4 PQ501.10
+RTCBATT: JRTC1.1 RTCR1.2
+RTCVCC: CC1.1 CC2.1 CH24.1 CLRP1.1 D9.1 D10.1 R16.1 RA18.2 RH7.1 RH23.1 RH25.1 RTCD1.1 RTCR1.1 UC1.AR19 UC1.AT19
+RTCVCC_EC: C24.1 R16.2 R17.2 R334.1 U34.B2
+SIM_PWR: JIO1.50 JNGFF1.28
+SYS_DOCK: PC542.1 PQ502.5 PQ503.5 PQ509.5 PR530.2
+V_DDR_0_DQ_VREF: C76.1 R66.1 UC1.AN53
+V_DDR_1_DQ_VREF: C86.1 R75.1 UC1.AW53
+V_DDR_VREF_CA: C124.1 R120.1 UC1.AR53
+VDISPLAY_VCC: CX17.1 CX18.1 JHDMI1.19 RX1.2 RX2.2 UV3.7 UV3.8
+VR_CAP: C250.1 U34.H1
AC_PRESENT: RH14.2 T9.1(TP-1) U34.N8
AC_PRESENT_R: RH14.1 RH15.2 UC1.BD14
ACAV_IN: PR512.1 U34.C1
ACCEL_INT1#: JIO1.22 UC1.BF11
ACCEL_INT2#: JIO1.24 UC1.BD2
ADDR_EQ: RV4.2 RV6.2 UV1.3
ALERT#: PR1115.2 PU1101.E5
ALWON: D1.2 PR607.1 PR608.1 PR611.1 R2.2 R3.2
AMP_AGND: CA20.2 CA21.2 CA22.2 CA26.2 CA28.2 LA5.2 LA7.2 UA2.16 UA2.20
AMP_ASEL: RA37.1 RA38.2 UA2.14
AMP_G0: R158.2 R159.2 U21.6
AMP_G1: R156.2 R157.2 U21.7
AMP_I2S_BCLK: CA47.1 RA50.2 UA2.6
AMP_I2S_BCLK_R: RA50.1 UA3.56
AMP_I2S_MCLK: CA50.1 RA51.2 UA2.5
AMP_I2S_MCLK_R: RA16.1 RA51.1 UA3.55
AMP_LDO_A1.5V: CA21.1 CA26.1 UA2.18
ANA2_EN: U6.C4 U9.5
AUDIO_I2C_SW: RA30.1 U34.K11 UA1.1 UA1.5
AUDIO_IRQ: RA9.1 RA17.2 UA3.6
AUDIO_PWR_EN: R141.1 UC1.BL3
AUDIO_PWR_EN_R: R140.2 R141.2 R144.2 R145.2 U15.3 U15.5 U20.5
AUX_EN_WLAN: D4.3 U34.L13
B1-4_PHASE_GT: PC1123.1 PL1103.2 PR1137.2 PR1155.1 PU1101.B1 PU1101.B2 PU1101.B3 PU1101.B4
B4_SLP_S0#: R349.1 UC1.BC11
B5-8_PHASE_IA: PC1124.2 PL1104.1 PR1138.1 PR1153.1 PU1101.B5 PU1101.B6 PU1101.B7 PU1101.B8
B+: C168.1 C294.1 CZ1.1 JUSH1.1 PC509.1 PC510.1 PC511.1 PC512.1 PC513.1 PC514.1 PC515.1 PC516.1 PC517.1 PC518.1 PC519.1 PC520.1 PC521.1 PC522.1 PC541.1 PJP1100.1 PL501.2 PL600.1 PL602.1 PL605.1 PL700.1 PL803.1 PL806.1 PL900.1 PR511.1 PR1500.1 U41.3 U41.4
B+_1.0V: PC812.1 PC813.1 PC814.1 PL803.2 PU801.8
B+_5V: PC613.1 PC616.1 PC617.1 PC618.1 PL602.2 PL605.2 PR1418.1 PR1419.1 PU601.1
BASE_DDC_CLK: RV7.2 UV1.33
BASE_DDC_DTA: RV5.2 UV1.34
BASE_DP_AUXN: CV13.2 UV1.29
BASE_DP_AUXP: CV12.2 UV1.30
BASE_DP_CAD: R468.1 U47.33 UV1.8
BASE_DP_CLK_AUXP: CV12.1 R462.2 RV7.1
BASE_DP_CLK_AUXP_R: R458.1 R462.1 U47.28
BASE_DP_DAT_AUXN: CV13.1 R467.2 RV5.1
BASE_DP_DAT_AUXN_R: R466.1 R467.1 U47.29
BASE_DP_HPD: U47.38 UV1.9
BASE_DP_N0: CV7.1 U47.39
BASE_DP_N0_C: CV7.2 UV1.39
BASE_DP_N1: CV5.1 U47.36
BASE_DP_N1_C: CV5.2 UV1.42
BASE_DP_N2: CV3.1 U47.34
BASE_DP_N2_C: CV3.2 UV1.45
BASE_DP_N3: CV1.1 U47.31
BASE_DP_N3_C: CV1.2 UV1.48
BASE_DP_P0: CV8.1 U47.40
BASE_DP_P0_C: CV8.2 UV1.38
BASE_DP_P1: CV6.1 U47.37
BASE_DP_P1_C: CV6.2 UV1.41
BASE_DP_P2: CV4.1 U47.35
BASE_DP_P2_C: CV4.2 UV1.44
BASE_DP_P3: CV2.1 U47.32
BASE_DP_P3_C: CV2.2 UV1.47
BASE_SMB_ALERT#: JIO4.46 R318.1 U34.B5
BASE_SMBCLK: JIO4.50 R331.1 U34.A9
BASE_SMBDAT: JIO4.48 R319.1 U34.D8
BAT_TAB_EN#: PQ506.2 PQ511.2 PR544.1 PR557.1 PU200.2 U34.K9
BAT_TAB_OFF: PQ505.2 PR558.2 U34.N11
BATDRV#: PQ503.4 PR515.2 PR526.2
BATLOW#: RH58.2 UC1.BD16
BATT_VREF: PC1414.2 PR1422.1 PR1423.2 PU1501.2 PU1501.6
BEEP: RA57.1 U34.M8
BGT: PR1134.2 PU1101.D2
BIA_PWM_EC: D12.2 U34.M10
BOARD_ID: C249.1 R340.2 U34.G1
BQ24777_CSIN: PR500.3 PR502.1
BQ24777_CSIP: PR500.2 PR501.1
BQ24777_CSON: PC536.2 PC537.1 PR511.3 PU500.19
BQ24777_CSOP: PC535.2 PC536.1 PR511.2 PU500.20
BQ24777_REGN: PC526.1 PR509.1 PR523.2 PR529.1 PU500.24
BST_1.0V: PR816.1 PU801.6
BT_OFF#_R: D7.1 JNGFF3.54 R104.1
BT_ON/OFF#: D7.3 UC1.AA10
BT_RADIO_DIS#: D7.2 U34.L11
CAD_SNK: RV16.2 U34.K13
CAM_LED#: Q8.3 R62.1
CEXT: C307.1 U47.17
CFG0: RC127.1 UC1.G52
CFG1: JXDP1.11 UC1.F53
CFG2: JXDP1.15 UC1.J52
CFG3: JXDP1.17 RC63.1 UC1.H53
CFG4: JXDP1.27 RC83.2 UC1.H55
CFG5: JXDP1.29 UC1.D55
CFG6: JXDP1.33 UC1.C56
CFG7: JXDP1.35 UC1.F55
CFG8: JXDP1.10 UC1.D61
CFG9: JXDP1.12 UC1.G58
CFG10: JXDP1.16 UC1.D57
CFG11: JXDP1.18 UC1.F61
CFG12: JXDP1.28 UC1.J60
CFG13: JXDP1.30 UC1.J58
CFG14: JXDP1.34 UC1.H61
CFG15: JXDP1.36 UC1.H59
CFG16: JXDP1.6 UC1.J54
CFG17: JXDP1.4 UC1.G54
CFG18: JXDP1.24 UC1.G56
CFG19: JXDP1.22 UC1.J56
CFG_RCOMP: RC81.1 UC1.A54
CHG_BTS: PR507.1 PU500.25
CHG_BTS_C: PC529.1 PR507.2
CHG_CELL: PR529.2 PR532.1 PU500.16
CHG_LED#: JIO1.12 U34.E3
CHG_LGATE: PQ501.8 PU500.23
CHG_SMBCLK: PR510.1 R320.1 U34.B8
CHG_SMBCLK_R: PR510.2 PU500.12
CHG_SMBDAT: PR508.1 R321.1 U34.C8
CHG_SMBDAT_R: PR508.2 PU500.11
CHG_SW: PC529.2 PL501.1 PQ501.9 PR514.1 PU500.27
CHG_UGATE: PQ501.1 PU500.26
CK_XDP: JXDP1.40 UC1.G34
CK_XDP#: JXDP1.42 UC1.J34
CL_CLK: JNGFF3.42 UC1.F12
CL_DATA: JNGFF3.40 UC1.D12
CL_RST#: JNGFF3.38 UC1.B12
CLK_LPC_DEBUG: CH6.1 JLPDE1.10 RH27.2
CLK_PCI_MEC: CH12.1 R356.1 RH69.2 U34.N6
CLK_PCIE2: JIO1.37 UC1.G36
CLK_PCIE2#: JIO1.39 UC1.J36
CLK_PCIE3: L23.4 R404.1 UC1.G38
CLK_PCIE3#: L23.1 R403.1 UC1.J38
CLK_PCIE3#_R: JNGFF2.53 L23.2 R403.2
CLK_PCIE3_R: JNGFF2.55 L23.3 R404.2
CLK_PCIE4: L4.1 R37.1 UC1.F37
CLK_PCIE4#: L4.4 R32.1 UC1.H37
CLK_PCIE4#_R: JNGFF3.49 L4.3 R32.2
CLK_PCIE4_R: JNGFF3.47 L4.2 R37.2
CLK_REQ2#: JIO1.18 RH66.2 U52.2 UC1.BD10
CLK_REQ3#: JNGFF2.52 RH44.2 UC1.AV5
CLK_REQ4#: JNGFF3.53 RH43.2 UC1.AV7
CLK_SMB: JT100.4 PD100.2 PR106.1
CLKOUT_LPC0: RH69.1 UC1.BJ10
CLKOUT_LPC1: RH27.1 UC1.BF5
CLKRUN#: RH63.1 U34.J3 UC1.BH11
CMSRC: PR503.2 PU500.3
CODEC_MUTE#: DA4.1 RA23.1 RA49.1 RA52.2 UA2.11 UA3.52
CONTACTLESS_DET#: JUSH1.23 RH89.1 UC1.AF11
CORE_FB: C39.1 L6.2 R55.1 U6.H6
CORE_SW: L6.1 U6.G7
CPU_B+: PC1104.1 PC1105.1 PC1106.1 PC1107.1 PC1109.1 PC1133.1 PC1134.1 PC1135.1 PC1136.1 PC1137.1 PC1139.1 PC1142.1 PC1146.1 PC1147.1 PC1148.1 PC1151.1 PJP1100.2 PQ1100.2 PQ1100.3 PQ1100.4 PQ1100.10 PU1101.C1 PU1101.C2 PU1101.C3 PU1101.C4 PU1101.C5 PU1101.C6 PU1101.C7 PU1101.C8
CPU_POPIRCOMP: RC35.1 UC1.BN17
CPU_XDP_TCK: RC92.1 RC93.1 UC1.D53
CPU_XDP_TDI: RC97.2 RC109.1 UC1.C54
CPU_XDP_TDO: RC95.2 RC116.1 UC1.G48
CPU_XDP_TMS: RC105.1 RC119.2 UC1.C59
CPU_XDP_TRST#: RC101.1 RC104.1 UC1.F47
CSI2_COMP: RC65.2 UC1.A11
D1_PVCC_GT: PC1140.1 PR1557.1 PU1101.D1
D7_BOOT_IA: PR1135.1 PU1101.D7
D8_PVCC_IA: PC1141.1 PR1556.1 PU1101.D8
DAT_SMB: JT100.5 PD100.3 PR108.1
DCPDSW_1P0: CC108.1 UC1.AL2 UC1.AM1
DCTRL: PC408.1 PR403.2 PR405.1 PU400.11
DDCBUF: R202.2 R203.2 U25.14
DDR_0_DQ_VREF: C71.1 R64.2 R66.2 R71.1 U35.H17 U35.U8
DDR_1_DQ_VREF: C226.1 R74.1 R75.2 R76.2 U33.H17 U33.U8
DDR_CHA_EN: RH40.1 RH47.1 UC1.AC6
DDR_CHB_EN: RH45.1 RH46.1 UC1.AB5
DDR_RCOMP_0: RC46.1 UC1.BF64
DDR_RCOMP_1: RC45.1 UC1.BJ64
DDR_RCOMP_2: RC47.1 UC1.BC64
DDR_VREF_CA: C122.1 C268.1 R118.1 R119.2 R120.2 U33.A10 U33.J1 U35.A10 U35.J1
DDR_VTT_CNTL: UC1.BN47 UC2.2
DEBUG_CTL1: R251.2 U32.E4
DEBUG_CTL2: R246.2 U32.D5
DEBUG_UART_TX: JDEG1.9 UC1.AC4
DEVSLP0: JNGFF2.38 T33.1(TP-1) UC1.F10
DISPOFF#: D37.1 PR406.1 R419.1
DMIC_CLK1: CA49.1 MIC1.3 MIC2.3 RA48.2 TC27.1(TP-1)
DMIC_CLK1_R: RA48.1 UA3.53
DMIC_CLK2: CA6.1 JDMIC1.3 JUFC.29 RA13.2 TC26.1(TP-1)
DMIC_CLK2_R: RA13.1 UA3.2
DMIC_DATA1: CA48.1 MIC1.4 MIC2.4 RA47.2 TC28.1(TP-1)
DMIC_DATA1_R: RA47.1 UA3.54
DMIC_DATA2: CA4.1 JDMIC1.2 JUFC.28 RA11.2 TC25.1(TP-1)
DMIC_DATA2_R: RA11.1 UA3.4
DOCK_PWR_EN: R155.2 R163.1 U17.3 U34.M5
DP_CFG0: R444.2 U47.59
DP_CFG1: R446.2 U47.58
DP_LANE_CNT_EC: U34.H11 UC1.M5
DP_LANE_CNT_PD: R303.2 UC1.L4
DP_MUX_SEL: U34.N10 U47.18
DP_RP_RST#: CV9.1 RV3.2 UV1.35
DP_USBC_HPD: RC73.2 UC1.C11 UV2.9
DPRP_ADDR: RV25.2 RV26.2 UV2.3
DPRP_CFG0: RV18.2 RV19.2 UV2.5
DPRP_CFG1: RV27.2 RV28.2 UV2.40
DPRP_PEQ: RV23.2 RV24.2 UV2.4
DPRP_RST#: CV33.1 RV29.2 UV2.35
